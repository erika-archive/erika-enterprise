  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC8000+752.)++0x03
  line.long    0x00 "MB39,Message Buffer 39"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC8000+752.)&0x00200000)==0x00200000
group.long ((0xFFFC8000+752.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 39"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC8000+752.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 39"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC8000+752.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 39"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 39"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC8000+768.)++0x03
  line.long    0x00 "MB40,Message Buffer 40"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC8000+768.)&0x00200000)==0x00200000
group.long ((0xFFFC8000+768.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 40"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC8000+768.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 40"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC8000+768.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 40"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 40"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC8000+784.)++0x03
  line.long    0x00 "MB41,Message Buffer 41"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC8000+784.)&0x00200000)==0x00200000
group.long ((0xFFFC8000+784.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 41"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC8000+784.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 41"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC8000+784.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 41"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 41"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC8000+800.)++0x03
  line.long    0x00 "MB42,Message Buffer 42"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC8000+800.)&0x00200000)==0x00200000
group.long ((0xFFFC8000+800.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 42"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC8000+800.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 42"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC8000+800.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 42"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 42"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC8000+816.)++0x03
  line.long    0x00 "MB43,Message Buffer 43"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC8000+816.)&0x00200000)==0x00200000
group.long ((0xFFFC8000+816.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 43"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC8000+816.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 43"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC8000+816.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 43"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 43"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC8000+832.)++0x03
  line.long    0x00 "MB44,Message Buffer 44"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC8000+832.)&0x00200000)==0x00200000
group.long ((0xFFFC8000+832.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 44"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC8000+832.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 44"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC8000+832.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 44"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 44"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC8000+848.)++0x03
  line.long    0x00 "MB45,Message Buffer 45"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC8000+848.)&0x00200000)==0x00200000
group.long ((0xFFFC8000+848.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 45"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC8000+848.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 45"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC8000+848.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 45"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 45"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC8000+864.)++0x03
  line.long    0x00 "MB46,Message Buffer 46"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC8000+864.)&0x00200000)==0x00200000
group.long ((0xFFFC8000+864.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 46"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC8000+864.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 46"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC8000+864.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 46"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 46"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC8000+880.)++0x03
  line.long    0x00 "MB47,Message Buffer 47"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC8000+880.)&0x00200000)==0x00200000
group.long ((0xFFFC8000+880.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 47"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC8000+880.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 47"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC8000+880.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 47"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 47"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC8000+896.)++0x03
  line.long    0x00 "MB48,Message Buffer 48"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC8000+896.)&0x00200000)==0x00200000
group.long ((0xFFFC8000+896.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 48"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC8000+896.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 48"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC8000+896.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 48"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 48"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC8000+912.)++0x03
  line.long    0x00 "MB49,Message Buffer 49"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC8000+912.)&0x00200000)==0x00200000
group.long ((0xFFFC8000+912.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 49"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC8000+912.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 49"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC8000+912.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 49"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 49"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC8000+928.)++0x03
  line.long    0x00 "MB50,Message Buffer 50"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC8000+928.)&0x00200000)==0x00200000
group.long ((0xFFFC8000+928.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 50"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC8000+928.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 50"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC8000+928.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 50"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 50"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC8000+944.)++0x03
  line.long    0x00 "MB51,Message Buffer 51"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC8000+944.)&0x00200000)==0x00200000
group.long ((0xFFFC8000+944.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 51"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC8000+944.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 51"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC8000+944.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 51"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 51"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC8000+960.)++0x03
  line.long    0x00 "MB52,Message Buffer 52"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC8000+960.)&0x00200000)==0x00200000
group.long ((0xFFFC8000+960.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 52"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC8000+960.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 52"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC8000+960.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 52"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 52"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC8000+976.)++0x03
  line.long    0x00 "MB53,Message Buffer 53"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC8000+976.)&0x00200000)==0x00200000
group.long ((0xFFFC8000+976.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 53"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC8000+976.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 53"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC8000+976.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 53"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 53"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC8000+992.)++0x03
  line.long    0x00 "MB54,Message Buffer 54"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC8000+992.)&0x00200000)==0x00200000
group.long ((0xFFFC8000+992.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 54"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC8000+992.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 54"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC8000+992.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 54"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 54"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC8000+1008.)++0x03
  line.long    0x00 "MB55,Message Buffer 55"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC8000+1008.)&0x00200000)==0x00200000
group.long ((0xFFFC8000+1008.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 55"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC8000+1008.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 55"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC8000+1008.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 55"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 55"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC8000+1024.)++0x03
  line.long    0x00 "MB56,Message Buffer 56"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC8000+1024.)&0x00200000)==0x00200000
group.long ((0xFFFC8000+1024.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 56"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC8000+1024.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 56"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC8000+1024.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 56"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 56"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC8000+1040.)++0x03
  line.long    0x00 "MB57,Message Buffer 57"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC8000+1040.)&0x00200000)==0x00200000
group.long ((0xFFFC8000+1040.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 57"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC8000+1040.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 57"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC8000+1040.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 57"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 57"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC8000+1056.)++0x03
  line.long    0x00 "MB58,Message Buffer 58"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC8000+1056.)&0x00200000)==0x00200000
group.long ((0xFFFC8000+1056.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 58"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC8000+1056.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 58"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC8000+1056.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 58"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 58"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC8000+1072.)++0x03
  line.long    0x00 "MB59,Message Buffer 59"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC8000+1072.)&0x00200000)==0x00200000
group.long ((0xFFFC8000+1072.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 59"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC8000+1072.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 59"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC8000+1072.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 59"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 59"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC8000+1088.)++0x03
  line.long    0x00 "MB60,Message Buffer 60"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC8000+1088.)&0x00200000)==0x00200000
group.long ((0xFFFC8000+1088.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 60"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC8000+1088.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 60"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC8000+1088.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 60"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 60"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC8000+1104.)++0x03
  line.long    0x00 "MB61,Message Buffer 61"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC8000+1104.)&0x00200000)==0x00200000
group.long ((0xFFFC8000+1104.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 61"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC8000+1104.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 61"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC8000+1104.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 61"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 61"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC8000+1120.)++0x03
  line.long    0x00 "MB62,Message Buffer 62"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC8000+1120.)&0x00200000)==0x00200000
group.long ((0xFFFC8000+1120.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 62"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC8000+1120.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 62"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC8000+1120.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 62"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 62"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC8000+1136.)++0x03
  line.long    0x00 "MB63,Message Buffer 63"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC8000+1136.)&0x00200000)==0x00200000
group.long ((0xFFFC8000+1136.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 63"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC8000+1136.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 63"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC8000+1136.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 63"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 63"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""
tree.end


tree.end

endif

sif (cpu()=="MPC5566")||(cpu()=="MPC5567")||(CPUIS("MPC5674*"))

tree "FlexCAN D"

group.long 0xFFFCC000++0x03
  line.long    0x00 "MCR,Module Configuration Register"
  bitfld.long  0x00 31.                  "MDIS     ,Module disable" "0,1"
  bitfld.long  0x00 30.                  "  FRZ ,Freeze enable" "0,1"
  bitfld.long  0x00 28.                  "      HALT    ,Halt FlexCAN" "0,1"
  bitfld.long  0x00 27.                  "    NOTRDY ,FlexCAN2 not ready" "0,1"
  bitfld.long  0x00 25.                  "  SOFTRST ,Soft reset" "0,1"
  bitfld.long  0x00 24.                  "  FRZACK ,Freeze mode acknowledge" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 21.                  "  WRNEN    ,Warning interrupt enable" "0,1"
  bitfld.long  0x00 20.                  "  MDISACK ,Low power mode acknowledge" "0,1"
  bitfld.long  0x00 17.                  "  SRXDIS  ,This bit defines whether FlexCAN is allowed to receive frames transmitted by itself" "0,1"
  bitfld.long  0x00 16.                  "    MBFEN  ,Message buffer filter enable" "0,1"
  hexmask.byte 0x03 00.--06. 1.          "  MAXMB  ,Maximum number of message buffers"
TEXTLINE ""
 

group.long (0xFFFCC000+0x04)++0x03
  line.long    0x00 "CR,Control Register"
  hexmask.byte 0x00 00.--07. 1.          "PRESDIV ,Prescaler division factor"
  bitfld.long  0x00 22.--23.             "  RJW ,Resync jump width" "0,1,2,3"
  bitfld.long  0x00 19.--21.             "      PSEG1   ,Phase segment 1" "0,1,2,3,4,5,6,7"
  bitfld.long  0x00 16.--18.             "    PSEG2  ,Phase segment 2" "0,1,2,3,4,5,6,7"
  bitfld.long  0x00 15.                  "  BOFFMSK ,Bus off mask" "0,1"
  bitfld.long  0x00 14.                  "  ERRMSK ,Error mask" "0,1"
  bitfld.long  0x00 13.                  "  CLK_SRC ,CAN engine clock source" "osc_clk,bus_clk"
TEXTLINE "                "
  bitfld.long  0x00 12.                  "  LPB      ,Loop back" "0,1"
  bitfld.long  0x00 07.                  "  SMP ,Sampling mode" "one,three"
  bitfld.long  0x00 06.                  "  BOFFREC ,Bus off recovery mode" "ena,dis"
  bitfld.long  0x00 05.                  "  TSYN   ,Timer sync mode" "0,1"
  bitfld.long  0x00 04.                  "  LBUF    ,Lowest buffer transmitted first" "0,1"
  bitfld.long  0x00 03.                  "  LOM    ,Listen-only mode" "0,1"
  bitfld.long  0x00 00.--02.             "  PROPSEG ,Propagation segment" "0,1,2,3,4,5,6,7"
TEXTLINE ""

group.long (0xFFFCC000+0x08)++0x03
  line.long    0x00 "TIMER,Free Running Timer"
TEXTLINE ""

group.long (0xFFFCC000+0x10)++0x03
  line.long    0x00 "RXGMASK,RX Global Mask"
  bitfld.long  0x00 28.              "MI28       ,ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
  
  TEXTLINE "                "

  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"

TEXTLINE ""

group.long (0xFFFCC000+0x14)++0x03
  line.long    0x00 "RX14MASK,RX 14 Global Mask"
  bitfld.long  0x00 28.              "MI28       ,ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
  
  TEXTLINE "                "

  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""

group.long (0xFFFCC000+0x18)++0x03
  line.long    0x00 "RX15MASK,RX 15 Global Mask"
  bitfld.long  0x00 28.              "MI28       ,ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
  
  TEXTLINE "                "

  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""

group.long (0xFFFCC000+0x1C)++0x03
  line.long    0x00 "ECR,Error Counter Register"
  hexmask.byte 0x02 00.--07. 1.          "RXECTR ,Receive Error Counter"
  hexmask.byte 0x03 00.--07. 1.          "  TXECTR ,Transmit Error Counter"
TEXTLINE ""

group.long (0xFFFCC000+0x20)++0x03
  line.long    0x00 "ESR,Error and Status Register"
  bitfld.long  0x00 15.                  "BIT1ERR ,Bit 1 error" "0,1"
  bitfld.long  0x00 14.                  "  BIT0ERR ,Bit 0 error" "0,1"
  bitfld.long  0x00 13.                  "  ACKERR ,Acknowledge error." "0,1"
  bitfld.long  0x00 12.                  "   CRCERR   ,Cyclic redundancy code error" "0,1"
  bitfld.long  0x00 11.                  "  FRMERR ,Form error" "0,1"
  bitfld.long  0x00 10.                  "  STFERR ,Stuffing error" "0,1"
  bitfld.long  0x00 09.                  "  TXWRN  ,TX error counter" "0,1"
  TEXTLINE "                "
  bitfld.long  0x00 08.                  "  RXWRN   ,RX error counter" "0,1"
  bitfld.long  0x00 07.                  "  IDLE    ,CAN bus IDLE state" "0,1"
  bitfld.long  0x00 06.                  "  TXRX   ,Current FlexCAN2 status" "RX,TX"
  bitfld.long  0x00 04.--05.             "  FLTCONF  ,Fault confinement state" "err act,err pass,bus off,bus off"
  eventfld.long  0x00 02.                  "  BOFFINT   ,Bus off interrupt" "0,1"
  eventfld.long  0x00 01.                  "  ERRINT ,Error interrupt" "0,1"
TEXTLINE ""


group.long (0xFFFCC000+0x24)++0x03
  line.long    0x00 "IMRH,Interrupt masks high register"
  bitfld.long  0x00 31.              "BUF63-60 ,Message Buffer 63 mask" "0,1"
  bitfld.long  0x00 30.              ",Message Buffer 62 mask" "0,1"
  bitfld.long  0x00 29.              ",Message Buffer 61 mask" "0,1"
  bitfld.long  0x00 28.              ",Message Buffer 60 mask" "0,1"

  bitfld.long  0x00 27.              "  BUF59-56 ,Message Buffer 59 mask" "0,1"
  bitfld.long  0x00 26.              ",Message Buffer 58 mask" "0,1"
  bitfld.long  0x00 25.              ",Message Buffer 57 mask" "0,1"
  bitfld.long  0x00 24.              ",Message Buffer 56 mask" "0,1"

  bitfld.long  0x00 23.              "  BUF55-52 ,Message Buffer 55 mask" "0,1"
  bitfld.long  0x00 22.              ",Message Buffer 54 mask" "0,1"
  bitfld.long  0x00 21.              ",Message Buffer 53 mask" "0,1"
  bitfld.long  0x00 20.              ",Message Buffer 52 mask" "0,1"

  bitfld.long  0x00 19.              "  BUF51-48 ,Message Buffer 51 mask" "0,1"
  bitfld.long  0x00 18.              ",Message Buffer 50 mask" "0,1"
  bitfld.long  0x00 17.              ",Message Buffer 49 mask" "0,1"
  bitfld.long  0x00 16.              ",Message Buffer 48 mask" "0,1"
  
  TEXTLINE "                "

  bitfld.long  0x00 15.              "  BUF47-44 ,Message Buffer 47 mask" "0,1"
  bitfld.long  0x00 14.              ",Message Buffer 46 mask" "0,1"
  bitfld.long  0x00 13.              ",Message Buffer 45 mask" "0,1"
  bitfld.long  0x00 12.              ",Message Buffer 44 mask" "0,1"
  
  bitfld.long  0x00 11.              "  BUF43-40 ,Message Buffer 43 mask" "0,1"
  bitfld.long  0x00 10.              ",Message Buffer 42 mask" "0,1"
  bitfld.long  0x00 09.              ",Message Buffer 41 mask" "0,1"
  bitfld.long  0x00 08.              ",Message Buffer 40 mask" "0,1"
  
  bitfld.long  0x00 07.              "  BUF39-36 ,Message Buffer 39 mask" "0,1"
  bitfld.long  0x00 06.              ",Message Buffer 38 mask" "0,1"
  bitfld.long  0x00 05.              ",Message Buffer 37 mask" "0,1"
  bitfld.long  0x00 04.              ",Message Buffer 36 mask" "0,1"

  bitfld.long  0x00 03.              "  BUF35-32 ,Message Buffer 35 mask" "0,1"
  bitfld.long  0x00 02.              ",Message Buffer 34 mask" "0,1"
  bitfld.long  0x00 01.              ",Message Buffer 33 mask" "0,1"
  bitfld.long  0x00 00.              ",Message Buffer 32 mask" "0,1"
  
TEXTLINE ""

group.long (0xFFFCC000+0x28)++0x03
  line.long    0x00 "IMRL,Interrupt masks low register"
  bitfld.long  0x00 31.              "BUF31-28 ,Message Buffer 31 mask" "0,1"
  bitfld.long  0x00 30.              ",Message Buffer 30 mask" "0,1"
  bitfld.long  0x00 29.              ",Message Buffer 29 mask" "0,1"
  bitfld.long  0x00 28.              ",Message Buffer 28 mask" "0,1"

  bitfld.long  0x00 27.              "  BUF27-24 ,Message Buffer 27 mask" "0,1"
  bitfld.long  0x00 26.              ",Message Buffer 26 mask" "0,1"
  bitfld.long  0x00 25.              ",Message Buffer 25 mask" "0,1"
  bitfld.long  0x00 24.              ",Message Buffer 24 mask" "0,1"

  bitfld.long  0x00 23.              "  BUF23-20 ,Message Buffer 23 mask" "0,1"
  bitfld.long  0x00 22.              ",Message Buffer 22 mask" "0,1"
  bitfld.long  0x00 21.              ",Message Buffer 21 mask" "0,1"
  bitfld.long  0x00 20.              ",Message Buffer 20 mask" "0,1"

  bitfld.long  0x00 19.              "  BUF19-16 ,Message Buffer 19 mask" "0,1"
  bitfld.long  0x00 18.              ",Message Buffer 18 mask" "0,1"
  bitfld.long  0x00 17.              ",Message Buffer 17 mask" "0,1"
  bitfld.long  0x00 16.              ",Message Buffer 16 mask" "0,1"
  
  TEXTLINE "                "

  bitfld.long  0x00 15.              "  BUF15-12 ,Message Buffer 15 mask" "0,1"
  bitfld.long  0x00 14.              ",Message Buffer 14 mask" "0,1"
  bitfld.long  0x00 13.              ",Message Buffer 13 mask" "0,1"
  bitfld.long  0x00 12.              ",Message Buffer 12 mask" "0,1"
  
  bitfld.long  0x00 11.              "  BUF11-08 ,Message Buffer 11 mask" "0,1"
  bitfld.long  0x00 10.              ",Message Buffer 10 mask" "0,1"
  bitfld.long  0x00 09.              ",Message Buffer 09 mask" "0,1"
  bitfld.long  0x00 08.              ",Message Buffer 08 mask" "0,1"
  
  bitfld.long  0x00 07.              "  BUF07-04 ,Message Buffer 07 mask" "0,1"
  bitfld.long  0x00 06.              ",Message Buffer 06 mask" "0,1"
  bitfld.long  0x00 05.              ",Message Buffer 05 mask" "0,1"
  bitfld.long  0x00 04.              ",Message Buffer 04 mask" "0,1"

  bitfld.long  0x00 03.              "  BUF03-00 ,Message Buffer 03 mask" "0,1"
  bitfld.long  0x00 02.              ",Message Buffer 02 mask" "0,1"
  bitfld.long  0x00 01.              ",Message Buffer 01 mask" "0,1"
  bitfld.long  0x00 00.              ",Message Buffer 00 mask" "0,1"
  
TEXTLINE ""


group.long (0xFFFCC000+0x2C)++0x03
  line.long    0x00 "IFRH,Interrupt flags high register"
  eventfld.long  0x00 31.              "BUF63-60 ,Message Buffer 63 flag" "0,1"
  eventfld.long  0x00 30.              ",Message Buffer 62 flag" "0,1"
  eventfld.long  0x00 29.              ",Message Buffer 61 flag" "0,1"
  eventfld.long  0x00 28.              ",Message Buffer 60 flag" "0,1"

  eventfld.long  0x00 27.              "  BUF59-56 ,Message Buffer 59 flag" "0,1"
  eventfld.long  0x00 26.              ",Message Buffer 58 flag" "0,1"
  eventfld.long  0x00 25.              ",Message Buffer 57 flag" "0,1"
  eventfld.long  0x00 24.              ",Message Buffer 56 flag" "0,1"

  eventfld.long  0x00 23.              "  BUF55-52 ,Message Buffer 55 flag" "0,1"
  eventfld.long  0x00 22.              ",Message Buffer 54 flag" "0,1"
  eventfld.long  0x00 21.              ",Message Buffer 53 flag" "0,1"
  eventfld.long  0x00 20.              ",Message Buffer 52 flag" "0,1"

  eventfld.long  0x00 19.              "  BUF51-48 ,Message Buffer 51 flag" "0,1"
  eventfld.long  0x00 18.              ",Message Buffer 50 flag" "0,1"
  eventfld.long  0x00 17.              ",Message Buffer 49 flag" "0,1"
  eventfld.long  0x00 16.              ",Message Buffer 48 flag" "0,1"
  
  TEXTLINE "                "

  eventfld.long  0x00 15.              "  BUF47-44 ,Message Buffer 47 flag" "0,1"
  eventfld.long  0x00 14.              ",Message Buffer 46 flag" "0,1"
  eventfld.long  0x00 13.              ",Message Buffer 45 flag" "0,1"
  eventfld.long  0x00 12.              ",Message Buffer 44 flag" "0,1"
  
  eventfld.long  0x00 11.              "  BUF43-40 ,Message Buffer 43 flag" "0,1"
  eventfld.long  0x00 10.              ",Message Buffer 42 flag" "0,1"
  eventfld.long  0x00 09.              ",Message Buffer 41 flag" "0,1"
  eventfld.long  0x00 08.              ",Message Buffer 40 flag" "0,1"
  
  eventfld.long  0x00 07.              "  BUF39-36 ,Message Buffer 39 flag" "0,1"
  eventfld.long  0x00 06.              ",Message Buffer 38 flag" "0,1"
  eventfld.long  0x00 05.              ",Message Buffer 37 flag" "0,1"
  eventfld.long  0x00 04.              ",Message Buffer 36 flag" "0,1"

  eventfld.long  0x00 03.              "  BUF35-32 ,Message Buffer 35 flag" "0,1"
  eventfld.long  0x00 02.              ",Message Buffer 34 flag" "0,1"
  eventfld.long  0x00 01.              ",Message Buffer 33 flag" "0,1"
  eventfld.long  0x00 00.              ",Message Buffer 32 flag" "0,1"
  
TEXTLINE ""

group.long (0xFFFCC000+0x30)++0x03
  line.long    0x00 "IFRL,Interrupt flags low register"
  eventfld.long  0x00 31.              "BUF31-28 ,Message Buffer 31 flag" "0,1"
  eventfld.long  0x00 30.              ",Message Buffer 30 flag" "0,1"
  eventfld.long  0x00 29.              ",Message Buffer 29 flag" "0,1"
  eventfld.long  0x00 28.              ",Message Buffer 28 flag" "0,1"

  eventfld.long  0x00 27.              "  BUF27-24 ,Message Buffer 27 flag" "0,1"
  eventfld.long  0x00 26.              ",Message Buffer 26 flag" "0,1"
  eventfld.long  0x00 25.              ",Message Buffer 25 flag" "0,1"
  eventfld.long  0x00 24.              ",Message Buffer 24 flag" "0,1"

  eventfld.long  0x00 23.              "  BUF23-20 ,Message Buffer 23 flag" "0,1"
  eventfld.long  0x00 22.              ",Message Buffer 22 flag" "0,1"
  eventfld.long  0x00 21.              ",Message Buffer 21 flag" "0,1"
  eventfld.long  0x00 20.              ",Message Buffer 20 flag" "0,1"

  eventfld.long  0x00 19.              "  BUF19-16 ,Message Buffer 19 flag" "0,1"
  eventfld.long  0x00 18.              ",Message Buffer 18 flag" "0,1"
  eventfld.long  0x00 17.              ",Message Buffer 17 flag" "0,1"
  eventfld.long  0x00 16.              ",Message Buffer 16 flag" "0,1"
  
  TEXTLINE "                "

  eventfld.long  0x00 15.              "  BUF15-12 ,Message Buffer 15 flag" "0,1"
  eventfld.long  0x00 14.              ",Message Buffer 14 flag" "0,1"
  eventfld.long  0x00 13.              ",Message Buffer 13 flag" "0,1"
  eventfld.long  0x00 12.              ",Message Buffer 12 flag" "0,1"
  
  eventfld.long  0x00 11.              "  BUF11-08 ,Message Buffer 11 flag" "0,1"
  eventfld.long  0x00 10.              ",Message Buffer 10 flag" "0,1"
  eventfld.long  0x00 09.              ",Message Buffer 09 flag" "0,1"
  eventfld.long  0x00 08.              ",Message Buffer 08 flag" "0,1"
  
  eventfld.long  0x00 07.              "  BUF07-04 ,Message Buffer 07 flag" "0,1"
  eventfld.long  0x00 06.              ",Message Buffer 06 flag" "0,1"
  eventfld.long  0x00 05.              ",Message Buffer 05 flag" "0,1"
  eventfld.long  0x00 04.              ",Message Buffer 04 flag" "0,1"

  eventfld.long  0x00 03.              "  BUF03-00 ,Message Buffer 03 flag" "0,1"
  eventfld.long  0x00 02.              ",Message Buffer 02 flag" "0,1"
  eventfld.long  0x00 01.              ",Message Buffer 01 flag" "0,1"
  eventfld.long  0x00 00.              ",Message Buffer 00 flag" "0,1"
  
TEXTLINE ""


tree "Rx Individual Mask Registers"
group.long (0xFFFCC000+0x0880)++0x03
  line.long    0x00 "RXIMR00,Rx Individual Mask Register 00"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFCC000+0x0884)++0x03
  line.long    0x00 "RXIMR01,Rx Individual Mask Register 01"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFCC000+0x0888)++0x03
  line.long    0x00 "RXIMR02,Rx Individual Mask Register 02"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFCC000+0x088c)++0x03
  line.long    0x00 "RXIMR03,Rx Individual Mask Register 03"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFCC000+0x0890)++0x03
  line.long    0x00 "RXIMR04,Rx Individual Mask Register 04"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFCC000+0x0894)++0x03
  line.long    0x00 "RXIMR05,Rx Individual Mask Register 05"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFCC000+0x0898)++0x03
  line.long    0x00 "RXIMR06,Rx Individual Mask Register 06"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFCC000+0x089c)++0x03
  line.long    0x00 "RXIMR07,Rx Individual Mask Register 07"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFCC000+0x08a0)++0x03
  line.long    0x00 "RXIMR08,Rx Individual Mask Register 08"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFCC000+0x08a4)++0x03
  line.long    0x00 "RXIMR09,Rx Individual Mask Register 09"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFCC000+0x08a8)++0x03
  line.long    0x00 "RXIMR10,Rx Individual Mask Register 10"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFCC000+0x08ac)++0x03
  line.long    0x00 "RXIMR11,Rx Individual Mask Register 11"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFCC000+0x08b0)++0x03
  line.long    0x00 "RXIMR12,Rx Individual Mask Register 12"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFCC000+0x08b4)++0x03
  line.long    0x00 "RXIMR13,Rx Individual Mask Register 13"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFCC000+0x08b8)++0x03
  line.long    0x00 "RXIMR14,Rx Individual Mask Register 14"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFCC000+0x08bc)++0x03
  line.long    0x00 "RXIMR15,Rx Individual Mask Register 15"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFCC000+0x08c0)++0x03
  line.long    0x00 "RXIMR16,Rx Individual Mask Register 16"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFCC000+0x08c4)++0x03
  line.long    0x00 "RXIMR17,Rx Individual Mask Register 17"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFCC000+0x08c8)++0x03
  line.long    0x00 "RXIMR18,Rx Individual Mask Register 18"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFCC000+0x08cc)++0x03
  line.long    0x00 "RXIMR19,Rx Individual Mask Register 19"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFCC000+0x08d0)++0x03
  line.long    0x00 "RXIMR20,Rx Individual Mask Register 20"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFCC000+0x08d4)++0x03
  line.long    0x00 "RXIMR21,Rx Individual Mask Register 21"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFCC000+0x08d8)++0x03
  line.long    0x00 "RXIMR22,Rx Individual Mask Register 22"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFCC000+0x08dc)++0x03
  line.long    0x00 "RXIMR23,Rx Individual Mask Register 23"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFCC000+0x08e0)++0x03
  line.long    0x00 "RXIMR24,Rx Individual Mask Register 24"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFCC000+0x08e4)++0x03
  line.long    0x00 "RXIMR25,Rx Individual Mask Register 25"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFCC000+0x08e8)++0x03
  line.long    0x00 "RXIMR26,Rx Individual Mask Register 26"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFCC000+0x08ec)++0x03
  line.long    0x00 "RXIMR27,Rx Individual Mask Register 27"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFCC000+0x08f0)++0x03
  line.long    0x00 "RXIMR28,Rx Individual Mask Register 28"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFCC000+0x08f4)++0x03
  line.long    0x00 "RXIMR29,Rx Individual Mask Register 29"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFCC000+0x08f8)++0x03
  line.long    0x00 "RXIMR30,Rx Individual Mask Register 30"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFCC000+0x08fc)++0x03
  line.long    0x00 "RXIMR31,Rx Individual Mask Register 31"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFCC000+0x0900)++0x03
  line.long    0x00 "RXIMR32,Rx Individual Mask Register 32"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFCC000+0x0904)++0x03
  line.long    0x00 "RXIMR33,Rx Individual Mask Register 33"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFCC000+0x0908)++0x03
  line.long    0x00 "RXIMR34,Rx Individual Mask Register 34"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFCC000+0x090c)++0x03
  line.long    0x00 "RXIMR35,Rx Individual Mask Register 35"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFCC000+0x0910)++0x03
  line.long    0x00 "RXIMR36,Rx Individual Mask Register 36"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFCC000+0x0914)++0x03
  line.long    0x00 "RXIMR37,Rx Individual Mask Register 37"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFCC000+0x0918)++0x03
  line.long    0x00 "RXIMR38,Rx Individual Mask Register 38"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFCC000+0x091c)++0x03
  line.long    0x00 "RXIMR39,Rx Individual Mask Register 39"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFCC000+0x0920)++0x03
  line.long    0x00 "RXIMR30,Rx Individual Mask Register 30"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFCC000+0x0924)++0x03
  line.long    0x00 "RXIMR41,Rx Individual Mask Register 41"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFCC000+0x0928)++0x03
  line.long    0x00 "RXIMR42,Rx Individual Mask Register 42"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFCC000+0x092c)++0x03
  line.long    0x00 "RXIMR43,Rx Individual Mask Register 43"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFCC000+0x0930)++0x03
  line.long    0x00 "RXIMR44,Rx Individual Mask Register 44"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFCC000+0x0934)++0x03
  line.long    0x00 "RXIMR45,Rx Individual Mask Register 45"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFCC000+0x0938)++0x03
  line.long    0x00 "RXIMR46,Rx Individual Mask Register 46"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFCC000+0x093c)++0x03
  line.long    0x00 "RXIMR47,Rx Individual Mask Register 47"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFCC000+0x0940)++0x03
  line.long    0x00 "RXIMR48,Rx Individual Mask Register 48"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFCC000+0x0944)++0x03
  line.long    0x00 "RXIMR49,Rx Individual Mask Register 49"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFCC000+0x0948)++0x03
  line.long    0x00 "RXIMR50,Rx Individual Mask Register 50"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFCC000+0x094c)++0x03
  line.long    0x00 "RXIMR51,Rx Individual Mask Register 51"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFCC000+0x0950)++0x03
  line.long    0x00 "RXIMR52,Rx Individual Mask Register 52"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFCC000+0x0954)++0x03
  line.long    0x00 "RXIMR53,Rx Individual Mask Register 53"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFCC000+0x0958)++0x03
  line.long    0x00 "RXIMR54,Rx Individual Mask Register 54"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFCC000+0x095c)++0x03
  line.long    0x00 "RXIMR55,Rx Individual Mask Register 55"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFCC000+0x0960)++0x03
  line.long    0x00 "RXIMR56,Rx Individual Mask Register 56"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFCC000+0x0964)++0x03
  line.long    0x00 "RXIMR57,Rx Individual Mask Register 57"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFCC000+0x0968)++0x03
  line.long    0x00 "RXIMR58,Rx Individual Mask Register 58"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFCC000+0x096c)++0x03
  line.long    0x00 "RXIMR59,Rx Individual Mask Register 59"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFCC000+0x0970)++0x03
  line.long    0x00 "RXIMR60,Rx Individual Mask Register 60"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFCC000+0x0974)++0x03
  line.long    0x00 "RXIMR61,Rx Individual Mask Register 61"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFCC000+0x0978)++0x03
  line.long    0x00 "RXIMR62,Rx Individual Mask Register 62"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFCC000+0x097c)++0x03
  line.long    0x00 "RXIMR63,Rx Individual Mask Register 63"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
tree.end 

tree "Message Buffers"


group.long (0xFFFCC000+128.)++0x03
  line.long    0x00 "MB0,Message Buffer 0"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFCC000+128.)&0x00200000)==0x00200000
group.long ((0xFFFCC000+128.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 0"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFCC000+128.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 0"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFCC000+128.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 0"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 0"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFCC000+144.)++0x03
  line.long    0x00 "MB1,Message Buffer 1"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFCC000+144.)&0x00200000)==0x00200000
group.long ((0xFFFCC000+144.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 1"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFCC000+144.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 1"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFCC000+144.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 1"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 1"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFCC000+160.)++0x03
  line.long    0x00 "MB2,Message Buffer 2"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFCC000+160.)&0x00200000)==0x00200000
group.long ((0xFFFCC000+160.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 2"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFCC000+160.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 2"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFCC000+160.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 2"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 2"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFCC000+176.)++0x03
  line.long    0x00 "MB3,Message Buffer 3"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFCC000+176.)&0x00200000)==0x00200000
group.long ((0xFFFCC000+176.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 3"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFCC000+176.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 3"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFCC000+176.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 3"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 3"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFCC000+192.)++0x03
  line.long    0x00 "MB4,Message Buffer 4"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFCC000+192.)&0x00200000)==0x00200000
group.long ((0xFFFCC000+192.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 4"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFCC000+192.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 4"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFCC000+192.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 4"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 4"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFCC000+208.)++0x03
  line.long    0x00 "MB5,Message Buffer 5"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFCC000+208.)&0x00200000)==0x00200000
group.long ((0xFFFCC000+208.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 5"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFCC000+208.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 5"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFCC000+208.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 5"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 5"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFCC000+224.)++0x03
  line.long    0x00 "MB6,Message Buffer 6"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFCC000+224.)&0x00200000)==0x00200000
group.long ((0xFFFCC000+224.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 6"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFCC000+224.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 6"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFCC000+224.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 6"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 6"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFCC000+240.)++0x03
  line.long    0x00 "MB7,Message Buffer 7"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFCC000+240.)&0x00200000)==0x00200000
group.long ((0xFFFCC000+240.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 7"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFCC000+240.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 7"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFCC000+240.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 7"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 7"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFCC000+256.)++0x03
  line.long    0x00 "MB8,Message Buffer 8"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFCC000+256.)&0x00200000)==0x00200000
group.long ((0xFFFCC000+256.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 8"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFCC000+256.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 8"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFCC000+256.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 8"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 8"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFCC000+272.)++0x03
  line.long    0x00 "MB9,Message Buffer 9"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFCC000+272.)&0x00200000)==0x00200000
group.long ((0xFFFCC000+272.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 9"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFCC000+272.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 9"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFCC000+272.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 9"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 9"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFCC000+288.)++0x03
  line.long    0x00 "MB10,Message Buffer 10"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFCC000+288.)&0x00200000)==0x00200000
group.long ((0xFFFCC000+288.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 10"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFCC000+288.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 10"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFCC000+288.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 10"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 10"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFCC000+304.)++0x03
  line.long    0x00 "MB11,Message Buffer 11"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFCC000+304.)&0x00200000)==0x00200000
group.long ((0xFFFCC000+304.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 11"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFCC000+304.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 11"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFCC000+304.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 11"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 11"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFCC000+320.)++0x03
  line.long    0x00 "MB12,Message Buffer 12"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFCC000+320.)&0x00200000)==0x00200000
group.long ((0xFFFCC000+320.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 12"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFCC000+320.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 12"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFCC000+320.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 12"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 12"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFCC000+336.)++0x03
  line.long    0x00 "MB13,Message Buffer 13"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFCC000+336.)&0x00200000)==0x00200000
group.long ((0xFFFCC000+336.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 13"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFCC000+336.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 13"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFCC000+336.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 13"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 13"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFCC000+352.)++0x03
  line.long    0x00 "MB14,Message Buffer 14"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFCC000+352.)&0x00200000)==0x00200000
group.long ((0xFFFCC000+352.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 14"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFCC000+352.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 14"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFCC000+352.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 14"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 14"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFCC000+368.)++0x03
  line.long    0x00 "MB15,Message Buffer 15"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFCC000+368.)&0x00200000)==0x00200000
group.long ((0xFFFCC000+368.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 15"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFCC000+368.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 15"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFCC000+368.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 15"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 15"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFCC000+384.)++0x03
  line.long    0x00 "MB16,Message Buffer 16"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFCC000+384.)&0x00200000)==0x00200000
group.long ((0xFFFCC000+384.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 16"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFCC000+384.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 16"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFCC000+384.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 16"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 16"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFCC000+400.)++0x03
  line.long    0x00 "MB17,Message Buffer 17"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFCC000+400.)&0x00200000)==0x00200000
group.long ((0xFFFCC000+400.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 17"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFCC000+400.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 17"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFCC000+400.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 17"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 17"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFCC000+416.)++0x03
  line.long    0x00 "MB18,Message Buffer 18"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFCC000+416.)&0x00200000)==0x00200000
group.long ((0xFFFCC000+416.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 18"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFCC000+416.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 18"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFCC000+416.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 18"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 18"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFCC000+432.)++0x03
  line.long    0x00 "MB19,Message Buffer 19"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFCC000+432.)&0x00200000)==0x00200000
group.long ((0xFFFCC000+432.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 19"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFCC000+432.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 19"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFCC000+432.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 19"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 19"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFCC000+448.)++0x03
  line.long    0x00 "MB20,Message Buffer 20"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFCC000+448.)&0x00200000)==0x00200000
group.long ((0xFFFCC000+448.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 20"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFCC000+448.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 20"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFCC000+448.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 20"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 20"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFCC000+464.)++0x03
  line.long    0x00 "MB21,Message Buffer 21"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFCC000+464.)&0x00200000)==0x00200000
group.long ((0xFFFCC000+464.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 21"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFCC000+464.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 21"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFCC000+464.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 21"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 21"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFCC000+480.)++0x03
  line.long    0x00 "MB22,Message Buffer 22"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFCC000+480.)&0x00200000)==0x00200000
group.long ((0xFFFCC000+480.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 22"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFCC000+480.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 22"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFCC000+480.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 22"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 22"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFCC000+496.)++0x03
  line.long    0x00 "MB23,Message Buffer 23"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFCC000+496.)&0x00200000)==0x00200000
group.long ((0xFFFCC000+496.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 23"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFCC000+496.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 23"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFCC000+496.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 23"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 23"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFCC000+512.)++0x03
  line.long    0x00 "MB24,Message Buffer 24"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFCC000+512.)&0x00200000)==0x00200000
group.long ((0xFFFCC000+512.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 24"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFCC000+512.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 24"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFCC000+512.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 24"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 24"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFCC000+528.)++0x03
  line.long    0x00 "MB25,Message Buffer 25"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFCC000+528.)&0x00200000)==0x00200000
group.long ((0xFFFCC000+528.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 25"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFCC000+528.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 25"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFCC000+528.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 25"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 25"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFCC000+544.)++0x03
  line.long    0x00 "MB26,Message Buffer 26"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFCC000+544.)&0x00200000)==0x00200000
group.long ((0xFFFCC000+544.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 26"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFCC000+544.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 26"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFCC000+544.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 26"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 26"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFCC000+560.)++0x03
  line.long    0x00 "MB27,Message Buffer 27"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFCC000+560.)&0x00200000)==0x00200000
group.long ((0xFFFCC000+560.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 27"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFCC000+560.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 27"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFCC000+560.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 27"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 27"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFCC000+576.)++0x03
  line.long    0x00 "MB28,Message Buffer 28"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFCC000+576.)&0x00200000)==0x00200000
group.long ((0xFFFCC000+576.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 28"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFCC000+576.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 28"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFCC000+576.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 28"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 28"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFCC000+592.)++0x03
  line.long    0x00 "MB29,Message Buffer 29"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFCC000+592.)&0x00200000)==0x00200000
group.long ((0xFFFCC000+592.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 29"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFCC000+592.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 29"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFCC000+592.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 29"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 29"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFCC000+608.)++0x03
  line.long    0x00 "MB30,Message Buffer 30"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFCC000+608.)&0x00200000)==0x00200000
group.long ((0xFFFCC000+608.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 30"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFCC000+608.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 30"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFCC000+608.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 30"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 30"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFCC000+624.)++0x03
  line.long    0x00 "MB31,Message Buffer 31"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFCC000+624.)&0x00200000)==0x00200000
group.long ((0xFFFCC000+624.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 31"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFCC000+624.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 31"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFCC000+624.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 31"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 31"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFCC000+640.)++0x03
  line.long    0x00 "MB32,Message Buffer 32"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFCC000+640.)&0x00200000)==0x00200000
group.long ((0xFFFCC000+640.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 32"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFCC000+640.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 32"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFCC000+640.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 32"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 32"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFCC000+656.)++0x03
  line.long    0x00 "MB33,Message Buffer 33"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFCC000+656.)&0x00200000)==0x00200000
group.long ((0xFFFCC000+656.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 33"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFCC000+656.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 33"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFCC000+656.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 33"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 33"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFCC000+672.)++0x03
  line.long    0x00 "MB34,Message Buffer 34"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFCC000+672.)&0x00200000)==0x00200000
group.long ((0xFFFCC000+672.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 34"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFCC000+672.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 34"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFCC000+672.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 34"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 34"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFCC000+688.)++0x03
  line.long    0x00 "MB35,Message Buffer 35"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFCC000+688.)&0x00200000)==0x00200000
group.long ((0xFFFCC000+688.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 35"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFCC000+688.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 35"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFCC000+688.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 35"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 35"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFCC000+704.)++0x03
  line.long    0x00 "MB36,Message Buffer 36"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFCC000+704.)&0x00200000)==0x00200000
group.long ((0xFFFCC000+704.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 36"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFCC000+704.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 36"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFCC000+704.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 36"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 36"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFCC000+720.)++0x03
  line.long    0x00 "MB37,Message Buffer 37"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFCC000+720.)&0x00200000)==0x00200000
group.long ((0xFFFCC000+720.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 37"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFCC000+720.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 37"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFCC000+720.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 37"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 37"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFCC000+736.)++0x03
  line.long    0x00 "MB38,Message Buffer 38"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFCC000+736.)&0x00200000)==0x00200000
group.long ((0xFFFCC000+736.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 38"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFCC000+736.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 38"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFCC000+736.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 38"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 38"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFCC000+752.)++0x03
  line.long    0x00 "MB39,Message Buffer 39"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFCC000+752.)&0x00200000)==0x00200000
group.long ((0xFFFCC000+752.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 39"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFCC000+752.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 39"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFCC000+752.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 39"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 39"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFCC000+768.)++0x03
  line.long    0x00 "MB40,Message Buffer 40"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFCC000+768.)&0x00200000)==0x00200000
group.long ((0xFFFCC000+768.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 40"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFCC000+768.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 40"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFCC000+768.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 40"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 40"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFCC000+784.)++0x03
  line.long    0x00 "MB41,Message Buffer 41"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFCC000+784.)&0x00200000)==0x00200000
group.long ((0xFFFCC000+784.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 41"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFCC000+784.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 41"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFCC000+784.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 41"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 41"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFCC000+800.)++0x03
  line.long    0x00 "MB42,Message Buffer 42"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFCC000+800.)&0x00200000)==0x00200000
group.long ((0xFFFCC000+800.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 42"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFCC000+800.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 42"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFCC000+800.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 42"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 42"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFCC000+816.)++0x03
  line.long    0x00 "MB43,Message Buffer 43"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFCC000+816.)&0x00200000)==0x00200000
group.long ((0xFFFCC000+816.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 43"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFCC000+816.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 43"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFCC000+816.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 43"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 43"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFCC000+832.)++0x03
  line.long    0x00 "MB44,Message Buffer 44"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFCC000+832.)&0x00200000)==0x00200000
group.long ((0xFFFCC000+832.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 44"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFCC000+832.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 44"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFCC000+832.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 44"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 44"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFCC000+848.)++0x03
  line.long    0x00 "MB45,Message Buffer 45"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFCC000+848.)&0x00200000)==0x00200000
group.long ((0xFFFCC000+848.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 45"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFCC000+848.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 45"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFCC000+848.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 45"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 45"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFCC000+864.)++0x03
  line.long    0x00 "MB46,Message Buffer 46"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFCC000+864.)&0x00200000)==0x00200000
group.long ((0xFFFCC000+864.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 46"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFCC000+864.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 46"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFCC000+864.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 46"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 46"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFCC000+880.)++0x03
  line.long    0x00 "MB47,Message Buffer 47"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFCC000+880.)&0x00200000)==0x00200000
group.long ((0xFFFCC000+880.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 47"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFCC000+880.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 47"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFCC000+880.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 47"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 47"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFCC000+896.)++0x03
  line.long    0x00 "MB48,Message Buffer 48"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFCC000+896.)&0x00200000)==0x00200000
group.long ((0xFFFCC000+896.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 48"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFCC000+896.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 48"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFCC000+896.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 48"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 48"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFCC000+912.)++0x03
  line.long    0x00 "MB49,Message Buffer 49"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFCC000+912.)&0x00200000)==0x00200000
group.long ((0xFFFCC000+912.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 49"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFCC000+912.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 49"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFCC000+912.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 49"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 49"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFCC000+928.)++0x03
  line.long    0x00 "MB50,Message Buffer 50"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFCC000+928.)&0x00200000)==0x00200000
group.long ((0xFFFCC000+928.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 50"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFCC000+928.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 50"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFCC000+928.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 50"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 50"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFCC000+944.)++0x03
  line.long    0x00 "MB51,Message Buffer 51"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFCC000+944.)&0x00200000)==0x00200000
group.long ((0xFFFCC000+944.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 51"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFCC000+944.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 51"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFCC000+944.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 51"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 51"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFCC000+960.)++0x03
  line.long    0x00 "MB52,Message Buffer 52"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFCC000+960.)&0x00200000)==0x00200000
group.long ((0xFFFCC000+960.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 52"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFCC000+960.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 52"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFCC000+960.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 52"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 52"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFCC000+976.)++0x03
  line.long    0x00 "MB53,Message Buffer 53"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFCC000+976.)&0x00200000)==0x00200000
group.long ((0xFFFCC000+976.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 53"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFCC000+976.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 53"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFCC000+976.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 53"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 53"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFCC000+992.)++0x03
  line.long    0x00 "MB54,Message Buffer 54"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFCC000+992.)&0x00200000)==0x00200000
group.long ((0xFFFCC000+992.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 54"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFCC000+992.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 54"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFCC000+992.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 54"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 54"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFCC000+1008.)++0x03
  line.long    0x00 "MB55,Message Buffer 55"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFCC000+1008.)&0x00200000)==0x00200000
group.long ((0xFFFCC000+1008.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 55"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFCC000+1008.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 55"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFCC000+1008.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 55"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 55"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFCC000+1024.)++0x03
  line.long    0x00 "MB56,Message Buffer 56"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFCC000+1024.)&0x00200000)==0x00200000
group.long ((0xFFFCC000+1024.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 56"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFCC000+1024.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 56"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFCC000+1024.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 56"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 56"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFCC000+1040.)++0x03
  line.long    0x00 "MB57,Message Buffer 57"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFCC000+1040.)&0x00200000)==0x00200000
group.long ((0xFFFCC000+1040.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 57"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFCC000+1040.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 57"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFCC000+1040.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 57"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 57"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFCC000+1056.)++0x03
  line.long    0x00 "MB58,Message Buffer 58"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFCC000+1056.)&0x00200000)==0x00200000
group.long ((0xFFFCC000+1056.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 58"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFCC000+1056.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 58"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFCC000+1056.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 58"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 58"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFCC000+1072.)++0x03
  line.long    0x00 "MB59,Message Buffer 59"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFCC000+1072.)&0x00200000)==0x00200000
group.long ((0xFFFCC000+1072.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 59"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFCC000+1072.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 59"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFCC000+1072.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 59"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 59"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFCC000+1088.)++0x03
  line.long    0x00 "MB60,Message Buffer 60"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFCC000+1088.)&0x00200000)==0x00200000
group.long ((0xFFFCC000+1088.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 60"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFCC000+1088.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 60"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFCC000+1088.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 60"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 60"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFCC000+1104.)++0x03
  line.long    0x00 "MB61,Message Buffer 61"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFCC000+1104.)&0x00200000)==0x00200000
group.long ((0xFFFCC000+1104.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 61"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFCC000+1104.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 61"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFCC000+1104.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 61"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 61"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFCC000+1120.)++0x03
  line.long    0x00 "MB62,Message Buffer 62"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFCC000+1120.)&0x00200000)==0x00200000
group.long ((0xFFFCC000+1120.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 62"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFCC000+1120.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 62"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFCC000+1120.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 62"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 62"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFCC000+1136.)++0x03
  line.long    0x00 "MB63,Message Buffer 63"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFCC000+1136.)&0x00200000)==0x00200000
group.long ((0xFFFCC000+1136.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 63"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFCC000+1136.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 63"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFCC000+1136.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 63"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 63"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""
tree.end


tree.end

endif

sif ((cpu()=="MPC5567"))

tree "FlexCAN E"

group.long 0xFFFD0000++0x03
  line.long    0x00 "MCR,Module Configuration Register"
  bitfld.long  0x00 31.                  "MDIS     ,Module disable" "0,1"
  bitfld.long  0x00 30.                  "  FRZ ,Freeze enable" "0,1"
  bitfld.long  0x00 28.                  "      HALT    ,Halt FlexCAN" "0,1"
  bitfld.long  0x00 27.                  "    NOTRDY ,FlexCAN2 not ready" "0,1"
  bitfld.long  0x00 25.                  "  SOFTRST ,Soft reset" "0,1"
  bitfld.long  0x00 24.                  "  FRZACK ,Freeze mode acknowledge" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 21.                  "  WRNEN    ,Warning interrupt enable" "0,1"
  bitfld.long  0x00 20.                  "  MDISACK ,Low power mode acknowledge" "0,1"
  bitfld.long  0x00 17.                  "  SRXDIS  ,This bit defines whether FlexCAN is allowed to receive frames transmitted by itself" "0,1"
  bitfld.long  0x00 16.                  "    MBFEN  ,Message buffer filter enable" "0,1"
  hexmask.byte 0x03 00.--06. 1.          "  MAXMB  ,Maximum number of message buffers"
TEXTLINE ""
 

group.long (0xFFFD0000+0x04)++0x03
  line.long    0x00 "CR,Control Register"
  hexmask.byte 0x00 00.--07. 1.          "PRESDIV ,Prescaler division factor"
  bitfld.long  0x00 22.--23.             "  RJW ,Resync jump width" "0,1,2,3"
  bitfld.long  0x00 19.--21.             "      PSEG1   ,Phase segment 1" "0,1,2,3,4,5,6,7"
  bitfld.long  0x00 16.--18.             "    PSEG2  ,Phase segment 2" "0,1,2,3,4,5,6,7"
  bitfld.long  0x00 15.                  "  BOFFMSK ,Bus off mask" "0,1"
  bitfld.long  0x00 14.                  "  ERRMSK ,Error mask" "0,1"
  bitfld.long  0x00 13.                  "  CLK_SRC ,CAN engine clock source" "osc_clk,bus_clk"
TEXTLINE "                "
  bitfld.long  0x00 12.                  "  LPB      ,Loop back" "0,1"
  bitfld.long  0x00 07.                  "  SMP ,Sampling mode" "one,three"
  bitfld.long  0x00 06.                  "  BOFFREC ,Bus off recovery mode" "ena,dis"
  bitfld.long  0x00 05.                  "  TSYN   ,Timer sync mode" "0,1"
  bitfld.long  0x00 04.                  "  LBUF    ,Lowest buffer transmitted first" "0,1"
  bitfld.long  0x00 03.                  "  LOM    ,Listen-only mode" "0,1"
  bitfld.long  0x00 00.--02.             "  PROPSEG ,Propagation segment" "0,1,2,3,4,5,6,7"
TEXTLINE ""

group.long (0xFFFD0000+0x08)++0x03
  line.long    0x00 "TIMER,Free Running Timer"
TEXTLINE ""

group.long (0xFFFD0000+0x10)++0x03
  line.long    0x00 "RXGMASK,RX Global Mask"
  bitfld.long  0x00 28.              "MI28       ,ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
  
  TEXTLINE "                "

  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"

TEXTLINE ""

group.long (0xFFFD0000+0x14)++0x03
  line.long    0x00 "RX14MASK,RX 14 Global Mask"
  bitfld.long  0x00 28.              "MI28       ,ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
  
  TEXTLINE "                "

  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""

group.long (0xFFFD0000+0x18)++0x03
  line.long    0x00 "RX15MASK,RX 15 Global Mask"
  bitfld.long  0x00 28.              "MI28       ,ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
  
  TEXTLINE "                "

  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""

group.long (0xFFFD0000+0x1C)++0x03
  line.long    0x00 "ECR,Error Counter Register"
  hexmask.byte 0x02 00.--07. 1.          "RXECTR ,Receive Error Counter"
  hexmask.byte 0x03 00.--07. 1.          "  TXECTR ,Transmit Error Counter"
TEXTLINE ""

group.long (0xFFFD0000+0x20)++0x03
  line.long    0x00 "ESR,Error and Status Register"
  bitfld.long  0x00 15.                  "BIT1ERR ,Bit 1 error" "0,1"
  bitfld.long  0x00 14.                  "  BIT0ERR ,Bit 0 error" "0,1"
  bitfld.long  0x00 13.                  "  ACKERR ,Acknowledge error." "0,1"
  bitfld.long  0x00 12.                  "   CRCERR   ,Cyclic redundancy code error" "0,1"
  bitfld.long  0x00 11.                  "  FRMERR ,Form error" "0,1"
  bitfld.long  0x00 10.                  "  STFERR ,Stuffing error" "0,1"
  bitfld.long  0x00 09.                  "  TXWRN  ,TX error counter" "0,1"
  TEXTLINE "                "
  bitfld.long  0x00 08.                  "  RXWRN   ,RX error counter" "0,1"
  bitfld.long  0x00 07.                  "  IDLE    ,CAN bus IDLE state" "0,1"
  bitfld.long  0x00 06.                  "  TXRX   ,Current FlexCAN2 status" "RX,TX"
  bitfld.long  0x00 04.--05.             "  FLTCONF  ,Fault confinement state" "err act,err pass,bus off,bus off"
  eventfld.long  0x00 02.                  "  BOFFINT   ,Bus off interrupt" "0,1"
  eventfld.long  0x00 01.                  "  ERRINT ,Error interrupt" "0,1"
TEXTLINE ""


group.long (0xFFFD0000+0x24)++0x03
  line.long    0x00 "IMRH,Interrupt masks high register"
  bitfld.long  0x00 31.              "BUF63-60 ,Message Buffer 63 mask" "0,1"
  bitfld.long  0x00 30.              ",Message Buffer 62 mask" "0,1"
  bitfld.long  0x00 29.              ",Message Buffer 61 mask" "0,1"
  bitfld.long  0x00 28.              ",Message Buffer 60 mask" "0,1"

  bitfld.long  0x00 27.              "  BUF59-56 ,Message Buffer 59 mask" "0,1"
  bitfld.long  0x00 26.              ",Message Buffer 58 mask" "0,1"
  bitfld.long  0x00 25.              ",Message Buffer 57 mask" "0,1"
  bitfld.long  0x00 24.              ",Message Buffer 56 mask" "0,1"

  bitfld.long  0x00 23.              "  BUF55-52 ,Message Buffer 55 mask" "0,1"
  bitfld.long  0x00 22.              ",Message Buffer 54 mask" "0,1"
  bitfld.long  0x00 21.              ",Message Buffer 53 mask" "0,1"
  bitfld.long  0x00 20.              ",Message Buffer 52 mask" "0,1"

  bitfld.long  0x00 19.              "  BUF51-48 ,Message Buffer 51 mask" "0,1"
  bitfld.long  0x00 18.              ",Message Buffer 50 mask" "0,1"
  bitfld.long  0x00 17.              ",Message Buffer 49 mask" "0,1"
  bitfld.long  0x00 16.              ",Message Buffer 48 mask" "0,1"
  
  TEXTLINE "                "

  bitfld.long  0x00 15.              "  BUF47-44 ,Message Buffer 47 mask" "0,1"
  bitfld.long  0x00 14.              ",Message Buffer 46 mask" "0,1"
  bitfld.long  0x00 13.              ",Message Buffer 45 mask" "0,1"
  bitfld.long  0x00 12.              ",Message Buffer 44 mask" "0,1"
  
  bitfld.long  0x00 11.              "  BUF43-40 ,Message Buffer 43 mask" "0,1"
  bitfld.long  0x00 10.              ",Message Buffer 42 mask" "0,1"
  bitfld.long  0x00 09.              ",Message Buffer 41 mask" "0,1"
  bitfld.long  0x00 08.              ",Message Buffer 40 mask" "0,1"
  
  bitfld.long  0x00 07.              "  BUF39-36 ,Message Buffer 39 mask" "0,1"
  bitfld.long  0x00 06.              ",Message Buffer 38 mask" "0,1"
  bitfld.long  0x00 05.              ",Message Buffer 37 mask" "0,1"
  bitfld.long  0x00 04.              ",Message Buffer 36 mask" "0,1"

  bitfld.long  0x00 03.              "  BUF35-32 ,Message Buffer 35 mask" "0,1"
  bitfld.long  0x00 02.              ",Message Buffer 34 mask" "0,1"
  bitfld.long  0x00 01.              ",Message Buffer 33 mask" "0,1"
  bitfld.long  0x00 00.              ",Message Buffer 32 mask" "0,1"
  
TEXTLINE ""

group.long (0xFFFD0000+0x28)++0x03
  line.long    0x00 "IMRL,Interrupt masks low register"
  bitfld.long  0x00 31.              "BUF31-28 ,Message Buffer 31 mask" "0,1"
  bitfld.long  0x00 30.              ",Message Buffer 30 mask" "0,1"
  bitfld.long  0x00 29.              ",Message Buffer 29 mask" "0,1"
  bitfld.long  0x00 28.              ",Message Buffer 28 mask" "0,1"

  bitfld.long  0x00 27.              "  BUF27-24 ,Message Buffer 27 mask" "0,1"
  bitfld.long  0x00 26.              ",Message Buffer 26 mask" "0,1"
  bitfld.long  0x00 25.              ",Message Buffer 25 mask" "0,1"
  bitfld.long  0x00 24.              ",Message Buffer 24 mask" "0,1"

  bitfld.long  0x00 23.              "  BUF23-20 ,Message Buffer 23 mask" "0,1"
  bitfld.long  0x00 22.              ",Message Buffer 22 mask" "0,1"
  bitfld.long  0x00 21.              ",Message Buffer 21 mask" "0,1"
  bitfld.long  0x00 20.              ",Message Buffer 20 mask" "0,1"

  bitfld.long  0x00 19.              "  BUF19-16 ,Message Buffer 19 mask" "0,1"
  bitfld.long  0x00 18.              ",Message Buffer 18 mask" "0,1"
  bitfld.long  0x00 17.              ",Message Buffer 17 mask" "0,1"
  bitfld.long  0x00 16.              ",Message Buffer 16 mask" "0,1"
  
  TEXTLINE "                "

  bitfld.long  0x00 15.              "  BUF15-12 ,Message Buffer 15 mask" "0,1"
  bitfld.long  0x00 14.              ",Message Buffer 14 mask" "0,1"
  bitfld.long  0x00 13.              ",Message Buffer 13 mask" "0,1"
  bitfld.long  0x00 12.              ",Message Buffer 12 mask" "0,1"
  
  bitfld.long  0x00 11.              "  BUF11-08 ,Message Buffer 11 mask" "0,1"
  bitfld.long  0x00 10.              ",Message Buffer 10 mask" "0,1"
  bitfld.long  0x00 09.              ",Message Buffer 09 mask" "0,1"
  bitfld.long  0x00 08.              ",Message Buffer 08 mask" "0,1"
  
  bitfld.long  0x00 07.              "  BUF07-04 ,Message Buffer 07 mask" "0,1"
  bitfld.long  0x00 06.              ",Message Buffer 06 mask" "0,1"
  bitfld.long  0x00 05.              ",Message Buffer 05 mask" "0,1"
  bitfld.long  0x00 04.              ",Message Buffer 04 mask" "0,1"

  bitfld.long  0x00 03.              "  BUF03-00 ,Message Buffer 03 mask" "0,1"
  bitfld.long  0x00 02.              ",Message Buffer 02 mask" "0,1"
  bitfld.long  0x00 01.              ",Message Buffer 01 mask" "0,1"
  bitfld.long  0x00 00.              ",Message Buffer 00 mask" "0,1"
  
TEXTLINE ""


group.long (0xFFFD0000+0x2C)++0x03
  line.long    0x00 "IFRH,Interrupt flags high register"
  eventfld.long  0x00 31.              "BUF63-60 ,Message Buffer 63 flag" "0,1"
  eventfld.long  0x00 30.              ",Message Buffer 62 flag" "0,1"
  eventfld.long  0x00 29.              ",Message Buffer 61 flag" "0,1"
  eventfld.long  0x00 28.              ",Message Buffer 60 flag" "0,1"

  eventfld.long  0x00 27.              "  BUF59-56 ,Message Buffer 59 flag" "0,1"
  eventfld.long  0x00 26.              ",Message Buffer 58 flag" "0,1"
  eventfld.long  0x00 25.              ",Message Buffer 57 flag" "0,1"
  eventfld.long  0x00 24.              ",Message Buffer 56 flag" "0,1"

  eventfld.long  0x00 23.              "  BUF55-52 ,Message Buffer 55 flag" "0,1"
  eventfld.long  0x00 22.              ",Message Buffer 54 flag" "0,1"
  eventfld.long  0x00 21.              ",Message Buffer 53 flag" "0,1"
  eventfld.long  0x00 20.              ",Message Buffer 52 flag" "0,1"

  eventfld.long  0x00 19.              "  BUF51-48 ,Message Buffer 51 flag" "0,1"
  eventfld.long  0x00 18.              ",Message Buffer 50 flag" "0,1"
  eventfld.long  0x00 17.              ",Message Buffer 49 flag" "0,1"
  eventfld.long  0x00 16.              ",Message Buffer 48 flag" "0,1"
  
  TEXTLINE "                "

  eventfld.long  0x00 15.              "  BUF47-44 ,Message Buffer 47 flag" "0,1"
  eventfld.long  0x00 14.              ",Message Buffer 46 flag" "0,1"
  eventfld.long  0x00 13.              ",Message Buffer 45 flag" "0,1"
  eventfld.long  0x00 12.              ",Message Buffer 44 flag" "0,1"
  
  eventfld.long  0x00 11.              "  BUF43-40 ,Message Buffer 43 flag" "0,1"
  eventfld.long  0x00 10.              ",Message Buffer 42 flag" "0,1"
  eventfld.long  0x00 09.              ",Message Buffer 41 flag" "0,1"
  eventfld.long  0x00 08.              ",Message Buffer 40 flag" "0,1"
  
  eventfld.long  0x00 07.              "  BUF39-36 ,Message Buffer 39 flag" "0,1"
  eventfld.long  0x00 06.              ",Message Buffer 38 flag" "0,1"
  eventfld.long  0x00 05.              ",Message Buffer 37 flag" "0,1"
  eventfld.long  0x00 04.              ",Message Buffer 36 flag" "0,1"

  eventfld.long  0x00 03.              "  BUF35-32 ,Message Buffer 35 flag" "0,1"
  eventfld.long  0x00 02.              ",Message Buffer 34 flag" "0,1"
  eventfld.long  0x00 01.              ",Message Buffer 33 flag" "0,1"
  eventfld.long  0x00 00.              ",Message Buffer 32 flag" "0,1"
  
TEXTLINE ""

group.long (0xFFFD0000+0x30)++0x03
  line.long    0x00 "IFRL,Interrupt flags low register"
  eventfld.long  0x00 31.              "BUF31-28 ,Message Buffer 31 flag" "0,1"
  eventfld.long  0x00 30.              ",Message Buffer 30 flag" "0,1"
  eventfld.long  0x00 29.              ",Message Buffer 29 flag" "0,1"
  eventfld.long  0x00 28.              ",Message Buffer 28 flag" "0,1"

  eventfld.long  0x00 27.              "  BUF27-24 ,Message Buffer 27 flag" "0,1"
  eventfld.long  0x00 26.              ",Message Buffer 26 flag" "0,1"
  eventfld.long  0x00 25.              ",Message Buffer 25 flag" "0,1"
  eventfld.long  0x00 24.              ",Message Buffer 24 flag" "0,1"

  eventfld.long  0x00 23.              "  BUF23-20 ,Message Buffer 23 flag" "0,1"
  eventfld.long  0x00 22.              ",Message Buffer 22 flag" "0,1"
  eventfld.long  0x00 21.              ",Message Buffer 21 flag" "0,1"
  eventfld.long  0x00 20.              ",Message Buffer 20 flag" "0,1"

  eventfld.long  0x00 19.              "  BUF19-16 ,Message Buffer 19 flag" "0,1"
  eventfld.long  0x00 18.              ",Message Buffer 18 flag" "0,1"
  eventfld.long  0x00 17.              ",Message Buffer 17 flag" "0,1"
  eventfld.long  0x00 16.              ",Message Buffer 16 flag" "0,1"
  
  TEXTLINE "                "

  eventfld.long  0x00 15.              "  BUF15-12 ,Message Buffer 15 flag" "0,1"
  eventfld.long  0x00 14.              ",Message Buffer 14 flag" "0,1"
  eventfld.long  0x00 13.              ",Message Buffer 13 flag" "0,1"
  eventfld.long  0x00 12.              ",Message Buffer 12 flag" "0,1"
  
  eventfld.long  0x00 11.              "  BUF11-08 ,Message Buffer 11 flag" "0,1"
  eventfld.long  0x00 10.              ",Message Buffer 10 flag" "0,1"
  eventfld.long  0x00 09.              ",Message Buffer 09 flag" "0,1"
  eventfld.long  0x00 08.              ",Message Buffer 08 flag" "0,1"
  
  eventfld.long  0x00 07.              "  BUF07-04 ,Message Buffer 07 flag" "0,1"
  eventfld.long  0x00 06.              ",Message Buffer 06 flag" "0,1"
  eventfld.long  0x00 05.              ",Message Buffer 05 flag" "0,1"
  eventfld.long  0x00 04.              ",Message Buffer 04 flag" "0,1"

  eventfld.long  0x00 03.              "  BUF03-00 ,Message Buffer 03 flag" "0,1"
  eventfld.long  0x00 02.              ",Message Buffer 02 flag" "0,1"
  eventfld.long  0x00 01.              ",Message Buffer 01 flag" "0,1"
  eventfld.long  0x00 00.              ",Message Buffer 00 flag" "0,1"
  
TEXTLINE ""


tree "Rx Individual Mask Registers"
group.long (0xFFFD0000+0x0880)++0x03
  line.long    0x00 "RXIMR00,Rx Individual Mask Register 00"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFD0000+0x0884)++0x03
  line.long    0x00 "RXIMR01,Rx Individual Mask Register 01"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFD0000+0x0888)++0x03
  line.long    0x00 "RXIMR02,Rx Individual Mask Register 02"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFD0000+0x088c)++0x03
  line.long    0x00 "RXIMR03,Rx Individual Mask Register 03"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFD0000+0x0890)++0x03
  line.long    0x00 "RXIMR04,Rx Individual Mask Register 04"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFD0000+0x0894)++0x03
  line.long    0x00 "RXIMR05,Rx Individual Mask Register 05"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFD0000+0x0898)++0x03
  line.long    0x00 "RXIMR06,Rx Individual Mask Register 06"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFD0000+0x089c)++0x03
  line.long    0x00 "RXIMR07,Rx Individual Mask Register 07"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFD0000+0x08a0)++0x03
  line.long    0x00 "RXIMR08,Rx Individual Mask Register 08"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFD0000+0x08a4)++0x03
  line.long    0x00 "RXIMR09,Rx Individual Mask Register 09"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFD0000+0x08a8)++0x03
  line.long    0x00 "RXIMR10,Rx Individual Mask Register 10"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFD0000+0x08ac)++0x03
  line.long    0x00 "RXIMR11,Rx Individual Mask Register 11"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFD0000+0x08b0)++0x03
  line.long    0x00 "RXIMR12,Rx Individual Mask Register 12"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFD0000+0x08b4)++0x03
  line.long    0x00 "RXIMR13,Rx Individual Mask Register 13"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFD0000+0x08b8)++0x03
  line.long    0x00 "RXIMR14,Rx Individual Mask Register 14"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFD0000+0x08bc)++0x03
  line.long    0x00 "RXIMR15,Rx Individual Mask Register 15"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFD0000+0x08c0)++0x03
  line.long    0x00 "RXIMR16,Rx Individual Mask Register 16"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFD0000+0x08c4)++0x03
  line.long    0x00 "RXIMR17,Rx Individual Mask Register 17"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFD0000+0x08c8)++0x03
  line.long    0x00 "RXIMR18,Rx Individual Mask Register 18"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFD0000+0x08cc)++0x03
  line.long    0x00 "RXIMR19,Rx Individual Mask Register 19"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFD0000+0x08d0)++0x03
  line.long    0x00 "RXIMR20,Rx Individual Mask Register 20"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFD0000+0x08d4)++0x03
  line.long    0x00 "RXIMR21,Rx Individual Mask Register 21"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFD0000+0x08d8)++0x03
  line.long    0x00 "RXIMR22,Rx Individual Mask Register 22"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFD0000+0x08dc)++0x03
  line.long    0x00 "RXIMR23,Rx Individual Mask Register 23"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFD0000+0x08e0)++0x03
  line.long    0x00 "RXIMR24,Rx Individual Mask Register 24"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFD0000+0x08e4)++0x03
  line.long    0x00 "RXIMR25,Rx Individual Mask Register 25"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFD0000+0x08e8)++0x03
  line.long    0x00 "RXIMR26,Rx Individual Mask Register 26"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFD0000+0x08ec)++0x03
  line.long    0x00 "RXIMR27,Rx Individual Mask Register 27"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFD0000+0x08f0)++0x03
  line.long    0x00 "RXIMR28,Rx Individual Mask Register 28"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFD0000+0x08f4)++0x03
  line.long    0x00 "RXIMR29,Rx Individual Mask Register 29"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFD0000+0x08f8)++0x03
  line.long    0x00 "RXIMR30,Rx Individual Mask Register 30"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFD0000+0x08fc)++0x03
  line.long    0x00 "RXIMR31,Rx Individual Mask Register 31"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFD0000+0x0900)++0x03
  line.long    0x00 "RXIMR32,Rx Individual Mask Register 32"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFD0000+0x0904)++0x03
  line.long    0x00 "RXIMR33,Rx Individual Mask Register 33"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFD0000+0x0908)++0x03
  line.long    0x00 "RXIMR34,Rx Individual Mask Register 34"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFD0000+0x090c)++0x03
  line.long    0x00 "RXIMR35,Rx Individual Mask Register 35"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFD0000+0x0910)++0x03
  line.long    0x00 "RXIMR36,Rx Individual Mask Register 36"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFD0000+0x0914)++0x03
  line.long    0x00 "RXIMR37,Rx Individual Mask Register 37"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFD0000+0x0918)++0x03
  line.long    0x00 "RXIMR38,Rx Individual Mask Register 38"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFD0000+0x091c)++0x03
  line.long    0x00 "RXIMR39,Rx Individual Mask Register 39"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFD0000+0x0920)++0x03
  line.long    0x00 "RXIMR30,Rx Individual Mask Register 30"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFD0000+0x0924)++0x03
  line.long    0x00 "RXIMR41,Rx Individual Mask Register 41"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFD0000+0x0928)++0x03
  line.long    0x00 "RXIMR42,Rx Individual Mask Register 42"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFD0000+0x092c)++0x03
  line.long    0x00 "RXIMR43,Rx Individual Mask Register 43"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFD0000+0x0930)++0x03
  line.long    0x00 "RXIMR44,Rx Individual Mask Register 44"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFD0000+0x0934)++0x03
  line.long    0x00 "RXIMR45,Rx Individual Mask Register 45"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFD0000+0x0938)++0x03
  line.long    0x00 "RXIMR46,Rx Individual Mask Register 46"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFD0000+0x093c)++0x03
  line.long    0x00 "RXIMR47,Rx Individual Mask Register 47"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFD0000+0x0940)++0x03
  line.long    0x00 "RXIMR48,Rx Individual Mask Register 48"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFD0000+0x0944)++0x03
  line.long    0x00 "RXIMR49,Rx Individual Mask Register 49"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFD0000+0x0948)++0x03
  line.long    0x00 "RXIMR50,Rx Individual Mask Register 50"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFD0000+0x094c)++0x03
  line.long    0x00 "RXIMR51,Rx Individual Mask Register 51"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFD0000+0x0950)++0x03
  line.long    0x00 "RXIMR52,Rx Individual Mask Register 52"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFD0000+0x0954)++0x03
  line.long    0x00 "RXIMR53,Rx Individual Mask Register 53"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFD0000+0x0958)++0x03
  line.long    0x00 "RXIMR54,Rx Individual Mask Register 54"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFD0000+0x095c)++0x03
  line.long    0x00 "RXIMR55,Rx Individual Mask Register 55"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFD0000+0x0960)++0x03
  line.long    0x00 "RXIMR56,Rx Individual Mask Register 56"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFD0000+0x0964)++0x03
  line.long    0x00 "RXIMR57,Rx Individual Mask Register 57"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFD0000+0x0968)++0x03
  line.long    0x00 "RXIMR58,Rx Individual Mask Register 58"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFD0000+0x096c)++0x03
  line.long    0x00 "RXIMR59,Rx Individual Mask Register 59"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFD0000+0x0970)++0x03
  line.long    0x00 "RXIMR60,Rx Individual Mask Register 60"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFD0000+0x0974)++0x03
  line.long    0x00 "RXIMR61,Rx Individual Mask Register 61"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFD0000+0x0978)++0x03
  line.long    0x00 "RXIMR62,Rx Individual Mask Register 62"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFD0000+0x097c)++0x03
  line.long    0x00 "RXIMR63,Rx Individual Mask Register 63"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
tree.end 

tree "Message Buffers"


group.long (0xFFFD0000+128.)++0x03
  line.long    0x00 "MB0,Message Buffer 0"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFD0000+128.)&0x00200000)==0x00200000
group.long ((0xFFFD0000+128.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 0"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFD0000+128.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 0"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFD0000+128.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 0"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 0"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFD0000+144.)++0x03
  line.long    0x00 "MB1,Message Buffer 1"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFD0000+144.)&0x00200000)==0x00200000
group.long ((0xFFFD0000+144.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 1"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFD0000+144.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 1"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFD0000+144.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 1"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 1"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFD0000+160.)++0x03
  line.long    0x00 "MB2,Message Buffer 2"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFD0000+160.)&0x00200000)==0x00200000
group.long ((0xFFFD0000+160.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 2"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFD0000+160.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 2"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFD0000+160.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 2"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 2"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFD0000+176.)++0x03
  line.long    0x00 "MB3,Message Buffer 3"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFD0000+176.)&0x00200000)==0x00200000
group.long ((0xFFFD0000+176.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 3"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFD0000+176.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 3"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFD0000+176.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 3"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 3"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFD0000+192.)++0x03
  line.long    0x00 "MB4,Message Buffer 4"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFD0000+192.)&0x00200000)==0x00200000
group.long ((0xFFFD0000+192.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 4"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFD0000+192.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 4"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFD0000+192.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 4"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 4"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFD0000+208.)++0x03
  line.long    0x00 "MB5,Message Buffer 5"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFD0000+208.)&0x00200000)==0x00200000
group.long ((0xFFFD0000+208.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 5"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFD0000+208.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 5"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFD0000+208.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 5"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 5"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFD0000+224.)++0x03
  line.long    0x00 "MB6,Message Buffer 6"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFD0000+224.)&0x00200000)==0x00200000
group.long ((0xFFFD0000+224.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 6"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFD0000+224.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 6"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFD0000+224.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 6"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 6"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFD0000+240.)++0x03
  line.long    0x00 "MB7,Message Buffer 7"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFD0000+240.)&0x00200000)==0x00200000
group.long ((0xFFFD0000+240.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 7"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFD0000+240.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 7"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFD0000+240.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 7"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 7"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFD0000+256.)++0x03
  line.long    0x00 "MB8,Message Buffer 8"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFD0000+256.)&0x00200000)==0x00200000
group.long ((0xFFFD0000+256.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 8"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFD0000+256.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 8"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFD0000+256.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 8"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 8"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFD0000+272.)++0x03
  line.long    0x00 "MB9,Message Buffer 9"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFD0000+272.)&0x00200000)==0x00200000
group.long ((0xFFFD0000+272.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 9"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFD0000+272.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 9"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFD0000+272.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 9"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 9"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFD0000+288.)++0x03
  line.long    0x00 "MB10,Message Buffer 10"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFD0000+288.)&0x00200000)==0x00200000
group.long ((0xFFFD0000+288.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 10"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFD0000+288.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 10"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFD0000+288.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 10"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 10"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFD0000+304.)++0x03
  line.long    0x00 "MB11,Message Buffer 11"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFD0000+304.)&0x00200000)==0x00200000
group.long ((0xFFFD0000+304.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 11"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFD0000+304.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 11"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFD0000+304.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 11"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 11"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFD0000+320.)++0x03
  line.long    0x00 "MB12,Message Buffer 12"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFD0000+320.)&0x00200000)==0x00200000
group.long ((0xFFFD0000+320.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 12"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFD0000+320.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 12"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFD0000+320.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 12"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 12"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFD0000+336.)++0x03
  line.long    0x00 "MB13,Message Buffer 13"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFD0000+336.)&0x00200000)==0x00200000
group.long ((0xFFFD0000+336.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 13"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFD0000+336.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 13"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFD0000+336.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 13"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 13"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFD0000+352.)++0x03
  line.long    0x00 "MB14,Message Buffer 14"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFD0000+352.)&0x00200000)==0x00200000
group.long ((0xFFFD0000+352.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 14"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFD0000+352.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 14"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFD0000+352.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 14"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 14"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFD0000+368.)++0x03
  line.long    0x00 "MB15,Message Buffer 15"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFD0000+368.)&0x00200000)==0x00200000
group.long ((0xFFFD0000+368.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 15"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFD0000+368.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 15"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFD0000+368.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 15"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 15"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFD0000+384.)++0x03
  line.long    0x00 "MB16,Message Buffer 16"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFD0000+384.)&0x00200000)==0x00200000
group.long ((0xFFFD0000+384.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 16"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFD0000+384.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 16"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFD0000+384.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 16"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 16"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFD0000+400.)++0x03
  line.long    0x00 "MB17,Message Buffer 17"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFD0000+400.)&0x00200000)==0x00200000
group.long ((0xFFFD0000+400.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 17"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFD0000+400.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 17"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFD0000+400.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 17"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 17"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFD0000+416.)++0x03
  line.long    0x00 "MB18,Message Buffer 18"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFD0000+416.)&0x00200000)==0x00200000
group.long ((0xFFFD0000+416.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 18"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFD0000+416.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 18"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFD0000+416.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 18"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 18"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFD0000+432.)++0x03
  line.long    0x00 "MB19,Message Buffer 19"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFD0000+432.)&0x00200000)==0x00200000
group.long ((0xFFFD0000+432.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 19"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFD0000+432.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 19"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFD0000+432.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 19"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 19"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFD0000+448.)++0x03
  line.long    0x00 "MB20,Message Buffer 20"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFD0000+448.)&0x00200000)==0x00200000
group.long ((0xFFFD0000+448.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 20"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFD0000+448.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 20"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFD0000+448.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 20"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 20"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFD0000+464.)++0x03
  line.long    0x00 "MB21,Message Buffer 21"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFD0000+464.)&0x00200000)==0x00200000
group.long ((0xFFFD0000+464.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 21"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFD0000+464.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 21"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFD0000+464.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 21"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 21"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFD0000+480.)++0x03
  line.long    0x00 "MB22,Message Buffer 22"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFD0000+480.)&0x00200000)==0x00200000
group.long ((0xFFFD0000+480.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 22"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFD0000+480.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 22"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFD0000+480.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 22"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 22"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFD0000+496.)++0x03
  line.long    0x00 "MB23,Message Buffer 23"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFD0000+496.)&0x00200000)==0x00200000
group.long ((0xFFFD0000+496.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 23"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFD0000+496.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 23"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFD0000+496.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 23"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 23"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFD0000+512.)++0x03
  line.long    0x00 "MB24,Message Buffer 24"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFD0000+512.)&0x00200000)==0x00200000
group.long ((0xFFFD0000+512.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 24"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFD0000+512.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 24"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFD0000+512.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 24"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 24"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFD0000+528.)++0x03
  line.long    0x00 "MB25,Message Buffer 25"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFD0000+528.)&0x00200000)==0x00200000
group.long ((0xFFFD0000+528.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 25"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFD0000+528.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 25"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFD0000+528.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 25"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 25"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFD0000+544.)++0x03
  line.long    0x00 "MB26,Message Buffer 26"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFD0000+544.)&0x00200000)==0x00200000
group.long ((0xFFFD0000+544.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 26"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFD0000+544.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 26"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFD0000+544.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 26"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 26"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFD0000+560.)++0x03
  line.long    0x00 "MB27,Message Buffer 27"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFD0000+560.)&0x00200000)==0x00200000
group.long ((0xFFFD0000+560.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 27"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFD0000+560.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 27"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFD0000+560.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 27"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 27"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFD0000+576.)++0x03
  line.long    0x00 "MB28,Message Buffer 28"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFD0000+576.)&0x00200000)==0x00200000
group.long ((0xFFFD0000+576.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 28"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFD0000+576.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 28"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFD0000+576.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 28"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 28"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFD0000+592.)++0x03
  line.long    0x00 "MB29,Message Buffer 29"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFD0000+592.)&0x00200000)==0x00200000
group.long ((0xFFFD0000+592.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 29"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFD0000+592.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 29"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFD0000+592.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 29"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 29"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFD0000+608.)++0x03
  line.long    0x00 "MB30,Message Buffer 30"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFD0000+608.)&0x00200000)==0x00200000
group.long ((0xFFFD0000+608.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 30"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFD0000+608.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 30"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFD0000+608.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 30"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 30"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFD0000+624.)++0x03
  line.long    0x00 "MB31,Message Buffer 31"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFD0000+624.)&0x00200000)==0x00200000
group.long ((0xFFFD0000+624.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 31"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFD0000+624.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 31"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFD0000+624.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 31"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 31"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFD0000+640.)++0x03
  line.long    0x00 "MB32,Message Buffer 32"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFD0000+640.)&0x00200000)==0x00200000
group.long ((0xFFFD0000+640.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 32"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFD0000+640.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 32"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFD0000+640.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 32"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 32"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFD0000+656.)++0x03
  line.long    0x00 "MB33,Message Buffer 33"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFD0000+656.)&0x00200000)==0x00200000
group.long ((0xFFFD0000+656.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 33"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFD0000+656.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 33"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFD0000+656.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 33"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 33"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFD0000+672.)++0x03
  line.long    0x00 "MB34,Message Buffer 34"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFD0000+672.)&0x00200000)==0x00200000
group.long ((0xFFFD0000+672.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 34"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFD0000+672.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 34"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFD0000+672.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 34"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 34"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFD0000+688.)++0x03
  line.long    0x00 "MB35,Message Buffer 35"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFD0000+688.)&0x00200000)==0x00200000
group.long ((0xFFFD0000+688.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 35"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFD0000+688.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 35"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFD0000+688.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 35"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 35"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFD0000+704.)++0x03
  line.long    0x00 "MB36,Message Buffer 36"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFD0000+704.)&0x00200000)==0x00200000
group.long ((0xFFFD0000+704.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 36"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFD0000+704.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 36"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFD0000+704.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 36"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 36"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFD0000+720.)++0x03
  line.long    0x00 "MB37,Message Buffer 37"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFD0000+720.)&0x00200000)==0x00200000
group.long ((0xFFFD0000+720.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 37"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFD0000+720.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 37"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFD0000+720.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 37"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 37"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFD0000+736.)++0x03
  line.long    0x00 "MB38,Message Buffer 38"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFD0000+736.)&0x00200000)==0x00200000
group.long ((0xFFFD0000+736.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 38"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFD0000+736.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 38"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFD0000+736.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 38"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 38"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFD0000+752.)++0x03
  line.long    0x00 "MB39,Message Buffer 39"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFD0000+752.)&0x00200000)==0x00200000
group.long ((0xFFFD0000+752.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 39"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFD0000+752.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 39"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFD0000+752.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 39"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 39"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFD0000+768.)++0x03
  line.long    0x00 "MB40,Message Buffer 40"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFD0000+768.)&0x00200000)==0x00200000
group.long ((0xFFFD0000+768.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 40"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFD0000+768.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 40"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFD0000+768.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 40"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 40"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFD0000+784.)++0x03
  line.long    0x00 "MB41,Message Buffer 41"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFD0000+784.)&0x00200000)==0x00200000
group.long ((0xFFFD0000+784.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 41"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFD0000+784.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 41"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFD0000+784.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 41"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 41"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFD0000+800.)++0x03
  line.long    0x00 "MB42,Message Buffer 42"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFD0000+800.)&0x00200000)==0x00200000
group.long ((0xFFFD0000+800.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 42"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFD0000+800.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 42"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFD0000+800.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 42"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 42"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFD0000+816.)++0x03
  line.long    0x00 "MB43,Message Buffer 43"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFD0000+816.)&0x00200000)==0x00200000
group.long ((0xFFFD0000+816.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 43"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFD0000+816.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 43"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFD0000+816.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 43"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 43"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFD0000+832.)++0x03
  line.long    0x00 "MB44,Message Buffer 44"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFD0000+832.)&0x00200000)==0x00200000
group.long ((0xFFFD0000+832.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 44"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFD0000+832.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 44"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFD0000+832.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 44"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 44"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFD0000+848.)++0x03
  line.long    0x00 "MB45,Message Buffer 45"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFD0000+848.)&0x00200000)==0x00200000
group.long ((0xFFFD0000+848.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 45"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFD0000+848.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 45"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFD0000+848.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 45"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 45"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFD0000+864.)++0x03
  line.long    0x00 "MB46,Message Buffer 46"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFD0000+864.)&0x00200000)==0x00200000
group.long ((0xFFFD0000+864.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 46"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFD0000+864.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 46"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFD0000+864.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 46"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 46"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFD0000+880.)++0x03
  line.long    0x00 "MB47,Message Buffer 47"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFD0000+880.)&0x00200000)==0x00200000
group.long ((0xFFFD0000+880.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 47"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFD0000+880.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 47"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFD0000+880.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 47"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 47"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFD0000+896.)++0x03
  line.long    0x00 "MB48,Message Buffer 48"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFD0000+896.)&0x00200000)==0x00200000
group.long ((0xFFFD0000+896.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 48"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFD0000+896.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 48"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFD0000+896.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 48"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 48"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFD0000+912.)++0x03
  line.long    0x00 "MB49,Message Buffer 49"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFD0000+912.)&0x00200000)==0x00200000
group.long ((0xFFFD0000+912.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 49"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFD0000+912.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 49"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFD0000+912.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 49"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 49"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFD0000+928.)++0x03
  line.long    0x00 "MB50,Message Buffer 50"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFD0000+928.)&0x00200000)==0x00200000
group.long ((0xFFFD0000+928.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 50"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFD0000+928.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 50"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFD0000+928.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 50"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 50"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFD0000+944.)++0x03
  line.long    0x00 "MB51,Message Buffer 51"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFD0000+944.)&0x00200000)==0x00200000
group.long ((0xFFFD0000+944.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 51"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFD0000+944.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 51"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFD0000+944.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 51"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 51"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFD0000+960.)++0x03
  line.long    0x00 "MB52,Message Buffer 52"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFD0000+960.)&0x00200000)==0x00200000
group.long ((0xFFFD0000+960.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 52"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFD0000+960.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 52"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFD0000+960.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 52"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 52"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFD0000+976.)++0x03
  line.long    0x00 "MB53,Message Buffer 53"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFD0000+976.)&0x00200000)==0x00200000
group.long ((0xFFFD0000+976.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 53"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFD0000+976.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 53"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFD0000+976.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 53"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 53"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFD0000+992.)++0x03
  line.long    0x00 "MB54,Message Buffer 54"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFD0000+992.)&0x00200000)==0x00200000
group.long ((0xFFFD0000+992.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 54"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFD0000+992.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 54"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFD0000+992.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 54"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 54"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFD0000+1008.)++0x03
  line.long    0x00 "MB55,Message Buffer 55"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFD0000+1008.)&0x00200000)==0x00200000
group.long ((0xFFFD0000+1008.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 55"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFD0000+1008.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 55"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFD0000+1008.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 55"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 55"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFD0000+1024.)++0x03
  line.long    0x00 "MB56,Message Buffer 56"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFD0000+1024.)&0x00200000)==0x00200000
group.long ((0xFFFD0000+1024.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 56"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFD0000+1024.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 56"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFD0000+1024.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 56"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 56"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFD0000+1040.)++0x03
  line.long    0x00 "MB57,Message Buffer 57"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFD0000+1040.)&0x00200000)==0x00200000
group.long ((0xFFFD0000+1040.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 57"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFD0000+1040.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 57"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFD0000+1040.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 57"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 57"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFD0000+1056.)++0x03
  line.long    0x00 "MB58,Message Buffer 58"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFD0000+1056.)&0x00200000)==0x00200000
group.long ((0xFFFD0000+1056.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 58"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFD0000+1056.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 58"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFD0000+1056.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 58"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 58"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFD0000+1072.)++0x03
  line.long    0x00 "MB59,Message Buffer 59"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFD0000+1072.)&0x00200000)==0x00200000
group.long ((0xFFFD0000+1072.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 59"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFD0000+1072.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 59"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFD0000+1072.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 59"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 59"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFD0000+1088.)++0x03
  line.long    0x00 "MB60,Message Buffer 60"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFD0000+1088.)&0x00200000)==0x00200000
group.long ((0xFFFD0000+1088.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 60"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFD0000+1088.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 60"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFD0000+1088.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 60"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 60"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFD0000+1104.)++0x03
  line.long    0x00 "MB61,Message Buffer 61"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFD0000+1104.)&0x00200000)==0x00200000
group.long ((0xFFFD0000+1104.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 61"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFD0000+1104.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 61"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFD0000+1104.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 61"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 61"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFD0000+1120.)++0x03
  line.long    0x00 "MB62,Message Buffer 62"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFD0000+1120.)&0x00200000)==0x00200000
group.long ((0xFFFD0000+1120.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 62"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFD0000+1120.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 62"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFD0000+1120.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 62"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 62"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFD0000+1136.)++0x03
  line.long    0x00 "MB63,Message Buffer 63"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFD0000+1136.)&0x00200000)==0x00200000
group.long ((0xFFFD0000+1136.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 63"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFD0000+1136.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 63"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFD0000+1136.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 63"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 63"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""
tree.end


tree.end

endif

tree.end


sif (cpu()=="MPC5633M")||(cpu()=="MPC5634M")||(cpu()=="SPC563M60")||(cpu()=="SPC563M64")||(CPUIS("MPC5674*"))
tree "Power Management Controller (PMC)"

group.long 0xC3FBC000++0x03
  line.long    0 "PMC_CFGR,Configuration and status register"

group.long 0xC3FBC004++0x03
  line.long    0 "PMC_TRIMR,Trimming register"



tree.end
endif


sif ((cpu()=="MPC5553")||(cpu()=="MPC5566")||(cpu()=="MPC5567"))

tree "Fast Ethernet Controller Registers (FEC)"

tree "Control and Status Registers"

group.long 0xFFF4C004++0x03
  line.long    0x00 "EIR,Ethernet Interrupt Event Register"
  eventfld.long   0x0 31.                  "HBERR   ,Heartbeat Error" "0,1"
  eventfld.long   0x0 30.                "  BABR    ,Babbling Receive Error" "0,1"
  eventfld.long   0x0 29.                "  BABT    ,Babbling Transmit Error" "0,1"
  eventfld.long   0x0 28.                "  GRA     ,Graceful Stop Complete" "0,1"
  eventfld.long   0x0 27.                "  TXF     ,Transmit frame interrupt" "0,1"
  eventfld.long   0x0 26.                "  TXB     ,Transmit buffer interrupt" "0,1"
  eventfld.long   0x0 25.                "  RXF     ,Receive frame interrupt" "0,1"
  eventfld.long   0x0 24.                "  RXB     ,Receive buffer interrupt" "0,1"
TEXTLINE "                " 
  eventfld.long   0x0 23.                "  MII     ,MII Interrupt" "0,1"
  eventfld.long   0x0 22.                "  EBERR   ,Ethernet bus error" "0,1"
  eventfld.long   0x0 21.                "  LC      ,Late collison" "0,1"
  eventfld.long   0x0 20.                "  RL      ,Collision retry limit" "0,1"
  eventfld.long   0x0 19.                "  UN      ,Transmit FIFO underrun" "0,1"
TEXTLINE ""

group.long 0xFFF4C008++0x03
  line.long    0x00 "EIMR,Ethernet Interrupt Mask Register"
  eventfld.long   0x0 31.                  "HBERRM  ,Heartbeat Error" "0,1"
  eventfld.long   0x0 30.                "  BABRM   ,Babbling Receive Error" "0,1"
  eventfld.long   0x0 29.                "  BABTM   ,Babbling Transmit Error" "0,1"
  eventfld.long   0x0 28.                "  GRAM    ,Graceful Stop Complete" "0,1"
  eventfld.long   0x0 27.                "  TXFM    ,Transmit frame interrupt" "0,1"
  eventfld.long   0x0 26.                "  TXBM    ,Transmit buffer interrupt" "0,1"
  eventfld.long   0x0 25.                "  RXFM    ,Receive frame interrupt" "0,1"
  eventfld.long   0x0 24.                "  RXBM    ,Receive buffer interrupt" "0,1"
TEXTLINE "                " 
  eventfld.long   0x0 23.                "  MIIM    ,MII Interrupt" "0,1"
  eventfld.long   0x0 22.                "  EBERRM  ,Ethernet bus error" "0,1"
  eventfld.long   0x0 21.                "  LCM     ,Late collison" "0,1"
  eventfld.long   0x0 20.                "  RLM     ,Collision retry limit" "0,1"
  eventfld.long   0x0 19.                "  UNM     ,Transmit FIFO underrun" "0,1"
TEXTLINE ""

group.long 0xFFF4C010++0x03
  line.long    0x00 "RDAR,Receive Descriptor Active Register"
  bitfld.long   0x0 24.                  "R_DES_ACTIVE  ,Set to one when this register is written, regardless of the value written" "0,1"

group.long 0xFFF4C014++0x03
  line.long    0x00 "TDAR,Transmit Descriptor Active Register"
  bitfld.long   0x0 24.                  "X_DES_ACTIVE  ,Set to one when this register is written, regardless of the value written" "0,1"
TEXTLINE ""

group.long 0xFFF4C024++0x03
  line.long    0x00 "ECR,Ethernet Interrupt Mask Register"
  bitfld.long   0x0 1.                   "ETHER_EN ,When this bit is set, the FEC is enabled" "0,1"
  bitfld.long   0x0 0.                 "  RESET    ,When this bit is set, the equivalent of a hardware reset is performed but it is local to the FEC" "0,1"
TEXTLINE ""

group.long 0xFFF4C040++0x03
  line.long    0x00 "MMFR,MII Management Frame Register"
  bitfld.long   0x0 30.--31.             "ST     ,Start of Frame Delimiter" "0,1,2,3"
  bitfld.long   0x0 28.--29.           "  OP     ,Operation Code"   "0,1,2,3"
  bitfld.long   0x0 23.--27.           "  PA     ,PHY Address"      "00,01,02,03,04,05,06,07,08,09,0A,0B,0C,0D,0E,0F,10,11,12,13,14,15,16,17,18,19,1A,1B,1C,1D,1E,1F"
  bitfld.long   0x0 18.--22.           "  RA     ,Register Address" "00,01,02,03,04,05,06,07,08,09,0A,0B,0C,0D,0E,0F,10,11,12,13,14,15,16,17,18,19,1A,1B,1C,1D,1E,1F"
  bitfld.long   0x0 16.--17.           "  TA     ,Turnaround. Must be programmed to 10 to generate a valid MII management frame" "0,1,2,3"
  hexmask.word  0x2 00.--15. 1. 0.     "  DATA   ,Management Frame Data. Used for data written to or read from PHY register"
TEXTLINE ""

group.long 0xFFF4C044++0x03
  line.long    0x00 "MSCR,MII Speed Control Register"
  bitfld.long    0x0  7.                 "DIS_PREAMBLE ,Asserting this bit causes preamble (32 1s) to not be prepended to the MII management frame." "0,1"
  hexmask.byte   0x3  1.--6.  1. 0.    "  MII_SPEED    ,Controls the frequency of the MII management interface clock (MDC) relative to ipb_clk."
TEXTLINE ""

group.long 0xFFF4C064++0x03
  line.long    0x00 "MIBC,MIB Control Register"
  bitfld.long   0x0 31.                  "MIB_DISABLE  ,If set, the MIB logic will halt and not update any MIB counters." "0,1"
  bitfld.long   0x0 30.                "  MIB_IDLE     ,A read-only status bit. If set the MIB block is not currently updating any MIB counters. Write 1 to clear" "0,1"
TEXTLINE ""

group.long 0xFFF4C084++0x03
  line.long    0x00 "RCR,Receive Control Register"
  hexmask.long.word  0x0  16.--26. 1. 0. "MAX_FL   ,Maximum Frame Length. User R/W Field. Resets to decimal 1518."
  bitfld.long   0x0  5.                "  FCE      ,Flow Control Enablea frames for a given duration." "0,1"
  bitfld.long   0x0  4.                "  BC_REJ   ,Broadcast frame reject" "0,1"
  bitfld.long   0x0  3.                "  PROM     ,Promiscuous mode. All frames are accepted regardless of address matching." "0,1"
  bitfld.long   0x0  2.                "  MII_MODE ,Selects external interface mode. Controls the interface mode for Tx/Rx blocks." "0,1"
  bitfld.long   0x0  1.                "  DRT      ,Disable Receive on Transmit" "0,1"
  bitfld.long   0x0  0.                "  LOOP     ,Internal Loopback to 0 when asserting LOOP." "0,1"
TEXTLINE ""

group.long 0xFFF4C0C4++0x03
  line.long    0x00 "TCR,Transmit Control Register"
  bitfld.long   0x0  4.                "RFC_PAUSE  ,This read-only status bit is asserted when a full duplex flow control pause frame is received." "0,1"
  bitfld.long   0x0  3.              "  TFC_PAUSE  ,Assert to transmit a PAUSE frame." "0,1"
  bitfld.long   0x0  2.              "  FDEN       ,Full Duplex Enable." "0,1"
  bitfld.long   0x0  1.              "  HBC        ,Heartbeat Controldeasserted." "0,1"
  bitfld.long   0x0  0.              "  GTS        ,Graceful Transmit Stopthe GRA interrupt." "0,1"
TEXTLINE ""

group.long 0xFFF4C0E4++0x03
  line.long    0x00 "PALR,Physical Address Low Register"

group.long 0xFFF4C0E8++0x03
  line.long    0x00 "PAUR,Physical Address Upper Register"
TEXTLINE ""

group.long 0xFFF4C0EC++0x03
  line.long    0x00 "OPD,Opcode/Pause Duration Register"
  hexmask.long.word  0x0 16.--32. 1. 0.         "OPCODE     ,Opcode field used in PAUSE frames"
  hexmask.long.word  0x0 00.--15. 1. 0.       "  PAUSE_DUR  ,Pause Duration field used in PAUSE frames"
TEXTLINE ""

group.long 0xFFF4C118++0x03
  line.long    0x00 "IAUR,Descriptor Individual Upper Address Register"

group.long 0xFFF4C11C++0x03
  line.long    0x00 "IALR,Descriptor Individual Lower Address"
TEXTLINE ""

group.long 0xFFF4C120++0x03
  line.long    0x00 "GAUR,Descriptor Group Upper Address"

group.long 0xFFF4C124++0x03
  line.long    0x00 "GALR,Descriptor Group Lower Address"
TEXTLINE ""

group.long 0xFFF4C144++0x03
  line.long    0x00 "TFWR,Transmit FIFO Watermark"
  bitfld.long   0x0  0.--1.              "X_WMRK      ,Number of bytes written to transmit FIFO before transmission of a frame begins" "64(0),64(1),128,192"
TEXTLINE ""

rgroup.long 0xFFF4C14C++0x03
  line.long    0x00 "FRBR,FIFO Receive Bound Register"
  hexmask.word  0x2 02.--09. 1. 0.       "R_BOUND     ,Read-only. Highest valid FIFO RAM address."

group.long 0xFFF4C150++0x03
  line.long    0x00 "FRSR,FIFO Receive Start Register"
  hexmask.word  0x2 02.--09. 1. 0.       "R_FSTART    ,Address of first receive FIFO location."
TEXTLINE ""

group.long 0xFFF4C180++0x03
  line.long    0x00 "ERDSR,Receive Descriptor Ring Start"
  hexmask.long  0x0 02.--31. 1. 0.       "R_DES_START ,Pointer to start of receive buffer descriptor queue."

group.long 0xFFF4C184++0x03
  line.long    0x00 "ETSDR,Transmit Buffer Descriptor Ring Start"
  hexmask.long  0x0 02.--31. 1. 0.       "X_DES_START ,Pointer to start of transmit buffer descriptor queue."
TEXTLINE ""

group.long 0xFFF4C188++0x03
  line.long    0x00 "EMRBR,Receive Buffer Size Register"
  hexmask.word  0x2 04.--10. 1. 0.       "R_BUF_SIZE  ,Receive buffer size."
TEXTLINE ""


tree.end

tree "Other FEC control registers (ECSM)"

group.long 0xFFF40024++0x03
  line.long    0x00 "FBOMCR,FEC Burst Optimization Master Control Register"
  bitfld.long   0x0  31.                "FXSBE0 ,FEC XBAR slave burst enable (FLASH)" "0,1"
  bitfld.long   0x0  30.              "  FXSBE1 ,FEC XBAR slave burst enable (EBI)" "0,1"
  bitfld.long   0x0  29.              "  FXSBE2 ,FEC XBAR slave burst enable (int. SRAM)" "0,1"
  bitfld.long   0x0  26.              "  FXSBE6 ,FEC XBAR slave burst enable (per bridge A)" "0,1"
  bitfld.long   0x0  25.              "  FXSBE7 ,FEC XBAR slave burst enable (per bridge B)" "0,1"
TEXTLINE "                " 
  bitfld.long   0x0  23.              "  RBEN   ,Global read burst enable from XBAR slave port designated by FXSBEn" "0,1"
  bitfld.long   0x0  22.              "  WBEN   ,Global write burst enable to XBAR slave port designated by FXSBEn" "0,1"
  bitfld.long   0x0  21.              "  ACCERR ,Accumulate error" "0,1"

tree.end

width 18.
config 18. 8.

tree "MIB Block Counters"

group.long 0xFFF4C200++0x03
  line.long    0x00 "RMON_T_DROP,Count of frames not counted correctly"

group.long 0xFFF4C204++0x03
  line.long    0x00 "RMON_T_PACKETS,RMON Tx packet count"

group.long 0xFFF4C208++0x03
  line.long    0x00 "RMON_T_BC_PKT,RMON Tx Broadcast Packets"

group.long 0xFFF4C20c++0x03
  line.long    0x00 "RMON_T_MC_PKT,Transmit"

group.long 0xFFF4C210++0x03
  line.long    0x00 "RMON_T_CRC_ALIGN,RMON Tx Packets w CRC/Align error"

group.long 0xFFF4C214++0x03
  line.long    0x00 "RMON_T_UNDERSIZE,RMON Tx Packets < 64 bytes, good crc"

group.long 0xFFF4C218++0x03
  line.long    0x00 "RMON_T_OVERSIZE,RMON Tx Packets > MAX_FL bytes, good crc"

group.long 0xFFF4C21c++0x03
  line.long    0x00 "RMON_T_FRAG,RMON Tx Packets < 64 bytes, bad crc"

group.long 0xFFF4C220++0x03
  line.long    0x00 "RMON_T_JAB,RMON Tx Packets > MAX_FL bytes, bad crc"

group.long 0xFFF4C224++0x03
  line.long    0x00 "RMON_T_COL,RMON Tx collision count"

group.long 0xFFF4C228++0x03
  line.long    0x00 "RMON_T_P64,RMON Tx 64 byte packets"

group.long 0xFFF4C22c++0x03
  line.long    0x00 "RMON_T_P65TO127,RMON Tx 65 to 127 byte packets"
  
group.long 0xFFF4C230++0x03
  line.long    0x00 "RMON_T_P128TO255,RMON Tx 128 to 255 byte packets"

group.long 0xFFF4C234++0x03
  line.long    0x00 "RMON_T_P256TO511,RMON Tx 256 to 511 byte packets"

group.long 0xFFF4C238++0x03
  line.long    0x00 "RMON_T_P512TO1023,RMON Tx 512 to 1023 byte packets"

group.long 0xFFF4C23c++0x03
  line.long    0x00 "RMON_T_P1024TO2047,RMON Tx 1024 to 2047 byte packets"

group.long 0xFFF4C240++0x03
  line.long    0x00 "RMON_T_P_GTE2048,RMON Tx packets w > 2048 bytes"

group.long 0xFFF4C244++0x03
  line.long    0x00 "RMON_T_OCTETS,RMON Tx Octets"

group.long 0xFFF4C248++0x03
  line.long    0x00 "IEEE_T_DROP,Count of frames not counted correctly"

group.long 0xFFF4C24c++0x03
  line.long    0x00 "IEEE_T_FRAME_OK,Frames Transmitted OK"

group.long 0xFFF4C250++0x03
  line.long    0x00 "IEEE_T_1COL,Frames Transmitted with Single Collision"

group.long 0xFFF4C254++0x03
  line.long    0x00 "IEEE_T_MCOL,Frames Transmitted with Multiple Collisions"

group.long 0xFFF4C258++0x03
  line.long    0x00 "IEEE_T_DEF,Frames Transmitted after Deferral Delay"

group.long 0xFFF4C25c++0x03
  line.long    0x00 "IEEE_T_LCOL,Frames Transmitted with Late Collision"

group.long 0xFFF4C260++0x03
  line.long    0x00 "IEEE_T_EXCOL,Frames Transmitted with Excessive Collisions"

group.long 0xFFF4C264++0x03
  line.long    0x00 "IEEE_T_MACERR,Frames Transmitted with Tx FIFO Underrun"

group.long 0xFFF4C268++0x03
  line.long    0x00 "IEEE_T_CSERR,Frames Transmitted with Carrier Sense Error"

group.long 0xFFF4C26c++0x03
  line.long    0x00 "IEEE_T_SQE,Frames Transmitted with SQE Error"

group.long 0xFFF4C270++0x03
  line.long    0x00 "IEEE_T_FDXFC,Flow Control Pause frames transmitted"

group.long 0xFFF4C274++0x03
  line.long    0x00 "IEEE_T_OCTETS_OK,Octet count for Frames Transmitted w/o Error"

TEXTLINE ""

group.long 0xFFF4C284++0x03
  line.long    0x00 "RMON_R_PACKETS,RMON Rx packet count"

group.long 0xFFF4C288++0x03
  line.long    0x00 "RMON_R_BC_PKT,RMON Rx Broadcast Packets"

group.long 0xFFF4C28c++0x03
  line.long    0x00 "RMON_R_MC_PKT,RMON Rx Multicast Packets"

group.long 0xFFF4C290++0x03
  line.long    0x00 "RMON_R_CRC_ALIGN,RMON Rx Packets w CRC/Align error"

group.long 0xFFF4C294++0x03
  line.long    0x00 "RMON_R_UNDERSIZE,RMON Rx Packets < 64 bytes, good crc"

group.long 0xFFF4C298++0x03
  line.long    0x00 "RMON_R_OVERSIZE,RMON Rx Packets > MAX_FL bytes, good crc"

group.long 0xFFF4C29c++0x03
  line.long    0x00 "RMON_R_FRAG,RMON Rx Packets < 64 bytes, bad crc"

group.long 0xFFF4C2a0++0x03
  line.long    0x00 "RMON_R_JAB,RMON Rx Packets > MAX_FL bytes, bad crc"

group.long 0xFFF4C2a4++0x03
  line.long    0x00 "RMON_R_RESVD_0,RMON reserved"

group.long 0xFFF4C2a8++0x03
  line.long    0x00 "RMON_R_P64,RMON Rx 64 byte packets"

group.long 0xFFF4C2ac++0x03
  line.long    0x00 "RMON_R_P65TO127,RMON Rx 65 to 127 byte packets"
  
group.long 0xFFF4C2b0++0x03
  line.long    0x00 "RMON_R_P128TO255,RMON Rx 128 to 255 byte packets"

group.long 0xFFF4C2b4++0x03
  line.long    0x00 "RMON_R_P256TO511,RMON Rx 256 to 511 byte packets"

group.long 0xFFF4C2b8++0x03
  line.long    0x00 "RMON_R_P512TO1023,RMON Rx 512 to 1023 byte packets"

group.long 0xFFF4C2bc++0x03
  line.long    0x00 "RMON_R_P1024TO2047,RMON Rx 1024 to 2047 byte packets"

group.long 0xFFF4C2c0++0x03
  line.long    0x00 "RMON_R_P_GTE2048,RMON Rx packets w > 2048 bytes"

group.long 0xFFF4C2c4++0x03
  line.long    0x00 "RMON_R_OCTETS,RMON Rx Octets"

group.long 0xFFF4C2c8++0x03
  line.long    0x00 "IEEE_R_DROP,Count of frames not counted correctly"

group.long 0xFFF4C2cc++0x03
  line.long    0x00 "IEEE_R_FRAME_OK,Frames Received OK"

group.long 0xFFF4C2d0++0x03
  line.long    0x00 "IEEE_R_CRC,Frames Received with CRC Error"

group.long 0xFFF4C2d4++0x03
  line.long    0x00 "IEEE_R_ALIGN,Frames Received with Alignment Error"

group.long 0xFFF4C2d8++0x03
  line.long    0x00 "IEEE_R_MACERR,Receive Fifo Overflow count"

group.long 0xFFF4C2dc++0x03
  line.long    0x00 "IEEE_R_FDXFC,Flow Control Pause frames received"

group.long 0xFFF4C2e0++0x03
  line.long    0x00 "IEEE_R_OCTETS_OK,Octet count for Frames Rcvd w/o Error"

tree.end

width 9.
config 9. 8.

tree.end




endif


sif (cpu()=="MPC5561")||(cpu()=="MPC5567")||(CPUIS("MPC5674*"))

width 11.
config 11. 8.

tree "FlexRay"

  tree "Module Configuration and Control"

    group.word (0xFFFE0000+0x0000)++0x01
      line.word 0 "MVR,Module Version Register"
      hexmask.byte 0 0.--7. 1.   "CHIVER ,Module Version Number"
      hexmask.byte 1 0.--7. 1. "  PEVER  ,Minor Release Number"

    group.word (0xFFFE0000+0x0002)++0x01
      line.word 0 "MCR,Module Configuration Register"
      bitfld.word  0 15.         "MEN  ,Module Enable" "0,1"
      bitfld.word  0 13.       "  SCM  ,Single Channel Mode" "0,1"
      bitfld.word  0 12.       "  CHB  ,FlexRay Channel B Enable" "0,1"
      bitfld.word  0 11.       "  CHA  ,FlexRay Channel A Enable" "0,1"
      bitfld.word  0 10.       "  SFFE ,Synchronization Frame Filter Enable" "0,1"
      bitfld.word  0 04.       "  CLKSEL ,Protocol Engine Clock Source Select" "0,1"
      bitfld.word  0 01.--03.  "  PRESCALE ,Protocol Engine Clock Prescaler" "1,2,4,6,8,10,12,14"

    group.word (0xFFFE0000+0x0004)++0x01
      line.word 0 "SYMBADHR,System Memory Base Address High Register"

    group.word (0xFFFE0000+0x0006)++0x01
      line.word 0 "SYMBADLR,System Memory Base Address Low Register"

    group.word (0xFFFE0000+0x0008)++0x01
      line.word 0 "STBSCR,Strobe Signal Control Register"
      bitfld.word  0 15.         "WMD  ,Write Mode" "0,1"
      bitfld.word  0 08.--14.   "  SEL ,Strobe Signal Select" "pocstate[0],pocstate[1],pocstate[2],pocstate[3],pocstate[4],pocstate[5],pocstate[6],channel idle indicator A,channel idle indicator B,receive data after glitch filtering A,receive data after glitch filtering B,synchronization edge strobe A,synchronization edge strobe B,header received A,header received B,wakeup symbol decoded A,wakeup symbol decoded B,MTS or CAS symbol decoded A,MTS or CAS symbol decoded B,frame decoded A,frame decoded B,channel idle detected A,channel idle detected B,potential frame start channel A,potential frame start channel B,wakeup collision detected A,wakeup collision detected B,content error detected A,content error detected B,syntax error detected A,syntax error detected B,start transmission of wakeup pattern A,start transmission of wakeup pattern B,start transmission of MTS or CAS symbol A,start transmission of MTS or CAS symbol B,start of transmission A,start of transmission B,end of transmission A,end of transmission B,static segment indicator,dynamic segment indicator,symbol window indicator,NIT indicator,action point,sync calculation complete,start of offset correction,cycle count[0],cycle count[1],cycle count[2],cycle count[3],cycle count[4],cycle count[5],slot count[0] A,slot count[1] A,slot count[2] A,slot count[3] A,slot count[4] A,slot count[5] A,slot count[6] A,slot count[7] A,slot count[8] A,slot count[9] A,slot count[10] A,slot count[0] B,slot count[1] B,slot count[2] B,slot count[3] B,slot count[4] B,slot count[5] B,slot count[6] B,slot count[7] B,slot count[8] A,slot count[9] B,slot count[10] B,cycle start,slot start A,slot start B,minislot start,arm,mt"
      TEXTLINE "              "
      bitfld.word  0 04.        "  ENB  ,Strobe Signal Enable" "0,1"
      bitfld.word  0 00.--01.   "  STBPSEL  ,Strobe Port Select" "STB0,STB1,STB2,STB3"

    group.word (0xFFFE0000+0x000A)++0x01
      line.word 0 "STBPCR,Strobe Port Control Register"
      bitfld.word  0 03.           "STB3EN ,Strobe Port STB3 Enable" "0,1"
      bitfld.word  0 02.         "  STB2EN ,Strobe Port STB2 Enable" "0,1"
      bitfld.word  0 01.         "  STB1EN ,Strobe Port STB1 Enable" "0,1"
      bitfld.word  0 00.         "  STB0EN ,Strobe Port STB0 Enable" "0,1"

    group.word (0xFFFE0000+0x000C)++0x01
      line.word 0 "MBDSR,Message Buffer Data Size Register"
      hexmask.byte 0 0.--6. 1.     "MBSEG2DS      ,Message Buffer Segment 2 Data Size"
      hexmask.byte 1 0.--6. 1.   "  MBSEG1DS      ,Message Buffer Segment 1 Data Size"

    group.word (0xFFFE0000+0x000E)++0x01
      line.word 0 "MBSSUTR,Message Buffer Segment Size and Utilization Register"
      hexmask.byte 0 0.--6. 1.     "LAST_MB_SEG1  ,Last Message Buffer In Segment 1"
      hexmask.byte 1 0.--6. 1.   "  LAST_MB_UTIL  ,Last Message Buffer Utilized"

  tree.end

  tree "Interrupt and Error Handling"

    group.word (0xFFFE0000+0x0014)++0x01
      line.word 0 "POCR,Protocol Operation Control Register"
      bitfld.word  0 15.           "WME ,Write Mode External Correction" "0,1"
      bitfld.word  0 10.--11.    "  EOC_AP  ,External Offset Correction Application" "add,sub,res,off"
      bitfld.word  0 08.--09.    "  ERC_AP  ,External Rate Correction Application" "add,sub,res,off"
      bitfld.word  0 07.         "  BSY/WMC ,Busy(r) / Write Mode Command(w)" "0,1"
      bitfld.word  0 00.--03.    "  POCCMD  ,Protocol Command" "ALLOW_COLDSTART,ALL_SLOTS,CONFIG,FREEZE,READY,RUN,DEF_CNF,HALT,WAKEUP,res.,res.,res.,RESET,res.,res.,res."

    group.word (0xFFFE0000+0x0016)++0x01
      line.word 0 "GIFER,Global Interrupt Flag and Enable Register"
      bitfld.word  0 15.           "MIF     ,Module Interrupt Flag" "0,1"
      bitfld.word  0 14.         "  PRIF    ,Protocol Interrupt Flag" "0,1"
      bitfld.word  0 13.         "  CHIF    ,Protocol Interrupt Flag" "0,1"
      bitfld.word  0 12.         "  WUPIF   ,Protocol Interrupt Flag" "0,1"
      bitfld.word  0 11.         "  FNEBIF  ,Protocol Interrupt Flag" "0,1"
      bitfld.word  0 10.         "  FNEAIF  ,Protocol Interrupt Flag" "0,1"
      bitfld.word  0 09.         "  RBIF    ,Protocol Interrupt Flag" "0,1"
      bitfld.word  0 08.         "  TBIF    ,Protocol Interrupt Flag" "0,1"
      TEXTLINE "              "
      bitfld.word  0 07.         "  MIE     ,Protocol Interrupt Flag" "0,1"
      bitfld.word  0 06.         "  PRIE    ,Module Interrupt Enable" "0,1"
      bitfld.word  0 05.         "  CHIE    ,CHI Interrupt Enable" "0,1"
      bitfld.word  0 04.         "  WUPIE   ,Wakeup Interrupt Enable" "0,1"
      bitfld.word  0 03.         "  FNEBIE  ,Receive FIFO channel B Not Empty Interrupt Enable" "0,1"
      bitfld.word  0 02.         "  FNEAIE  ,Receive FIFO channel A Not Empty Interrupt Enable" "0,1"
      bitfld.word  0 01.         "  RBIE    ,Receive Buffer Interrupt Enable" "0,1"
      bitfld.word  0 00.         "  TBIE    ,Transmit Interrupt Enable" "0,1"

    group.word (0xFFFE0000+0x0018)++0x01
      line.word 0 "PIFR0,Protocol Interrupt Flag Register 0"
      bitfld.word  0 15.           "FATL_IF ,Fatal Protocol Error Interrupt Flag" "0,1"
      bitfld.word  0 14.         "  INTL_IF ,Internal Protocol Error Interrupt Flag" "0,1"
      bitfld.word  0 13.         "  ILCF_IF ,Illegal Protocol Configuration Interrupt Flag" "0,1"
      bitfld.word  0 12.         "  CSA_IF  ,Cold Start Abort Interrupt Flag" "0,1"
      bitfld.word  0 11.         "  MRC_IF  ,Missing Rate Correction Interrupt Flag" "0,1"
      bitfld.word  0 10.         "  MOC_IF  ,Missing Offset Correction Interrupt Flag" "0,1"
      bitfld.word  0 09.         "  CCL_IF  ,Clock Correction Limit Reached Interrupt Flag" "0,1"
      bitfld.word  0 08.         "  MXS_IF  ,Max Sync Frames Detected Interrupt Flag" "0,1"
      TEXTLINE "              "
      bitfld.word  0 07.         "  MTX_IF  ,Module Interrupt Flag" "0,1"
      bitfld.word  0 06.         "  LTXB_IF ,Module Interrupt Flag" "0,1"
      bitfld.word  0 05.         "  LTXA_IF ,Module Interrupt Flag" "0,1"
      bitfld.word  0 04.         "  TBVB_IF ,Module Interrupt Flag" "0,1"
      bitfld.word  0 03.         "  TBVA_IF ,Module Interrupt Flag" "0,1"
      bitfld.word  0 02.         "  TI2_IF  ,Module Interrupt Flag" "0,1"
      bitfld.word  0 01.         "  TI1_IF  ,Module Interrupt Flag" "0,1"
      bitfld.word  0 00.         "  CYS_IF  ,Module Interrupt Flag" "0,1"

    group.word (0xFFFE0000+0x001A)++0x01
      line.word 0 "PIFR1,Protocol Interrupt Flag Register 1"
      bitfld.word  0 15.           "EMC_IF  ,Fatal Protocol Error Interrupt Flag" "0,1"
      bitfld.word  0 14.         "  IPC_IF  ,Internal Protocol Error Interrupt Flag" "0,1"
      bitfld.word  0 13.         "  PECF_IF ,Internal Protocol Error Interrupt Flag" "0,1"
      bitfld.word  0 12.         "  PSC_IF  ,Internal Protocol Error Interrupt Flag" "0,1"
      bitfld.word  0 11.         "  SSI3_IF  ,Internal Protocol Error Interrupt Flag" "0,1"
      bitfld.word  0 10.         "  SSI2_IF  ,Internal Protocol Error Interrupt Flag" "0,1"
      bitfld.word  0 09.         "  SSI1_IF  ,Internal Protocol Error Interrupt Flag" "0,1"
      bitfld.word  0 08.         "  SSI0_IF  ,Internal Protocol Error Interrupt Flag" "0,1"
      TEXTLINE "              "
      bitfld.word  0 05.         "  EVT_IF  ,Even Cycle Table Written Interrupt Flag" "0,1"
      bitfld.word  0 04.         "  ODT_IF  ,Odd Cycle Table Written Interrupt Flag" "0,1"

    group.word (0xFFFE0000+0x001C)++0x01
      line.word 0 "PIER0,Protocol Interrupt Enable Register 0"
      bitfld.word  0 15.           "FATL_IE ,Fatal Protocol Error Interrupt Enable" "0,1"
      bitfld.word  0 14.         "  INTL_IE ,Internal Protocol Error Interrupt Enable" "0,1"
      bitfld.word  0 13.         "  ILCF_IE ,Illegal Protocol Configuration Interrupt Enable" "0,1"
      bitfld.word  0 12.         "  CSA_IE  ,Cold Start Abort Interrupt Enable" "0,1"
      bitfld.word  0 11.         "  MRC_IE  ,Missing Rate Correction Interrupt Enable" "0,1"
      bitfld.word  0 10.         "  MOC_IE  ,Missing Offset Correction Interrupt Enable" "0,1"
      bitfld.word  0 09.         "  CCL_IE  ,Clock Correction Limit Reached Interrupt Enable" "0,1"
      bitfld.word  0 08.         "  MXS_IE  ,Max Sync Frames Detected Interrupt Enable" "0,1"
      TEXTLINE "              "
      bitfld.word  0 07.         "  MTX_IE  ,Module Interrupt Enable" "0,1"
      bitfld.word  0 06.         "  LTXB_IE ,Module Interrupt Enable" "0,1"
      bitfld.word  0 05.         "  LTXA_IE ,Module Interrupt Enable" "0,1"
      bitfld.word  0 04.         "  TBVB_IE ,Module Interrupt Enable" "0,1"
      bitfld.word  0 03.         "  TBVA_IE ,Module Interrupt Enable" "0,1"
      bitfld.word  0 02.         "  TI2_IE  ,Module Interrupt Enable" "0,1"
      bitfld.word  0 01.         "  TI1_IE  ,Module Interrupt Enable" "0,1"
      bitfld.word  0 00.         "  CYS_IE  ,Module Interrupt Enable" "0,1"

    group.word (0xFFFE0000+0x001E)++0x01
      line.word 0 "PIER1,Protocol Interrupt Enable Register 1"
      bitfld.word  0 15.           "EMC_IE  ,Fatal Protocol Error Interrupt Enable" "0,1"
      bitfld.word  0 14.         "  IPC_IE  ,Internal Protocol Error Interrupt Enable" "0,1"
      bitfld.word  0 13.         "  PECF_IE ,Internal Protocol Error Interrupt Enable" "0,1"
      bitfld.word  0 12.         "  PSC_IE  ,Internal Protocol Error Interrupt Enable" "0,1"
      bitfld.word  0 11.         "  SSI3_IE ,Internal Protocol Error Interrupt Enable" "0,1"
      bitfld.word  0 10.         "  SSI2_IE ,Internal Protocol Error Interrupt Enable" "0,1"
      bitfld.word  0 09.         "  SSI1_IE ,Internal Protocol Error Interrupt Enable" "0,1"
      bitfld.word  0 08.         "  SSI0_IE ,Internal Protocol Error Interrupt Enable" "0,1"
      TEXTLINE "              "
      bitfld.word  0 05.         "  EVT_IE  ,Even Cycle Table Written Interrupt Enable" "0,1"
      bitfld.word  0 04.         "  ODT_IE  ,Odd Cycle Table Written Interrupt Enable" "0,1"

    group.word (0xFFFE0000+0x0020)++0x01
      line.word 0 "CHIERFR,CHI Error Flag Register"
      bitfld.word  0 15.           "FRLB_EF ,Fatal Protocol Error Interrupt Enable" "0,1"
      bitfld.word  0 14.         "  FRLA_EF ,Frame Lost Channel A Error Flag" "0,1"
      bitfld.word  0 13.         "  PCMI_EF ,Protocol Command Ignored Error Flag" "0,1"
      bitfld.word  0 12.         "  FOVB_EF ,Receive FIFO Overrun Channel B Error Flag" "0,1"
      bitfld.word  0 11.         "  FOVA_EF ,Receive FIFO Overrun Channel A Error Flag" "0,1"
      bitfld.word  0 10.         "  MSB_EF  ,Message Buffer Search Error Flag" "0,1"
      bitfld.word  0 09.         "  MBU_EF  ,Message Buffer Utilization Error Flag" "0,1"
      bitfld.word  0 08.         "  LCK_EF  ,Lock Error Flag" "0,1"
      TEXTLINE "              "
      bitfld.word  0 07.         "  DBL_EF  ,Double Transmit Message Buffer Lock Error Flag" "0,1"
      bitfld.word  0 06.         "  SBCF_EF ,System Bus Communication Failure Error Flag" "0,1"
      bitfld.word  0 05.         "  FID_EF  ,Frame ID Error Flag" "0,1"
      bitfld.word  0 04.         "  DPL_EF  ,Dynamic Payload Length Error Flag" "0,1"
      bitfld.word  0 03.         "  SPL_EF  ,Static Payload Length Error Flag" "0,1"
      bitfld.word  0 02.         "  NML_EF  ,Network Management Length Error Flag" "0,1"
      bitfld.word  0 01.         "  NMF_EF  ,Network Management Frame Error Flag" "0,1"
      bitfld.word  0 00.         "  ILSA_EF ,Illegal System Memory Access Error Flag" "0,1"

    group.word (0xFFFE0000+0x0022)++0x01
      line.word 0 "MBIVEC,Message Buffer Interrupt Vector Register"
      hexmask.byte 0 0.--1. 1.     "TBIVEC      ,Transmit Buffer Interrupt Vector"
      hexmask.byte 1 0.--1. 1.   "  RBIVEC      ,Receive Buffer Interrupt Vector"

    group.word (0xFFFE0000+0x0024)++0x01
      line.word 0 "CASERCR,Channel A Status Error Counter Register"

    group.word (0xFFFE0000+0x0026)++0x01
      line.word 0 "CBSERCR,Channel B Status Error Counter Register"

  tree.end

  tree "Protocol Status"

    group.word (0xFFFE0000+0x0028)++0x01
      line.word 0 "PSR0,Protocol Status Register 0"
      bitfld.word  0 14.--15.      "ERRMODE   ,Error Mode" "ACTIVE,PASSIVE,COMM_HALT,res."
      bitfld.word  0 12.--13.    "  SLOTMODE  ,Slot Mode" "SINGLE,ALL_PENDING,ALL,res."
      TEXTLINE "              "
      bitfld.word  0 08.--10.    "  PROTSTATE ,Protocol State" "default config,config,wakeup,ready,normal passive,normal active,halt,startup"
      bitfld.word  0 04.--07.    "  STARTUPSTATE  ,Startup State" "res.,res.,coldstart collision,coldstart listen,integration consistency,integrationi listen,res.,initialize schedule,res.,res.,coldstart consistency,res.,res.,integration coldstart,coldstart gap,coldstart join"
      TEXTLINE "              "
      bitfld.word  0 00.--02.    "  WAKEUPSTATUS  ,Wakeup Status" "res.,RECEIVED_HEADER,RECEIVED_WUP,COLLISION_HEADER,COLLISION_WUP,COLLISION_UNKNOWN,TRANSMITTED,res."

    group.word (0xFFFE0000+0x002A)++0x01
      line.word 0 "PSR1,Protocol Status Register 1"
      bitfld.word  0 15.           "CSAA  ,Cold Start Attempt Aborted Flag" "0,1"
      bitfld.word  0 14.         "  CSP   ,Leading Cold Start Path" "0,1"
      bitfld.word  0 08.--11.    "  REMCSAT  ,Remaining Coldstart Attempts" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
      bitfld.word  0 07.         "  CPN   ,Leading Cold Start Path Noise" "0,1"
      bitfld.word  0 06.         "  HHR   ,Host Halt Request Pending" "0,1"
      bitfld.word  0 05.         "  FRZ   ,Freeze Occurred" "0,1"
      bitfld.word  0 00.--04.    "  APTAC ,Allow Passive to Active Counter" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"

    group.word (0xFFFE0000+0x002C)++0x01
      line.word 0 "PSR2,Protocol Status Register 2"
      bitfld.word  0 15.           "NBVB  ,NIT Boundary Violation on Channel B" "0,1"
      bitfld.word  0 14.         "  NSEB  ,NIT Syntax Error on Channel B" "0,1"
      bitfld.word  0 13.         "  STCB  ,Symbol Window Transmit Conflict on Channel B" "0,1"
      bitfld.word  0 12.         "  SBVB  ,Symbol Window Boundary Violation on Channel B" "0,1"
      bitfld.word  0 11.         "  SSEB  ,Symbol Window Syntax Error on Channel B" "0,1"
      bitfld.word  0 10.         "  MTB   ,Media Access Test Symbol MTS Received on Channel B" "0,1"
      bitfld.word  0 09.         "  NBVA  ,NIT Boundary Violation on Channel A" "0,1"
      TEXTLINE "              "
      bitfld.word  0 08.         "  NSEA  ,NIT Syntax Error on Channel A" "0,1"
      bitfld.word  0 07.         "  STCA  ,Symbol Window Transmit Conflict on Channel A" "0,1"
      bitfld.word  0 06.         "  SBVA  ,Symbol Window Boundary Violation on Channel A" "0,1"
      bitfld.word  0 05.         "  SSEA  ,Symbol Window Syntax Error on Channel A" "0,1"
      bitfld.word  0 04.         "  MTA   ,Media Access Test Symbol MTS Received on Channel A" "0,1"
      bitfld.word  0 00.--03.    "  CLKCORRFAILCNT ,Clock Correction Failed Counter" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

    group.word (0xFFFE0000+0x002E)++0x01
      line.word 0 "PSR3,Protocol Status Register 3"
      bitfld.word  0 13.           "WUB   ,Wakeup Symbol Received on Channel B" "0,1"
      bitfld.word  0 12.         "  ABVB  ,Aggregated Boundary Violation on Channel B" "0,1"
      bitfld.word  0 11.         "  AACB  ,Aggregated Additional Communication on Channel B" "0,1"
      bitfld.word  0 10.         "  ACEB  ,Aggregated Content Error on Channel B" "0,1"
      bitfld.word  0 09.         "  ASEB  ,Aggregated Syntax Error on Channel B" "0,1"
      bitfld.word  0 08.         "  AVFB  ,Aggregated Valid Frame on Channel B" "0,1"
      TEXTLINE "              "
      bitfld.word  0 05.         "  WUA   ,Wakeup Symbol Received on Channel A" "0,1"
      bitfld.word  0 04.         "  ABVA  ,Aggregated Boundary Violation on Channel A" "0,1"
      bitfld.word  0 03.         "  AACA  ,Aggregated Additional Communication on Channel A" "0,1"
      bitfld.word  0 02.         "  ACEA  ,Aggregated Content Error on Channel A" "0,1"
      bitfld.word  0 01.         "  ASEA  ,Aggregated Syntax Error on Channel A" "0,1"
      bitfld.word  0 00.         "  AVFA  ,Aggregated Valid Frame on Channel A" "0,1"

TEXTLINE ""

    group.word (0xFFFE0000+0x0030)++0x01
      line.word 0 "MTCTR,Macrotick Counter Register"

    group.word (0xFFFE0000+0x0032)++0x01
      line.word 0 "CYCTR,Cycle Counter Register"

    group.word (0xFFFE0000+0x0034)++0x01
      line.word 0 "SLTCAR,Slot Counter Channel A Register"

    group.word (0xFFFE0000+0x0036)++0x01
      line.word 0 "SLTCBR,Slot Counter Channel B Register"

    group.word (0xFFFE0000+0x0038)++0x01
      line.word 0 "RTCORVR,Rate Correction Value Register"

    group.word (0xFFFE0000+0x003A)++0x01
      line.word 0 "OFCORVR,Offset Correction Value Register"
TEXTLINE ""


    group.word (0xFFFE0000+0x003C)++0x01
      line.word 0 "CIFRR,Combined Interrupt Flag Register"
      bitfld.word  0 07.           "MIF     ,Module Interrupt Flag" "0,1"
      bitfld.word  0 06.         "  PRIF    ,Protocol Interrupt Flag" "0,1"
      bitfld.word  0 05.         "  CHIF    ,CHI Interrupt Flag" "0,1"
      bitfld.word  0 04.         "  WUPIF   ,Wakeup Interrupt Flag" "0,1"
      TEXTLINE "              "
      bitfld.word  0 03.         "  FNEBIF  ,Receive FIFO channel B Not Empty Interrupt Flag" "0,1"
      bitfld.word  0 02.         "  FNEAIF  ,Receive FIFO channel A Not Empty Interrupt Flag" "0,1"
      bitfld.word  0 01.         "  RBIF    ,Receive Message Buffer Interrupt Flag" "0,1"
      bitfld.word  0 00.         "  TBIF    ,Transmit Message Buffer Interrupt Flag" "0,1"

  tree.end

  tree "Sync Frame"

    group.word (0xFFFE0000+0x0040)++0x01
      line.word 0 "SFCNTR,Sync Frame Counter Register"
      bitfld.word 0 12.--15. 1.   "SFEVB ,Sync Frames Channel B, even cycle" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
      bitfld.word 0 08.--11. 1. "  SFEVA ,Sync Frames Channel A, even cycle" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
      bitfld.word 0 04.--07. 1. "  SFODB ,Sync Frames Channel B, odd cycle" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
      bitfld.word 0 00.--03. 1. "  SFODA ,Sync Frames Channel A, odd cycle" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"


    group.word (0xFFFE0000+0x0042)++0x01
      line.word 0 "SFTOR,Sync Frame Table Offset Register"

    group.word (0xFFFE0000+0x0044)++0x01
      line.word 0 "SFTCCSR,Sync Frame Table Configuration, Control, Status Register"
      bitfld.word  0 15.           "ELKT    ,Even Cycle Tables Lock/Unlock Trigger" "0,1"
      bitfld.word  0 14.         "  OLKT    ,Odd Cycle Tables Lock/Unlock Trigger" "0,1"
      hexmask.byte 0 00.--05. 1. "  CYCNUM  ,Cycle Number"
      TEXTLINE "              "
      bitfld.word  0 07.         "  ELKS    ,Even Cycle Tables Lock Status" "0,1"
      bitfld.word  0 06.         "  OLKS    ,Odd Cycle Tables Lock Status" "0,1"
      bitfld.word  0 05.         "  EVAL    ,Even Cycle Tables Valid" "0,1"
      bitfld.word  0 04.         "  OVAL    ,Odd Cycle Tables Valid" "0,1"
      TEXTLINE "              "
      bitfld.word  0 02.         "  OPT     ,One Pair Trigger" "0,1"
      bitfld.word  0 01.         "  SDVEN   ,Sync Frame Deviation Table Enable" "0,1"
      bitfld.word  0 00.         "  SIDEN   ,Sync Frame ID Table Enable" "0,1"

    group.word (0xFFFE0000+0x0046)++0x01
      line.word 0 "SFIDAFMR,Sync Frame ID Rejection Filter Register"

    group.word (0xFFFE0000+0x0048)++0x01
      line.word 0 "SFIDAFVR,Sync Frame ID Acceptance Filter Value Register"

    group.word (0xFFFE0000+0x004A)++0x01
      line.word 0 "SFIDAFMR,Sync Frame ID Rejection Filter Register"


  tree.end

  tree "Network Management Vector"

    group.word (0xFFFE0000+0x004C)++0x01
      line.word 0 "NMVR0,Network Management Vector Register 0"
      hexmask.byte 0 0.--7. 1.     "NMV0  ,Received Payload NMV0"
      hexmask.byte 1 0.--7. 1.   "  NMV1  ,Received Payload NMV1"

    group.word (0xFFFE0000+0x004E)++0x01
      line.word 0 "NMVR1,Network Management Vector Register 1"
      hexmask.byte 0 0.--7. 1.     "NMV2  ,Received Payload NMV2"
      hexmask.byte 1 0.--7. 1.   "  NMV3  ,Received Payload NMV3"

    group.word (0xFFFE0000+0x0050)++0x01
      line.word 0 "NMVR2,Network Management Vector Register 2"
      hexmask.byte 0 0.--7. 1.     "NMV4  ,Received Payload NMV4"
      hexmask.byte 1 0.--7. 1.   "  NMV5  ,Received Payload NMV5"

    group.word (0xFFFE0000+0x0052)++0x01
      line.word 0 "NMVR3,Network Management Vector Register 3"
      hexmask.byte 0 0.--7. 1.     "NMV6  ,Received Payload NMV6"
      hexmask.byte 1 0.--7. 1.   "  NMV7  ,Received Payload NMV7"

    group.word (0xFFFE0000+0x0054)++0x01
      line.word 0 "NMVR4,Network Management Vector Register 4"
      hexmask.byte 0 0.--7. 1.     "NMV8  ,Received Payload NMV8"
      hexmask.byte 1 0.--7. 1.   "  NMV9  ,Received Payload NMV9"

    group.word (0xFFFE0000+0x0056)++0x01
      line.word 0 "NMVR5,Network Management Vector Register 5"
      hexmask.byte 0 0.--7. 1.     "NMV10 ,Received Payload NMV10"
      hexmask.byte 1 0.--7. 1.   "  NMV11 ,Received Payload NMV11"

    group.word (0xFFFE0000+0x0058)++0x01
      line.word 0 "NMVLR,Network Management Vector Length Register"
      bitfld.word 0 00.--03. 1.   "SFEVB ,Sync Frames Channel B, even cycle" "0,1,2,3,4,5,6,7,8,9,10,11,12,res(13),res(14),res(15)"

  tree.end

  tree "Timer Configuration"

    group.word (0xFFFE0000+0x005A)++0x01
      line.word 0 "TICCR,Timer Configuration and Control Register"
      bitfld.word  0 13.           "T2_CFG ,Timer T2 Configuration" "absolute,relative"
      bitfld.word  0 12.         "  T2_REP ,Timer T2 Repetitive Mode" "non-rep,rep"
      bitfld.word  0 10.         "  T2SP ,Timer T2 Stop" "none,stop timer 2"
      bitfld.word  0 09.         "  T2TR ,Timer T2 Trigger" "none,start timer 2"
      bitfld.word  0 08.         "  T2ST ,Timer T2 State" "idle,running"
      TEXTLINE "              "
      bitfld.word  0 04.         "                   T1_REP ,Timer T1 Repetitive Mode" "non-rep,rep"
      bitfld.word  0 02.         "  T1SP ,Timer T1 Stop" "none,stop timer 1"
      bitfld.word  0 01.         "  T1TR ,Timer T1 Trigger" "none,start timer 1"
      bitfld.word  0 00.         "  T1ST ,Timer T1 State" "idle,running"


    group.word (0xFFFE0000+0x005C)++0x01
      line.word 0 "TI1CYSR,Timer 1 Cycle Set Register"
      hexmask.byte 0 0.--5. 1.     "T1_CYC_VAL  ,Timer T1 Cycle Filter Value"
      hexmask.byte 1 0.--5. 1.   "  T1_CYC_MSK  ,Timer T1 Cycle Filter Mask"

    group.word (0xFFFE0000+0x005E)++0x01
      line.word 0 "TI1MTOR,Timer 1 Macrotick Offset Register"

    group.word (0xFFFE0000+0x0060)++0x01
      line.word 0 "TI2CR0,Timer 2 Configuration Register 0"
      hexmask.byte 0 0.--5. 1.     "T2_CYC_VAL  ,Timer T2 Cycle Filter Value"
      hexmask.byte 1 0.--5. 1.   "  T2_CYC_MSK  ,Timer T2 Cycle Filter Mask"

    group.word (0xFFFE0000+0x0062)++0x01
      line.word 0 "TI2CR1,Timer 2 Configuration Register 1"

  tree.end

  tree "Slot Status"

    group.word (0xFFFE0000+0x0064)++0x01
      line.word 0 "SSSR,Slot Status Selection Register"
      bitfld.word  0 15.            "WMD  ,Write Mode" "0,1"
      bitfld.word  0 12.--13.     "  SEL  ,Selector" "SSSR0,SSSR1,SSSR2,SSSR3"
      hexmask.word 0 0.--10. 1.   "  SLOTNUMBER  ,Slot Number"

    group.word (0xFFFE0000+0x0066)++0x01
      line.word 0 "SSCCR,Slot Status Counter Condition Register"
      bitfld.word  0 15.            "WMD  ,Write Mode" "0,1"
      bitfld.word  0 12.--13.     "  SEL  ,Selector" "SSSR0,SSSR1,SSSR2,SSSR3"
      bitfld.word  0 09.--10.     "  CNTCFG ,Counter Configuration" "+1 on A,+1 on B,+1 on A|B,+1 on A^B/+2 on A&B"
      bitfld.word  0 08.          "  MCY  ,Multi Cycle Selection" "0,1"
      TEXTLINE "              "
      bitfld.word  0 07.          "  VFR  ,Valid Frame Restriction" "0,1"
      bitfld.word  0 06.          "  SYF  ,Sync Frame Restriction" "0,1"
      bitfld.word  0 05.          "  NUF  ,Null Frame Restriction" "0,1"
      bitfld.word  0 04.          "  SUF  ,Startup Frame Restriction" "0,1"
      bitfld.word  0 03.          "  SM3  ,Slot Status Mask (syntax error)" "0,1"
      bitfld.word  0 02.          "  SM2  ,Slot Status Mask (content error)" "0,1"
      bitfld.word  0 01.          "  SM1  ,Slot Status Mask (boundary violation)" "0,1"
      bitfld.word  0 00.          "  SM0  ,Slot Status Mask (transmission conflict)" "0,1"

TEXTLINE ""

    group.word (0xFFFE0000+0x0068)++0x01
      line.word 0 "SSR0,Slot Status Register 0"
      bitfld.word  0 15.           "VFB  ,Valid Frame on Channel B" "0,1"
      bitfld.word  0 14.         "  SYB   ,Sync Frame Indicator Channel B" "0,1"
      bitfld.word  0 13.         "  NFB   ,Null Frame Indicator Channel B" "0,1"
      bitfld.word  0 12.         "  SUB   ,Startup Frame Indicator Channel B" "0,1"
      bitfld.word  0 11.         "  SEB   ,Syntax Error on Channel B" "0,1"
      bitfld.word  0 10.         "  CEB   ,Content Error on Channel B" "0,1"
      bitfld.word  0 09.         "  BVB   ,Boundary Violation on Channel B" "0,1"
      bitfld.word  0 08.         "  TCB   ,Transmission Conflict on Channel B" "0,1"
      TEXTLINE "              "
      bitfld.word  0 07.         "  VFA  ,Valid Frame on Channel A" "0,1"
      bitfld.word  0 06.         "  SYA   ,Sync Frame Indicator ChannelAB" "0,1"
      bitfld.word  0 05.         "  NFA   ,Null Frame Indicator Channel A" "0,1"
      bitfld.word  0 04.         "  SUA   ,Startup Frame Indicator Channel A" "0,1"
      bitfld.word  0 03.         "  SEA   ,Syntax Error on Channel A" "0,1"
      bitfld.word  0 02.         "  CEA   ,Content Error on Channel A" "0,1"
      bitfld.word  0 01.         "  BVA   ,Boundary Violation on Channel A" "0,1"
      bitfld.word  0 00.         "  TCA   ,Transmission Conflict on Channel A" "0,1"
    group.word (0xFFFE0000+0x006A)++0x01
      line.word 0 "SSR1,Slot Status Register 1"
      bitfld.word  0 15.           "VFB  ,Valid Frame on Channel B" "0,1"
      bitfld.word  0 14.         "  SYB   ,Sync Frame Indicator Channel B" "0,1"
      bitfld.word  0 13.         "  NFB   ,Null Frame Indicator Channel B" "0,1"
      bitfld.word  0 12.         "  SUB   ,Startup Frame Indicator Channel B" "0,1"
      bitfld.word  0 11.         "  SEB   ,Syntax Error on Channel B" "0,1"
      bitfld.word  0 10.         "  CEB   ,Content Error on Channel B" "0,1"
      bitfld.word  0 09.         "  BVB   ,Boundary Violation on Channel B" "0,1"
      bitfld.word  0 08.         "  TCB   ,Transmission Conflict on Channel B" "0,1"
      TEXTLINE "              "
      bitfld.word  0 07.         "  VFA  ,Valid Frame on Channel A" "0,1"
      bitfld.word  0 06.         "  SYA   ,Sync Frame Indicator ChannelAB" "0,1"
      bitfld.word  0 05.         "  NFA   ,Null Frame Indicator Channel A" "0,1"
      bitfld.word  0 04.         "  SUA   ,Startup Frame Indicator Channel A" "0,1"
      bitfld.word  0 03.         "  SEA   ,Syntax Error on Channel A" "0,1"
      bitfld.word  0 02.         "  CEA   ,Content Error on Channel A" "0,1"
      bitfld.word  0 01.         "  BVA   ,Boundary Violation on Channel A" "0,1"
      bitfld.word  0 00.         "  TCA   ,Transmission Conflict on Channel A" "0,1"
    group.word (0xFFFE0000+0x006C)++0x01
      line.word 0 "SSR2,Slot Status Register 2"
      bitfld.word  0 15.           "VFB  ,Valid Frame on Channel B" "0,1"
      bitfld.word  0 14.         "  SYB   ,Sync Frame Indicator Channel B" "0,1"
      bitfld.word  0 13.         "  NFB   ,Null Frame Indicator Channel B" "0,1"
      bitfld.word  0 12.         "  SUB   ,Startup Frame Indicator Channel B" "0,1"
      bitfld.word  0 11.         "  SEB   ,Syntax Error on Channel B" "0,1"
      bitfld.word  0 10.         "  CEB   ,Content Error on Channel B" "0,1"
      bitfld.word  0 09.         "  BVB   ,Boundary Violation on Channel B" "0,1"
      bitfld.word  0 08.         "  TCB   ,Transmission Conflict on Channel B" "0,1"
      TEXTLINE "              "
      bitfld.word  0 07.         "  VFA  ,Valid Frame on Channel A" "0,1"
      bitfld.word  0 06.         "  SYA   ,Sync Frame Indicator ChannelAB" "0,1"
      bitfld.word  0 05.         "  NFA   ,Null Frame Indicator Channel A" "0,1"
      bitfld.word  0 04.         "  SUA   ,Startup Frame Indicator Channel A" "0,1"
      bitfld.word  0 03.         "  SEA   ,Syntax Error on Channel A" "0,1"
      bitfld.word  0 02.         "  CEA   ,Content Error on Channel A" "0,1"
      bitfld.word  0 01.         "  BVA   ,Boundary Violation on Channel A" "0,1"
      bitfld.word  0 00.         "  TCA   ,Transmission Conflict on Channel A" "0,1"
    group.word (0xFFFE0000+0x006E)++0x01
      line.word 0 "SSR3,Slot Status Register 3"
      bitfld.word  0 15.           "VFB  ,Valid Frame on Channel B" "0,1"
      bitfld.word  0 14.         "  SYB   ,Sync Frame Indicator Channel B" "0,1"
      bitfld.word  0 13.         "  NFB   ,Null Frame Indicator Channel B" "0,1"
      bitfld.word  0 12.         "  SUB   ,Startup Frame Indicator Channel B" "0,1"
      bitfld.word  0 11.         "  SEB   ,Syntax Error on Channel B" "0,1"
      bitfld.word  0 10.         "  CEB   ,Content Error on Channel B" "0,1"
      bitfld.word  0 09.         "  BVB   ,Boundary Violation on Channel B" "0,1"
      bitfld.word  0 08.         "  TCB   ,Transmission Conflict on Channel B" "0,1"
      TEXTLINE "              "
      bitfld.word  0 07.         "  VFA  ,Valid Frame on Channel A" "0,1"
      bitfld.word  0 06.         "  SYA   ,Sync Frame Indicator ChannelAB" "0,1"
      bitfld.word  0 05.         "  NFA   ,Null Frame Indicator Channel A" "0,1"
      bitfld.word  0 04.         "  SUA   ,Startup Frame Indicator Channel A" "0,1"
      bitfld.word  0 03.         "  SEA   ,Syntax Error on Channel A" "0,1"
      bitfld.word  0 02.         "  CEA   ,Content Error on Channel A" "0,1"
      bitfld.word  0 01.         "  BVA   ,Boundary Violation on Channel A" "0,1"
      bitfld.word  0 00.         "  TCA   ,Transmission Conflict on Channel A" "0,1"
    group.word (0xFFFE0000+0x0070)++0x01
      line.word 0 "SSR4,Slot Status Register 4"
      bitfld.word  0 15.           "VFB  ,Valid Frame on Channel B" "0,1"
      bitfld.word  0 14.         "  SYB   ,Sync Frame Indicator Channel B" "0,1"
      bitfld.word  0 13.         "  NFB   ,Null Frame Indicator Channel B" "0,1"
      bitfld.word  0 12.         "  SUB   ,Startup Frame Indicator Channel B" "0,1"
      bitfld.word  0 11.         "  SEB   ,Syntax Error on Channel B" "0,1"
      bitfld.word  0 10.         "  CEB   ,Content Error on Channel B" "0,1"
      bitfld.word  0 09.         "  BVB   ,Boundary Violation on Channel B" "0,1"
      bitfld.word  0 08.         "  TCB   ,Transmission Conflict on Channel B" "0,1"
      TEXTLINE "              "
      bitfld.word  0 07.         "  VFA  ,Valid Frame on Channel A" "0,1"
      bitfld.word  0 06.         "  SYA   ,Sync Frame Indicator ChannelAB" "0,1"
      bitfld.word  0 05.         "  NFA   ,Null Frame Indicator Channel A" "0,1"
      bitfld.word  0 04.         "  SUA   ,Startup Frame Indicator Channel A" "0,1"
      bitfld.word  0 03.         "  SEA   ,Syntax Error on Channel A" "0,1"
      bitfld.word  0 02.         "  CEA   ,Content Error on Channel A" "0,1"
      bitfld.word  0 01.         "  BVA   ,Boundary Violation on Channel A" "0,1"
      bitfld.word  0 00.         "  TCA   ,Transmission Conflict on Channel A" "0,1"
    group.word (0xFFFE0000+0x0072)++0x01
      line.word 0 "SSR5,Slot Status Register 5"
      bitfld.word  0 15.           "VFB  ,Valid Frame on Channel B" "0,1"
      bitfld.word  0 14.         "  SYB   ,Sync Frame Indicator Channel B" "0,1"
      bitfld.word  0 13.         "  NFB   ,Null Frame Indicator Channel B" "0,1"
      bitfld.word  0 12.         "  SUB   ,Startup Frame Indicator Channel B" "0,1"
      bitfld.word  0 11.         "  SEB   ,Syntax Error on Channel B" "0,1"
      bitfld.word  0 10.         "  CEB   ,Content Error on Channel B" "0,1"
      bitfld.word  0 09.         "  BVB   ,Boundary Violation on Channel B" "0,1"
      bitfld.word  0 08.         "  TCB   ,Transmission Conflict on Channel B" "0,1"
      TEXTLINE "              "
      bitfld.word  0 07.         "  VFA  ,Valid Frame on Channel A" "0,1"
      bitfld.word  0 06.         "  SYA   ,Sync Frame Indicator ChannelAB" "0,1"
      bitfld.word  0 05.         "  NFA   ,Null Frame Indicator Channel A" "0,1"
      bitfld.word  0 04.         "  SUA   ,Startup Frame Indicator Channel A" "0,1"
      bitfld.word  0 03.         "  SEA   ,Syntax Error on Channel A" "0,1"
      bitfld.word  0 02.         "  CEA   ,Content Error on Channel A" "0,1"
      bitfld.word  0 01.         "  BVA   ,Boundary Violation on Channel A" "0,1"
      bitfld.word  0 00.         "  TCA   ,Transmission Conflict on Channel A" "0,1"
    group.word (0xFFFE0000+0x0074)++0x01
      line.word 0 "SSR6,Slot Status Register 6"
      bitfld.word  0 15.           "VFB  ,Valid Frame on Channel B" "0,1"
      bitfld.word  0 14.         "  SYB   ,Sync Frame Indicator Channel B" "0,1"
      bitfld.word  0 13.         "  NFB   ,Null Frame Indicator Channel B" "0,1"
      bitfld.word  0 12.         "  SUB   ,Startup Frame Indicator Channel B" "0,1"
      bitfld.word  0 11.         "  SEB   ,Syntax Error on Channel B" "0,1"
      bitfld.word  0 10.         "  CEB   ,Content Error on Channel B" "0,1"
      bitfld.word  0 09.         "  BVB   ,Boundary Violation on Channel B" "0,1"
      bitfld.word  0 08.         "  TCB   ,Transmission Conflict on Channel B" "0,1"
      TEXTLINE "              "
      bitfld.word  0 07.         "  VFA  ,Valid Frame on Channel A" "0,1"
      bitfld.word  0 06.         "  SYA   ,Sync Frame Indicator ChannelAB" "0,1"
      bitfld.word  0 05.         "  NFA   ,Null Frame Indicator Channel A" "0,1"
      bitfld.word  0 04.         "  SUA   ,Startup Frame Indicator Channel A" "0,1"
      bitfld.word  0 03.         "  SEA   ,Syntax Error on Channel A" "0,1"
      bitfld.word  0 02.         "  CEA   ,Content Error on Channel A" "0,1"
      bitfld.word  0 01.         "  BVA   ,Boundary Violation on Channel A" "0,1"
      bitfld.word  0 00.         "  TCA   ,Transmission Conflict on Channel A" "0,1"
    group.word (0xFFFE0000+0x0076)++0x01
      line.word 0 "SSR7,Slot Status Register 7"
      bitfld.word  0 15.           "VFB  ,Valid Frame on Channel B" "0,1"
      bitfld.word  0 14.         "  SYB   ,Sync Frame Indicator Channel B" "0,1"
      bitfld.word  0 13.         "  NFB   ,Null Frame Indicator Channel B" "0,1"
      bitfld.word  0 12.         "  SUB   ,Startup Frame Indicator Channel B" "0,1"
      bitfld.word  0 11.         "  SEB   ,Syntax Error on Channel B" "0,1"
      bitfld.word  0 10.         "  CEB   ,Content Error on Channel B" "0,1"
      bitfld.word  0 09.         "  BVB   ,Boundary Violation on Channel B" "0,1"
      bitfld.word  0 08.         "  TCB   ,Transmission Conflict on Channel B" "0,1"
      TEXTLINE "              "
      bitfld.word  0 07.         "  VFA  ,Valid Frame on Channel A" "0,1"
      bitfld.word  0 06.         "  SYA   ,Sync Frame Indicator ChannelAB" "0,1"
      bitfld.word  0 05.         "  NFA   ,Null Frame Indicator Channel A" "0,1"
      bitfld.word  0 04.         "  SUA   ,Startup Frame Indicator Channel A" "0,1"
      bitfld.word  0 03.         "  SEA   ,Syntax Error on Channel A" "0,1"
      bitfld.word  0 02.         "  CEA   ,Content Error on Channel A" "0,1"
      bitfld.word  0 01.         "  BVA   ,Boundary Violation on Channel A" "0,1"
      bitfld.word  0 00.         "  TCA   ,Transmission Conflict on Channel A" "0,1"

    group.word (0xFFFE0000+0x0068)++0x01
      line.word 0 "SSR,Slot Status Register 0"

TEXTLINE ""

    group.word (0xFFFE0000+0x0078)++0x01
      line.word 0 "SSCR0,Slot Status Counter Register 0"
      
    group.word (0xFFFE0000+0x007A)++0x01
      line.word 0 "SSCR1,Slot Status Counter Register 1"
      
    group.word (0xFFFE0000+0x007C)++0x01
      line.word 0 "SSCR2,Slot Status Counter Register 2"
      
    group.word (0xFFFE0000+0x007E)++0x01
      line.word 0 "SSCR3,Slot Status Counter Register 3"
      
  tree.end

  tree "Media Access Test Symbol"

    group.word (0xFFFE0000+0x0080)++0x01
      line.word 0 "MTSACFR,MTS A Configuration Register"
      bitfld.word  0 15.            "MTE  ,Media Access Test Symbol Transmission Enable" "0,1"
      hexmask.byte 0 0.--5. 1.    "  CYCCNTMSK  ,Cycle Counter Mask"
      hexmask.byte 1 0.--5. 1.    "  CYCCNTVAL  ,Cycle Counter Value"

    group.word (0xFFFE0000+0x0082)++0x01
      line.word 0 "MTSBCFR,MTS B Configuration Register"
        bitfld.word  0 15.            "MTE  ,Media Access Test Symbol Transmission Enable" "0,1"
        hexmask.byte 0 0.--5. 1.    "  CYCCNTMSK  ,Cycle Counter Mask"
        hexmask.byte 1 0.--5. 1.    "  CYCCNTVAL  ,Cycle Counter Value"

  tree.end

  tree "Shadow Buffer Configuration"

    group.word (0xFFFE0000+0x0084)++0x01
      line.word 0 "RSBIR,Receive Shadow Buffer Index Register"
      bitfld.word  0 15.            "WMD  ,Write Mode" "0,1"
      bitfld.word  0 12.--13.     "  SEL  ,Selector" "RSBIR_A0,RSBIR_A1,RSBIR_A2,RSBIR_A3"
      hexmask.byte 1 0.--7. 1.    "  RSBIDX  ,Receive Shadow Buffer Index"

  tree.end

  tree "Receive FIFO"

    group.word (0xFFFE0000+0x0086)++0x01
      line.word 0 "RFARIR,Receive FIFO Selection Register"
        bitfld.word  0 0.            "SEL  ,This control bit selects the receiver FIFO for subsequent programming" "A,B"

    group.word (0xFFFE0000+0x0088)++0x01
      line.word 0 "RFSIR,Receive FIFO Start Index Register"

    group.word (0xFFFE0000+0x008A)++0x01
      line.word 0 "RFDSR,Receive FIFO Depth and Size Register"
      hexmask.byte 0 0.--7. 1.      "FIFO_DEPTH  ,FIFO Depth"
      hexmask.byte 1 0.--6. 1.    "  ENTRY_SIZE  ,Entry Size"

TEXTLINE ""

    group.word (0xFFFE0000+0x008C)++0x01
      line.word 0 "RFARIR,Receive FIFO A Read Index Register"

    group.word (0xFFFE0000+0x008E)++0x01
      line.word 0 "RFBRIR,Receive FIFO B Read Index Register"
TEXTLINE ""

    group.word (0xFFFE0000+0x0090)++0x01
      line.word 0 "RFMIDAFVR,Receive FIFO Message ID Acceptance Filter Value Register"

    group.word (0xFFFE0000+0x0092)++0x01
      line.word 0 "RFMIAFMR,Receive FIFO Message ID Acceptance Filter Mask Register"

    group.word (0xFFFE0000+0x0094)++0x01
      line.word 0 "RFFIDRFVR,Receive FIFO Frame ID Rejection Filter Value Register"

    group.word (0xFFFE0000+0x0096)++0x01
      line.word 0 "RFFIDRFMR,Receive FIFO Frame ID Rejection Filter Mask Register"

    group.word (0xFFFE0000+0x0098)++0x01
      line.word 0 "RFRFCFR,Receive FIFO Range Filter Configuration Register"
      bitfld.word  0 15.              "WMD  ,Write Mode" "0,1"
      bitfld.word  0 14.            "  IBD  ,Interval Boundary" "0,1"
      bitfld.word  0 12.--13.       "  SEL  ,Selector" "ID range filter 0,ID range filter 1,ID range filter 2,ID range filter 3"
      hexmask.word 0 0.--10. 1.     "  SID  ,Slot ID"

    group.word (0xFFFE0000+0x009A)++0x01
      line.word 0 "RFRFCTR,Receive FIFO Range Filter Control Register"
      bitfld.word  0 11.              "F3MD  ,Range Filter 3 Mode" "acc,rej"
      bitfld.word  0 10.            "  F2MD  ,Range Filter 2 Mode" "acc,rej"
      bitfld.word  0 09.            "  F1MD  ,Range Filter 1 Mode" "acc,rej"
      bitfld.word  0 08.            "  F0MD  ,Range Filter 0 Mode" "acc,rej"
      TEXTLINE "                "
      bitfld.word  0 03.            "  F3EN  ,Range Filter 3 Enable" "0,1"
      bitfld.word  0 02.            "  F2EN  ,Range Filter 2 Enable" "0,1"
      bitfld.word  0 01.            "  F1EN  ,Range Filter 1 Enable" "0,1"
      bitfld.word  0 00.            "  F0EN  ,Range Filter 0 Enable" "0,1"

  tree.end

  tree "Dynamic Segment Status"

    group.word (0xFFFE0000+0x009C)++0x01
      line.word 0 "LDTXSLAR,Last Dynamic Transmit Slot Channel A Register"

    group.word (0xFFFE0000+0x009E)++0x01
      line.word 0 "LDTXSLAR,Last Dynamic Transmit Slot Channel B Register"

  tree.end

  tree "Protocol Configuration"

    group.word (0xFFFE0000+0x00A0)++0x01
      line.word    0x00 "PCR0,Protocol Configuration Register 0"
      hexmask.word.byte 0 10.--15. 1.     "action_point_offset                ,"
      hexmask.word 0 00.--09. 1.        "  static_slot_length               ,"

    group.word (0xFFFE0000+0x00A2)++0x01
      line.word    0x00 "PCR1,Protocol Configuration Register 1"
      bitfld.word  0 14.                  "filter_bypass                       ," "0,1"
      hexmask.word 0 00.--13. 1.        "  macro_after_first_static_slot    ,"

    group.word (0xFFFE0000+0x00A4)++0x01
      line.word    0x00 "PCR2,Protocol Configuration Register 2"
      hexmask.word.byte 0 10.--15. 1.     "minislot_after_action_point        ,"
      hexmask.word 0 00.--09. 1.        "  number_of_static_slots           ,"

    group.word (0xFFFE0000+0x00A6)++0x01 
      line.word    0x00 "PCR3,Protocol Configuration Register 3"
      hexmask.word.byte 0 10.--15. 1.     "minislot_after_action_point        ,"
      hexmask.word 0 05.--09. 1.        "  number_of_static_slots           ,"
      TEXTLINE "              "
      bitfld.word  0 00.--04.           "  coldstart_attempts                 ," "00,01,02,03,04,05,06,07,08,09,0A,0B,0C,0D,0E,0F,10,11,12,13,14,15,16,17,18,19,1A,1B,1C,1D,1E,1F"

    group.word (0xFFFE0000+0x00A8)++0x01
      line.word    0x00 "PCR4,Protocol Configuration Register 4"
      hexmask.word.byte 0 09.--15. 1.     "cas_rx_low_max                     ,"
      hexmask.word.byte 0 00.--08. 1.   "  wakeup_symbol_rx_window            ,"

    group.word (0xFFFE0000+0x00Aa)++0x01
      line.word    0x00 "PCR5,Protocol Configuration Register 5"
      bitfld.word  0 12.--15.             "tss_transmitter                     ," "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
      hexmask.word 0 06.--11. 1.        "  wakeup_symbol_tx_low             ,"
      TEXTLINE "              "
      hexmask.word 0 00.--05. 1.        "  wakeup_symbol_rx_idle            ,"

    group.word (0xFFFE0000+0x00Ac)++0x01
      line.word    0x00 "PCR6,Protocol Configuration Register 6"
      hexmask.word.byte 0 07.--14. 1.     "symbol_window_after_action_point   ,"
      hexmask.word.byte 0 00.--06. 1.   "  macro_initial_offset_a             ,"

    group.word (0xFFFE0000+0x00Ae)++0x01
      line.word    0x00 "PCR7,Protocol Configuration Register 7"
      hexmask.word.byte 0 07.--15. 1.     "decoding_correction_b              ,"
      hexmask.word.byte 0 00.--06. 1.   "  micro_per_macro_nom_half           ,"

    group.word (0xFFFE0000+0x00b0)++0x01
      line.word    0x00 "PCR8,Protocol Configuration Register 8"
      bitfld.word  0 12.--15.             "max_without_clock_corr_fatal        ," "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
      bitfld.word 0 08.--11.            "  max_without_clock_corr_passive      ," "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
      TEXTLINE "              "
      hexmask.word 0 00.--07. 1.        "  wakeup_symbol_tx_idle            ,"

    group.word (0xFFFE0000+0x00b2)++0x01
      line.word    0x00 "PCR9,Protocol Configuration Register 9"
      bitfld.word  0 15.                  "minislot_exists                     ," "0,1"
      bitfld.word  0 14.                "  symbol_window_exists                ," "0,1"
      TEXTLINE "              "
      hexmask.word 0 00.--13. 1.        "  offset_correction_out            ,"

    group.word (0xFFFE0000+0x00b4)++0x01
      line.word    0x00 "PCR10,Protocol Configuration Register 10"
      bitfld.word  0 15.                  "single_slot_enabled                 ," "0,1"
      bitfld.word  0 14.                "  wakeup_channel                      ," "0,1"
      TEXTLINE "              "
      hexmask.word 0 00.--13. 1.        "  macro_per_cycle                  ,"

    group.word (0xFFFE0000+0x00b6)++0x01
      line.word    0x00 "PCR11,Protocol Configuration Register 11"
      bitfld.word  0 15.                  "key_slot_used_for_startup           ," "0,1"
      bitfld.word  0 14.                "  key_slot_used_for_sync              ," "0,1"
      TEXTLINE "              "
      hexmask.word 0 00.--13. 1.        "  offset_correction_start          ,"

    group.word (0xFFFE0000+0x00b8)++0x01
      line.word    0x00 "PCR12,Protocol Configuration Register 12"
      hexmask.word.byte 0 11.--15. 1.     "allow_passive_to_active            ,"
      hexmask.word 0 00.--10. 1.        "  key_slot_header_crc              ,"

    group.word (0xFFFE0000+0x00ba)++0x01
      line.word    0x00 "PCR13,Protocol Configuration Register 13"
      hexmask.word.byte 0 10.--15. 1.     "first_minislot_action_point_offs   ,"
      hexmask.word 0 00.--09. 1.        "  static_slot_after_action_point   ,"

    group.word (0xFFFE0000+0x00bc)++0x01
      line.word    0x00 "PCR14,Protocol Configuration Register 14"
      hexmask.word 0 05.--15. 1.          "rate_correction_out              ,"
      bitfld.word 0 00.--04.            "  listen_timeout[20:16]              ," "00,01,02,03,04,05,06,07,08,09,0A,0B,0C,0D,0E,0F,10,11,12,13,14,15,16,17,18,19,1A,1B,1C,1D,1E,1F"

    group.word (0xFFFE0000+0x00be)++0x01
      line.word    0x00 "PCR15,Protocol Configuration Register 15"
      hexmask.word 0 00.--15. 1.          "listen_timeout[00:15]            ,"

    group.word (0xFFFE0000+0x00c0)++0x01
      line.word    0x00 "PCR16,Protocol Configuration Register 16"
      hexmask.word.byte 0 09.--15. 1.     "macro_initial_offset_b             ,"
      hexmask.word 0 00.--08. 1.        "  noise_listen_timeout[24:16]      ,"

    group.word (0xFFFE0000+0x00c2)++0x01
      line.word    0x00 "PCR17,Protocol Configuration Register 17"
      hexmask.word 0 00.--15. 1.          "noise_listen_timeout[15:0]       ,"

    group.word (0xFFFE0000+0x00c4)++0x01
      line.word    0x00 "PCR18,Protocol Configuration Register 18"
      hexmask.word.byte 0 10.--15. 1.     "wakeup_pattern                     ,"
      hexmask.word 0 00.--09. 1.        "  key_slot_id                      ,"

    group.word (0xFFFE0000+0x00c6)++0x01
      line.word    0x00 "PCR19,Protocol Configuration Register 19"
      hexmask.word.byte 0 07.--15. 1.     "decoding_correction_a              ,"
      hexmask.word.byte 0 00.--06. 1.   "  payload_length_static              ,"

    group.word (0xFFFE0000+0x00c8)++0x01
      line.word    0x00 "PCR20,Protocol Configuration Register 20"
      hexmask.word.byte 0 08.--15. 1.     "micro_initial_offset_b             ,"
      hexmask.word.byte 0 00.--07. 1.   "  micro_initial_offset_a             ,"

    group.word (0xFFFE0000+0x00ca)++0x01
      line.word    0x00 "PCR21,Protocol Configuration Register 21"
      bitfld.word  0 13.--15.            "extern_rate_correction              ," "0,1,2,3,4,5,6,7"
      hexmask.word 0 00.--12. 1.        "  latest_tx                        ,"

    group.word (0xFFFE0000+0x00cc)++0x01
      line.word    0x00 "PCR22,Protocol Configuration Register 22"
      hexmask.word 0 04.--14. 1.          "comp_accepted_startup_range_a    ,"
      bitfld.word  0 00.--03.           "  micro_per_cycle[19:16]              ," "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"

    group.word (0xFFFE0000+0x00ce)++0x01
      line.word    0x00 "PCR23,Protocol Configuration Register 23"
      hexmask.word 0 00.--15. 1.          "micro_per_cycle[15:0]            ,"

    group.word (0xFFFE0000+0x00d0)++0x01
      line.word    0x00 "PCR24,Protocol Configuration Register 24"
      bitfld.word 0 12.--15.             "cluster_drift_damping               ," "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
      bitfld.word 0 08.--11.           "  max_payload_length_dynamic          ," "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
      TEXTLINE "              "
      hexmask.word.byte 0 00.--07. 1.  "  micro_per_cycle_min[19:16]         ,"

    group.word (0xFFFE0000+0x00d2)++0x01
      line.word    0x00 "PCR25,Protocol Configuration Register 25"
      hexmask.word 0 00.--15. 1.          "micro_per_cycle_min[15:00]       ,"

    group.word (0xFFFE0000+0x00d4)++0x01
      line.word    0x00 "PCR26,Protocol Configuration Register 26"
      bitfld.word  0 14.                  "allow_halt_due_to_clock             ," "0,1"
      hexmask.word 0 04.--14. 1.        "  comp_accepted_startup_range_b    ,"
      TEXTLINE "              "
      bitfld.word 0 00.--03.            "  micro_per_cycle_max[19:16]          ," "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"

    group.word (0xFFFE0000+0x00d6)++0x01
      line.word    0x00 "PCR27,Protocol Configuration Register 27"
      hexmask.word 0 00.--15. 1.          "micro_per_cycle_max[15:00]       ,"

    group.word (0xFFFE0000+0x00d8)++0x01
      line.word    0x00 "PCR28,Protocol Configuration Register 28"
      bitfld.word  0 14.--15.             "dynamic_slot_idle_phase             ," "0,1,2,3"
      hexmask.word 0 00.--13. 1.        "  macro_after_offset_correction    ,"

    group.word (0xFFFE0000+0x00da)++0x01
      line.word    0x00 "PCR29,Protocol Configuration Register 29"
      bitfld.word  0 13.--15.             "extern_offset_correction            ," "0,1,2,3,4,5,6,7"
      hexmask.word 0 00.--12. 1.        "  minislots_max                    ,"

    group.word (0xFFFE0000+0x00dc)++0x01
      line.word    0x00 "PCR30,Protocol Configuration Register 30"
      bitfld.word  0 00.--03.             "sync_node_max                       ," "0,1,2,3,4,5,6,7,8,9,A,B,C,D,E,F"
   
  tree.end

  tree "Message Buffer Registers"
  group.word ((0xFFFE0000+0x0100))++0x07
      line.word    0x00 "MBCCSR000,Message Buffer Configuration, Control, Status Register 000"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR000  ,Message Buffer Cycle Counter Filter Register 000"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR000  ,Message Buffer Frame ID Register 000"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR000  ,Message Buffer Index Register 000"
  group.word ((0xFFFE0000+0x0108))++0x07
      line.word    0x00 "MBCCSR001,Message Buffer Configuration, Control, Status Register 001"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR001  ,Message Buffer Cycle Counter Filter Register 001"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR001  ,Message Buffer Frame ID Register 001"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR001  ,Message Buffer Index Register 001"
  group.word ((0xFFFE0000+0x0110))++0x07
      line.word    0x00 "MBCCSR002,Message Buffer Configuration, Control, Status Register 002"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR002  ,Message Buffer Cycle Counter Filter Register 002"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR002  ,Message Buffer Frame ID Register 002"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR002  ,Message Buffer Index Register 002"
  group.word ((0xFFFE0000+0x0118))++0x07
      line.word    0x00 "MBCCSR003,Message Buffer Configuration, Control, Status Register 003"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR003  ,Message Buffer Cycle Counter Filter Register 003"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR003  ,Message Buffer Frame ID Register 003"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR003  ,Message Buffer Index Register 003"
  group.word ((0xFFFE0000+0x0120))++0x07
      line.word    0x00 "MBCCSR004,Message Buffer Configuration, Control, Status Register 004"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR004  ,Message Buffer Cycle Counter Filter Register 004"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR004  ,Message Buffer Frame ID Register 004"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR004  ,Message Buffer Index Register 004"
  group.word ((0xFFFE0000+0x0128))++0x07
      line.word    0x00 "MBCCSR005,Message Buffer Configuration, Control, Status Register 005"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR005  ,Message Buffer Cycle Counter Filter Register 005"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR005  ,Message Buffer Frame ID Register 005"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR005  ,Message Buffer Index Register 005"
  group.word ((0xFFFE0000+0x0130))++0x07
      line.word    0x00 "MBCCSR006,Message Buffer Configuration, Control, Status Register 006"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR006  ,Message Buffer Cycle Counter Filter Register 006"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR006  ,Message Buffer Frame ID Register 006"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR006  ,Message Buffer Index Register 006"
  group.word ((0xFFFE0000+0x0138))++0x07
      line.word    0x00 "MBCCSR007,Message Buffer Configuration, Control, Status Register 007"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR007  ,Message Buffer Cycle Counter Filter Register 007"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR007  ,Message Buffer Frame ID Register 007"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR007  ,Message Buffer Index Register 007"
  TEXTLINE ""
  group.word ((0xFFFE0000+0x0140))++0x07
      line.word    0x00 "MBCCSR008,Message Buffer Configuration, Control, Status Register 008"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR008  ,Message Buffer Cycle Counter Filter Register 008"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR008  ,Message Buffer Frame ID Register 008"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR008  ,Message Buffer Index Register 008"
  group.word ((0xFFFE0000+0x0148))++0x07
      line.word    0x00 "MBCCSR009,Message Buffer Configuration, Control, Status Register 009"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR009  ,Message Buffer Cycle Counter Filter Register 009"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR009  ,Message Buffer Frame ID Register 009"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR009  ,Message Buffer Index Register 009"
  group.word ((0xFFFE0000+0x0150))++0x07
      line.word    0x00 "MBCCSR010,Message Buffer Configuration, Control, Status Register 010"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR010  ,Message Buffer Cycle Counter Filter Register 010"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR010  ,Message Buffer Frame ID Register 010"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR010  ,Message Buffer Index Register 010"
  group.word ((0xFFFE0000+0x0158))++0x07
      line.word    0x00 "MBCCSR011,Message Buffer Configuration, Control, Status Register 011"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR011  ,Message Buffer Cycle Counter Filter Register 011"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR011  ,Message Buffer Frame ID Register 011"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR011  ,Message Buffer Index Register 011"
  group.word ((0xFFFE0000+0x0160))++0x07
      line.word    0x00 "MBCCSR012,Message Buffer Configuration, Control, Status Register 012"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR012  ,Message Buffer Cycle Counter Filter Register 012"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR012  ,Message Buffer Frame ID Register 012"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR012  ,Message Buffer Index Register 012"
  group.word ((0xFFFE0000+0x0168))++0x07
      line.word    0x00 "MBCCSR013,Message Buffer Configuration, Control, Status Register 013"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR013  ,Message Buffer Cycle Counter Filter Register 013"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR013  ,Message Buffer Frame ID Register 013"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR013  ,Message Buffer Index Register 013"
  group.word ((0xFFFE0000+0x0170))++0x07
      line.word    0x00 "MBCCSR014,Message Buffer Configuration, Control, Status Register 014"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR014  ,Message Buffer Cycle Counter Filter Register 014"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR014  ,Message Buffer Frame ID Register 014"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR014  ,Message Buffer Index Register 014"
  group.word ((0xFFFE0000+0x0178))++0x07
      line.word    0x00 "MBCCSR015,Message Buffer Configuration, Control, Status Register 015"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR015  ,Message Buffer Cycle Counter Filter Register 015"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR015  ,Message Buffer Frame ID Register 015"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR015  ,Message Buffer Index Register 015"
  TEXTLINE ""
  group.word ((0xFFFE0000+0x0180))++0x07
      line.word    0x00 "MBCCSR016,Message Buffer Configuration, Control, Status Register 016"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR016  ,Message Buffer Cycle Counter Filter Register 016"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR016  ,Message Buffer Frame ID Register 016"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR016  ,Message Buffer Index Register 016"
  group.word ((0xFFFE0000+0x0188))++0x07
      line.word    0x00 "MBCCSR017,Message Buffer Configuration, Control, Status Register 017"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR017  ,Message Buffer Cycle Counter Filter Register 017"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR017  ,Message Buffer Frame ID Register 017"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR017  ,Message Buffer Index Register 017"
  group.word ((0xFFFE0000+0x0190))++0x07
      line.word    0x00 "MBCCSR018,Message Buffer Configuration, Control, Status Register 018"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR018  ,Message Buffer Cycle Counter Filter Register 018"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR018  ,Message Buffer Frame ID Register 018"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR018  ,Message Buffer Index Register 018"
  group.word ((0xFFFE0000+0x0198))++0x07
      line.word    0x00 "MBCCSR019,Message Buffer Configuration, Control, Status Register 019"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR019  ,Message Buffer Cycle Counter Filter Register 019"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR019  ,Message Buffer Frame ID Register 019"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR019  ,Message Buffer Index Register 019"
  group.word ((0xFFFE0000+0x01A0))++0x07
      line.word    0x00 "MBCCSR020,Message Buffer Configuration, Control, Status Register 020"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR020  ,Message Buffer Cycle Counter Filter Register 020"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR020  ,Message Buffer Frame ID Register 020"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR020  ,Message Buffer Index Register 020"
  group.word ((0xFFFE0000+0x01A8))++0x07
      line.word    0x00 "MBCCSR021,Message Buffer Configuration, Control, Status Register 021"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR021  ,Message Buffer Cycle Counter Filter Register 021"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR021  ,Message Buffer Frame ID Register 021"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR021  ,Message Buffer Index Register 021"
  group.word ((0xFFFE0000+0x01B0))++0x07
      line.word    0x00 "MBCCSR022,Message Buffer Configuration, Control, Status Register 022"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR022  ,Message Buffer Cycle Counter Filter Register 022"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR022  ,Message Buffer Frame ID Register 022"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR022  ,Message Buffer Index Register 022"
  group.word ((0xFFFE0000+0x01B8))++0x07
      line.word    0x00 "MBCCSR023,Message Buffer Configuration, Control, Status Register 023"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR023  ,Message Buffer Cycle Counter Filter Register 023"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR023  ,Message Buffer Frame ID Register 023"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR023  ,Message Buffer Index Register 023"
  TEXTLINE ""
  group.word ((0xFFFE0000+0x01C0))++0x07
      line.word    0x00 "MBCCSR024,Message Buffer Configuration, Control, Status Register 024"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR024  ,Message Buffer Cycle Counter Filter Register 024"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR024  ,Message Buffer Frame ID Register 024"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR024  ,Message Buffer Index Register 024"
  group.word ((0xFFFE0000+0x01C8))++0x07
      line.word    0x00 "MBCCSR025,Message Buffer Configuration, Control, Status Register 025"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR025  ,Message Buffer Cycle Counter Filter Register 025"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR025  ,Message Buffer Frame ID Register 025"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR025  ,Message Buffer Index Register 025"
  group.word ((0xFFFE0000+0x01D0))++0x07
      line.word    0x00 "MBCCSR026,Message Buffer Configuration, Control, Status Register 026"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR026  ,Message Buffer Cycle Counter Filter Register 026"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR026  ,Message Buffer Frame ID Register 026"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR026  ,Message Buffer Index Register 026"
  group.word ((0xFFFE0000+0x01D8))++0x07
      line.word    0x00 "MBCCSR027,Message Buffer Configuration, Control, Status Register 027"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR027  ,Message Buffer Cycle Counter Filter Register 027"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR027  ,Message Buffer Frame ID Register 027"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR027  ,Message Buffer Index Register 027"
  group.word ((0xFFFE0000+0x01E0))++0x07
      line.word    0x00 "MBCCSR028,Message Buffer Configuration, Control, Status Register 028"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR028  ,Message Buffer Cycle Counter Filter Register 028"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR028  ,Message Buffer Frame ID Register 028"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR028  ,Message Buffer Index Register 028"
  group.word ((0xFFFE0000+0x01E8))++0x07
      line.word    0x00 "MBCCSR029,Message Buffer Configuration, Control, Status Register 029"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR029  ,Message Buffer Cycle Counter Filter Register 029"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR029  ,Message Buffer Frame ID Register 029"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR029  ,Message Buffer Index Register 029"
  group.word ((0xFFFE0000+0x01F0))++0x07
      line.word    0x00 "MBCCSR030,Message Buffer Configuration, Control, Status Register 030"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR030  ,Message Buffer Cycle Counter Filter Register 030"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR030  ,Message Buffer Frame ID Register 030"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR030  ,Message Buffer Index Register 030"
  group.word ((0xFFFE0000+0x01F8))++0x07
      line.word    0x00 "MBCCSR031,Message Buffer Configuration, Control, Status Register 031"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR031  ,Message Buffer Cycle Counter Filter Register 031"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR031  ,Message Buffer Frame ID Register 031"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR031  ,Message Buffer Index Register 031"
  TEXTLINE ""
  group.word ((0xFFFE0000+0x0200))++0x07
      line.word    0x00 "MBCCSR032,Message Buffer Configuration, Control, Status Register 032"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR032  ,Message Buffer Cycle Counter Filter Register 032"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR032  ,Message Buffer Frame ID Register 032"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR032  ,Message Buffer Index Register 032"
  group.word ((0xFFFE0000+0x0208))++0x07
      line.word    0x00 "MBCCSR033,Message Buffer Configuration, Control, Status Register 033"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR033  ,Message Buffer Cycle Counter Filter Register 033"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR033  ,Message Buffer Frame ID Register 033"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR033  ,Message Buffer Index Register 033"
  group.word ((0xFFFE0000+0x0210))++0x07
      line.word    0x00 "MBCCSR034,Message Buffer Configuration, Control, Status Register 034"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR034  ,Message Buffer Cycle Counter Filter Register 034"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR034  ,Message Buffer Frame ID Register 034"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR034  ,Message Buffer Index Register 034"
  group.word ((0xFFFE0000+0x0218))++0x07
      line.word    0x00 "MBCCSR035,Message Buffer Configuration, Control, Status Register 035"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR035  ,Message Buffer Cycle Counter Filter Register 035"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR035  ,Message Buffer Frame ID Register 035"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR035  ,Message Buffer Index Register 035"
  group.word ((0xFFFE0000+0x0220))++0x07
      line.word    0x00 "MBCCSR036,Message Buffer Configuration, Control, Status Register 036"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR036  ,Message Buffer Cycle Counter Filter Register 036"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR036  ,Message Buffer Frame ID Register 036"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR036  ,Message Buffer Index Register 036"
  group.word ((0xFFFE0000+0x0228))++0x07
      line.word    0x00 "MBCCSR037,Message Buffer Configuration, Control, Status Register 037"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR037  ,Message Buffer Cycle Counter Filter Register 037"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR037  ,Message Buffer Frame ID Register 037"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR037  ,Message Buffer Index Register 037"
  group.word ((0xFFFE0000+0x0230))++0x07
      line.word    0x00 "MBCCSR038,Message Buffer Configuration, Control, Status Register 038"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR038  ,Message Buffer Cycle Counter Filter Register 038"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR038  ,Message Buffer Frame ID Register 038"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR038  ,Message Buffer Index Register 038"
  group.word ((0xFFFE0000+0x0238))++0x07
      line.word    0x00 "MBCCSR039,Message Buffer Configuration, Control, Status Register 039"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR039  ,Message Buffer Cycle Counter Filter Register 039"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR039  ,Message Buffer Frame ID Register 039"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR039  ,Message Buffer Index Register 039"
  TEXTLINE ""
  group.word ((0xFFFE0000+0x0240))++0x07
      line.word    0x00 "MBCCSR040,Message Buffer Configuration, Control, Status Register 040"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR040  ,Message Buffer Cycle Counter Filter Register 040"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR040  ,Message Buffer Frame ID Register 040"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR040  ,Message Buffer Index Register 040"
  group.word ((0xFFFE0000+0x0248))++0x07
      line.word    0x00 "MBCCSR041,Message Buffer Configuration, Control, Status Register 041"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR041  ,Message Buffer Cycle Counter Filter Register 041"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR041  ,Message Buffer Frame ID Register 041"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR041  ,Message Buffer Index Register 041"
  group.word ((0xFFFE0000+0x0250))++0x07
      line.word    0x00 "MBCCSR042,Message Buffer Configuration, Control, Status Register 042"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR042  ,Message Buffer Cycle Counter Filter Register 042"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR042  ,Message Buffer Frame ID Register 042"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR042  ,Message Buffer Index Register 042"
  group.word ((0xFFFE0000+0x0258))++0x07
      line.word    0x00 "MBCCSR043,Message Buffer Configuration, Control, Status Register 043"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR043  ,Message Buffer Cycle Counter Filter Register 043"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR043  ,Message Buffer Frame ID Register 043"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR043  ,Message Buffer Index Register 043"
  group.word ((0xFFFE0000+0x0260))++0x07
      line.word    0x00 "MBCCSR044,Message Buffer Configuration, Control, Status Register 044"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR044  ,Message Buffer Cycle Counter Filter Register 044"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR044  ,Message Buffer Frame ID Register 044"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR044  ,Message Buffer Index Register 044"
  group.word ((0xFFFE0000+0x0268))++0x07
      line.word    0x00 "MBCCSR045,Message Buffer Configuration, Control, Status Register 045"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR045  ,Message Buffer Cycle Counter Filter Register 045"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR045  ,Message Buffer Frame ID Register 045"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR045  ,Message Buffer Index Register 045"
  group.word ((0xFFFE0000+0x0270))++0x07
      line.word    0x00 "MBCCSR046,Message Buffer Configuration, Control, Status Register 046"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR046  ,Message Buffer Cycle Counter Filter Register 046"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR046  ,Message Buffer Frame ID Register 046"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR046  ,Message Buffer Index Register 046"
  group.word ((0xFFFE0000+0x0278))++0x07
      line.word    0x00 "MBCCSR047,Message Buffer Configuration, Control, Status Register 047"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR047  ,Message Buffer Cycle Counter Filter Register 047"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR047  ,Message Buffer Frame ID Register 047"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR047  ,Message Buffer Index Register 047"
  TEXTLINE ""
  group.word ((0xFFFE0000+0x0280))++0x07
      line.word    0x00 "MBCCSR048,Message Buffer Configuration, Control, Status Register 048"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR048  ,Message Buffer Cycle Counter Filter Register 048"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR048  ,Message Buffer Frame ID Register 048"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR048  ,Message Buffer Index Register 048"
  group.word ((0xFFFE0000+0x0288))++0x07
      line.word    0x00 "MBCCSR049,Message Buffer Configuration, Control, Status Register 049"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR049  ,Message Buffer Cycle Counter Filter Register 049"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR049  ,Message Buffer Frame ID Register 049"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR049  ,Message Buffer Index Register 049"
  group.word ((0xFFFE0000+0x0290))++0x07
      line.word    0x00 "MBCCSR050,Message Buffer Configuration, Control, Status Register 050"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR050  ,Message Buffer Cycle Counter Filter Register 050"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR050  ,Message Buffer Frame ID Register 050"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR050  ,Message Buffer Index Register 050"
  group.word ((0xFFFE0000+0x0298))++0x07
      line.word    0x00 "MBCCSR051,Message Buffer Configuration, Control, Status Register 051"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR051  ,Message Buffer Cycle Counter Filter Register 051"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR051  ,Message Buffer Frame ID Register 051"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR051  ,Message Buffer Index Register 051"
  group.word ((0xFFFE0000+0x02A0))++0x07
      line.word    0x00 "MBCCSR052,Message Buffer Configuration, Control, Status Register 052"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR052  ,Message Buffer Cycle Counter Filter Register 052"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR052  ,Message Buffer Frame ID Register 052"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR052  ,Message Buffer Index Register 052"
  group.word ((0xFFFE0000+0x02A8))++0x07
      line.word    0x00 "MBCCSR053,Message Buffer Configuration, Control, Status Register 053"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR053  ,Message Buffer Cycle Counter Filter Register 053"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR053  ,Message Buffer Frame ID Register 053"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR053  ,Message Buffer Index Register 053"
  group.word ((0xFFFE0000+0x02B0))++0x07
      line.word    0x00 "MBCCSR054,Message Buffer Configuration, Control, Status Register 054"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR054  ,Message Buffer Cycle Counter Filter Register 054"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR054  ,Message Buffer Frame ID Register 054"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR054  ,Message Buffer Index Register 054"
  group.word ((0xFFFE0000+0x02B8))++0x07
      line.word    0x00 "MBCCSR055,Message Buffer Configuration, Control, Status Register 055"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR055  ,Message Buffer Cycle Counter Filter Register 055"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR055  ,Message Buffer Frame ID Register 055"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR055  ,Message Buffer Index Register 055"
  TEXTLINE ""
  group.word ((0xFFFE0000+0x02C0))++0x07
      line.word    0x00 "MBCCSR056,Message Buffer Configuration, Control, Status Register 056"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR056  ,Message Buffer Cycle Counter Filter Register 056"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR056  ,Message Buffer Frame ID Register 056"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR056  ,Message Buffer Index Register 056"
  group.word ((0xFFFE0000+0x02C8))++0x07
      line.word    0x00 "MBCCSR057,Message Buffer Configuration, Control, Status Register 057"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR057  ,Message Buffer Cycle Counter Filter Register 057"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR057  ,Message Buffer Frame ID Register 057"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR057  ,Message Buffer Index Register 057"
  group.word ((0xFFFE0000+0x02D0))++0x07
      line.word    0x00 "MBCCSR058,Message Buffer Configuration, Control, Status Register 058"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR058  ,Message Buffer Cycle Counter Filter Register 058"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR058  ,Message Buffer Frame ID Register 058"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR058  ,Message Buffer Index Register 058"
  group.word ((0xFFFE0000+0x02D8))++0x07
      line.word    0x00 "MBCCSR059,Message Buffer Configuration, Control, Status Register 059"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR059  ,Message Buffer Cycle Counter Filter Register 059"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR059  ,Message Buffer Frame ID Register 059"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR059  ,Message Buffer Index Register 059"
  group.word ((0xFFFE0000+0x02E0))++0x07
      line.word    0x00 "MBCCSR060,Message Buffer Configuration, Control, Status Register 060"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR060  ,Message Buffer Cycle Counter Filter Register 060"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR060  ,Message Buffer Frame ID Register 060"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR060  ,Message Buffer Index Register 060"
  group.word ((0xFFFE0000+0x02E8))++0x07
      line.word    0x00 "MBCCSR061,Message Buffer Configuration, Control, Status Register 061"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR061  ,Message Buffer Cycle Counter Filter Register 061"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR061  ,Message Buffer Frame ID Register 061"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR061  ,Message Buffer Index Register 061"
  group.word ((0xFFFE0000+0x02F0))++0x07
      line.word    0x00 "MBCCSR062,Message Buffer Configuration, Control, Status Register 062"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR062  ,Message Buffer Cycle Counter Filter Register 062"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR062  ,Message Buffer Frame ID Register 062"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR062  ,Message Buffer Index Register 062"
  group.word ((0xFFFE0000+0x02F8))++0x07
      line.word    0x00 "MBCCSR063,Message Buffer Configuration, Control, Status Register 063"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR063  ,Message Buffer Cycle Counter Filter Register 063"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR063  ,Message Buffer Frame ID Register 063"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR063  ,Message Buffer Index Register 063"
  TEXTLINE ""
  group.word ((0xFFFE0000+0x0300))++0x07
      line.word    0x00 "MBCCSR064,Message Buffer Configuration, Control, Status Register 064"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR064  ,Message Buffer Cycle Counter Filter Register 064"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR064  ,Message Buffer Frame ID Register 064"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR064  ,Message Buffer Index Register 064"
  group.word ((0xFFFE0000+0x0308))++0x07
      line.word    0x00 "MBCCSR065,Message Buffer Configuration, Control, Status Register 065"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR065  ,Message Buffer Cycle Counter Filter Register 065"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR065  ,Message Buffer Frame ID Register 065"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR065  ,Message Buffer Index Register 065"
  group.word ((0xFFFE0000+0x0310))++0x07
      line.word    0x00 "MBCCSR066,Message Buffer Configuration, Control, Status Register 066"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR066  ,Message Buffer Cycle Counter Filter Register 066"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR066  ,Message Buffer Frame ID Register 066"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR066  ,Message Buffer Index Register 066"
  group.word ((0xFFFE0000+0x0318))++0x07
      line.word    0x00 "MBCCSR067,Message Buffer Configuration, Control, Status Register 067"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR067  ,Message Buffer Cycle Counter Filter Register 067"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR067  ,Message Buffer Frame ID Register 067"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR067  ,Message Buffer Index Register 067"
  group.word ((0xFFFE0000+0x0320))++0x07
      line.word    0x00 "MBCCSR068,Message Buffer Configuration, Control, Status Register 068"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR068  ,Message Buffer Cycle Counter Filter Register 068"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR068  ,Message Buffer Frame ID Register 068"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR068  ,Message Buffer Index Register 068"
  group.word ((0xFFFE0000+0x0328))++0x07
      line.word    0x00 "MBCCSR069,Message Buffer Configuration, Control, Status Register 069"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR069  ,Message Buffer Cycle Counter Filter Register 069"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR069  ,Message Buffer Frame ID Register 069"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR069  ,Message Buffer Index Register 069"
  group.word ((0xFFFE0000+0x0330))++0x07
      line.word    0x00 "MBCCSR070,Message Buffer Configuration, Control, Status Register 070"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR070  ,Message Buffer Cycle Counter Filter Register 070"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR070  ,Message Buffer Frame ID Register 070"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR070  ,Message Buffer Index Register 070"
  group.word ((0xFFFE0000+0x0338))++0x07
      line.word    0x00 "MBCCSR071,Message Buffer Configuration, Control, Status Register 071"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR071  ,Message Buffer Cycle Counter Filter Register 071"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR071  ,Message Buffer Frame ID Register 071"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR071  ,Message Buffer Index Register 071"
  TEXTLINE ""
  group.word ((0xFFFE0000+0x0340))++0x07
      line.word    0x00 "MBCCSR072,Message Buffer Configuration, Control, Status Register 072"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR072  ,Message Buffer Cycle Counter Filter Register 072"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR072  ,Message Buffer Frame ID Register 072"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR072  ,Message Buffer Index Register 072"
  group.word ((0xFFFE0000+0x0348))++0x07
      line.word    0x00 "MBCCSR073,Message Buffer Configuration, Control, Status Register 073"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR073  ,Message Buffer Cycle Counter Filter Register 073"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR073  ,Message Buffer Frame ID Register 073"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR073  ,Message Buffer Index Register 073"
  group.word ((0xFFFE0000+0x0350))++0x07
      line.word    0x00 "MBCCSR074,Message Buffer Configuration, Control, Status Register 074"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR074  ,Message Buffer Cycle Counter Filter Register 074"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR074  ,Message Buffer Frame ID Register 074"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR074  ,Message Buffer Index Register 074"
  group.word ((0xFFFE0000+0x0358))++0x07
      line.word    0x00 "MBCCSR075,Message Buffer Configuration, Control, Status Register 075"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR075  ,Message Buffer Cycle Counter Filter Register 075"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR075  ,Message Buffer Frame ID Register 075"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR075  ,Message Buffer Index Register 075"
  group.word ((0xFFFE0000+0x0360))++0x07
      line.word    0x00 "MBCCSR076,Message Buffer Configuration, Control, Status Register 076"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR076  ,Message Buffer Cycle Counter Filter Register 076"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR076  ,Message Buffer Frame ID Register 076"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR076  ,Message Buffer Index Register 076"
  group.word ((0xFFFE0000+0x0368))++0x07
      line.word    0x00 "MBCCSR077,Message Buffer Configuration, Control, Status Register 077"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR077  ,Message Buffer Cycle Counter Filter Register 077"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR077  ,Message Buffer Frame ID Register 077"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR077  ,Message Buffer Index Register 077"
  group.word ((0xFFFE0000+0x0370))++0x07
      line.word    0x00 "MBCCSR078,Message Buffer Configuration, Control, Status Register 078"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR078  ,Message Buffer Cycle Counter Filter Register 078"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR078  ,Message Buffer Frame ID Register 078"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR078  ,Message Buffer Index Register 078"
  group.word ((0xFFFE0000+0x0378))++0x07
      line.word    0x00 "MBCCSR079,Message Buffer Configuration, Control, Status Register 079"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR079  ,Message Buffer Cycle Counter Filter Register 079"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR079  ,Message Buffer Frame ID Register 079"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR079  ,Message Buffer Index Register 079"
  TEXTLINE ""
  group.word ((0xFFFE0000+0x0380))++0x07
      line.word    0x00 "MBCCSR080,Message Buffer Configuration, Control, Status Register 080"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR080  ,Message Buffer Cycle Counter Filter Register 080"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR080  ,Message Buffer Frame ID Register 080"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR080  ,Message Buffer Index Register 080"
  group.word ((0xFFFE0000+0x0388))++0x07
      line.word    0x00 "MBCCSR081,Message Buffer Configuration, Control, Status Register 081"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR081  ,Message Buffer Cycle Counter Filter Register 081"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR081  ,Message Buffer Frame ID Register 081"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR081  ,Message Buffer Index Register 081"
  group.word ((0xFFFE0000+0x0390))++0x07
      line.word    0x00 "MBCCSR082,Message Buffer Configuration, Control, Status Register 082"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR082  ,Message Buffer Cycle Counter Filter Register 082"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR082  ,Message Buffer Frame ID Register 082"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR082  ,Message Buffer Index Register 082"
  group.word ((0xFFFE0000+0x0398))++0x07
      line.word    0x00 "MBCCSR083,Message Buffer Configuration, Control, Status Register 083"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR083  ,Message Buffer Cycle Counter Filter Register 083"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR083  ,Message Buffer Frame ID Register 083"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR083  ,Message Buffer Index Register 083"
  group.word ((0xFFFE0000+0x03A0))++0x07
      line.word    0x00 "MBCCSR084,Message Buffer Configuration, Control, Status Register 084"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR084  ,Message Buffer Cycle Counter Filter Register 084"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR084  ,Message Buffer Frame ID Register 084"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR084  ,Message Buffer Index Register 084"
  group.word ((0xFFFE0000+0x03A8))++0x07
      line.word    0x00 "MBCCSR085,Message Buffer Configuration, Control, Status Register 085"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR085  ,Message Buffer Cycle Counter Filter Register 085"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR085  ,Message Buffer Frame ID Register 085"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR085  ,Message Buffer Index Register 085"
  group.word ((0xFFFE0000+0x03B0))++0x07
      line.word    0x00 "MBCCSR086,Message Buffer Configuration, Control, Status Register 086"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR086  ,Message Buffer Cycle Counter Filter Register 086"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR086  ,Message Buffer Frame ID Register 086"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR086  ,Message Buffer Index Register 086"
  group.word ((0xFFFE0000+0x03B8))++0x07
      line.word    0x00 "MBCCSR087,Message Buffer Configuration, Control, Status Register 087"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR087  ,Message Buffer Cycle Counter Filter Register 087"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR087  ,Message Buffer Frame ID Register 087"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR087  ,Message Buffer Index Register 087"
  TEXTLINE ""
  group.word ((0xFFFE0000+0x03C0))++0x07
      line.word    0x00 "MBCCSR088,Message Buffer Configuration, Control, Status Register 088"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR088  ,Message Buffer Cycle Counter Filter Register 088"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR088  ,Message Buffer Frame ID Register 088"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR088  ,Message Buffer Index Register 088"
  group.word ((0xFFFE0000+0x03C8))++0x07
      line.word    0x00 "MBCCSR089,Message Buffer Configuration, Control, Status Register 089"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR089  ,Message Buffer Cycle Counter Filter Register 089"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR089  ,Message Buffer Frame ID Register 089"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR089  ,Message Buffer Index Register 089"
  group.word ((0xFFFE0000+0x03D0))++0x07
      line.word    0x00 "MBCCSR090,Message Buffer Configuration, Control, Status Register 090"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR090  ,Message Buffer Cycle Counter Filter Register 090"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR090  ,Message Buffer Frame ID Register 090"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR090  ,Message Buffer Index Register 090"
  group.word ((0xFFFE0000+0x03D8))++0x07
      line.word    0x00 "MBCCSR091,Message Buffer Configuration, Control, Status Register 091"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR091  ,Message Buffer Cycle Counter Filter Register 091"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR091  ,Message Buffer Frame ID Register 091"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR091  ,Message Buffer Index Register 091"
  group.word ((0xFFFE0000+0x03E0))++0x07
      line.word    0x00 "MBCCSR092,Message Buffer Configuration, Control, Status Register 092"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR092  ,Message Buffer Cycle Counter Filter Register 092"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR092  ,Message Buffer Frame ID Register 092"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR092  ,Message Buffer Index Register 092"
  group.word ((0xFFFE0000+0x03E8))++0x07
      line.word    0x00 "MBCCSR093,Message Buffer Configuration, Control, Status Register 093"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR093  ,Message Buffer Cycle Counter Filter Register 093"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR093  ,Message Buffer Frame ID Register 093"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR093  ,Message Buffer Index Register 093"
  group.word ((0xFFFE0000+0x03F0))++0x07
      line.word    0x00 "MBCCSR094,Message Buffer Configuration, Control, Status Register 094"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR094  ,Message Buffer Cycle Counter Filter Register 094"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR094  ,Message Buffer Frame ID Register 094"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR094  ,Message Buffer Index Register 094"
  group.word ((0xFFFE0000+0x03F8))++0x07
      line.word    0x00 "MBCCSR095,Message Buffer Configuration, Control, Status Register 095"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR095  ,Message Buffer Cycle Counter Filter Register 095"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR095  ,Message Buffer Frame ID Register 095"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR095  ,Message Buffer Index Register 095"
  TEXTLINE ""
  group.word ((0xFFFE0000+0x0400))++0x07
      line.word    0x00 "MBCCSR096,Message Buffer Configuration, Control, Status Register 096"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR096  ,Message Buffer Cycle Counter Filter Register 096"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR096  ,Message Buffer Frame ID Register 096"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR096  ,Message Buffer Index Register 096"
  group.word ((0xFFFE0000+0x0408))++0x07
      line.word    0x00 "MBCCSR097,Message Buffer Configuration, Control, Status Register 097"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR097  ,Message Buffer Cycle Counter Filter Register 097"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR097  ,Message Buffer Frame ID Register 097"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR097  ,Message Buffer Index Register 097"
  group.word ((0xFFFE0000+0x0410))++0x07
      line.word    0x00 "MBCCSR098,Message Buffer Configuration, Control, Status Register 098"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR098  ,Message Buffer Cycle Counter Filter Register 098"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR098  ,Message Buffer Frame ID Register 098"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR098  ,Message Buffer Index Register 098"
  group.word ((0xFFFE0000+0x0418))++0x07
      line.word    0x00 "MBCCSR099,Message Buffer Configuration, Control, Status Register 099"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR099  ,Message Buffer Cycle Counter Filter Register 099"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR099  ,Message Buffer Frame ID Register 099"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR099  ,Message Buffer Index Register 099"
  group.word ((0xFFFE0000+0x0420))++0x07
      line.word    0x00 "MBCCSR100,Message Buffer Configuration, Control, Status Register 100"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR100  ,Message Buffer Cycle Counter Filter Register 100"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR100  ,Message Buffer Frame ID Register 100"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR100  ,Message Buffer Index Register 100"
  group.word ((0xFFFE0000+0x0428))++0x07
      line.word    0x00 "MBCCSR101,Message Buffer Configuration, Control, Status Register 101"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR101  ,Message Buffer Cycle Counter Filter Register 101"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR101  ,Message Buffer Frame ID Register 101"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR101  ,Message Buffer Index Register 101"
  group.word ((0xFFFE0000+0x0430))++0x07
      line.word    0x00 "MBCCSR102,Message Buffer Configuration, Control, Status Register 102"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR102  ,Message Buffer Cycle Counter Filter Register 102"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR102  ,Message Buffer Frame ID Register 102"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR102  ,Message Buffer Index Register 102"
  group.word ((0xFFFE0000+0x0438))++0x07
      line.word    0x00 "MBCCSR103,Message Buffer Configuration, Control, Status Register 103"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR103  ,Message Buffer Cycle Counter Filter Register 103"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR103  ,Message Buffer Frame ID Register 103"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR103  ,Message Buffer Index Register 103"
  TEXTLINE ""
  group.word ((0xFFFE0000+0x0440))++0x07
      line.word    0x00 "MBCCSR104,Message Buffer Configuration, Control, Status Register 104"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR104  ,Message Buffer Cycle Counter Filter Register 104"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR104  ,Message Buffer Frame ID Register 104"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR104  ,Message Buffer Index Register 104"
  group.word ((0xFFFE0000+0x0448))++0x07
      line.word    0x00 "MBCCSR105,Message Buffer Configuration, Control, Status Register 105"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR105  ,Message Buffer Cycle Counter Filter Register 105"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR105  ,Message Buffer Frame ID Register 105"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR105  ,Message Buffer Index Register 105"
  group.word ((0xFFFE0000+0x0450))++0x07
      line.word    0x00 "MBCCSR106,Message Buffer Configuration, Control, Status Register 106"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR106  ,Message Buffer Cycle Counter Filter Register 106"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR106  ,Message Buffer Frame ID Register 106"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR106  ,Message Buffer Index Register 106"
  group.word ((0xFFFE0000+0x0458))++0x07
      line.word    0x00 "MBCCSR107,Message Buffer Configuration, Control, Status Register 107"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR107  ,Message Buffer Cycle Counter Filter Register 107"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR107  ,Message Buffer Frame ID Register 107"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR107  ,Message Buffer Index Register 107"
  group.word ((0xFFFE0000+0x0460))++0x07
      line.word    0x00 "MBCCSR108,Message Buffer Configuration, Control, Status Register 108"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR108  ,Message Buffer Cycle Counter Filter Register 108"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR108  ,Message Buffer Frame ID Register 108"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR108  ,Message Buffer Index Register 108"
  group.word ((0xFFFE0000+0x0468))++0x07
      line.word    0x00 "MBCCSR109,Message Buffer Configuration, Control, Status Register 109"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR109  ,Message Buffer Cycle Counter Filter Register 109"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR109  ,Message Buffer Frame ID Register 109"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR109  ,Message Buffer Index Register 109"
  group.word ((0xFFFE0000+0x0470))++0x07
      line.word    0x00 "MBCCSR110,Message Buffer Configuration, Control, Status Register 110"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR110  ,Message Buffer Cycle Counter Filter Register 110"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR110  ,Message Buffer Frame ID Register 110"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR110  ,Message Buffer Index Register 110"
  group.word ((0xFFFE0000+0x0478))++0x07
      line.word    0x00 "MBCCSR111,Message Buffer Configuration, Control, Status Register 111"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR111  ,Message Buffer Cycle Counter Filter Register 111"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR111  ,Message Buffer Frame ID Register 111"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR111  ,Message Buffer Index Register 111"
  TEXTLINE ""
  group.word ((0xFFFE0000+0x0480))++0x07
      line.word    0x00 "MBCCSR112,Message Buffer Configuration, Control, Status Register 112"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR112  ,Message Buffer Cycle Counter Filter Register 112"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR112  ,Message Buffer Frame ID Register 112"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR112  ,Message Buffer Index Register 112"
  group.word ((0xFFFE0000+0x0488))++0x07
      line.word    0x00 "MBCCSR113,Message Buffer Configuration, Control, Status Register 113"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR113  ,Message Buffer Cycle Counter Filter Register 113"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR113  ,Message Buffer Frame ID Register 113"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR113  ,Message Buffer Index Register 113"
  group.word ((0xFFFE0000+0x0490))++0x07
      line.word    0x00 "MBCCSR114,Message Buffer Configuration, Control, Status Register 114"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR114  ,Message Buffer Cycle Counter Filter Register 114"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR114  ,Message Buffer Frame ID Register 114"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR114  ,Message Buffer Index Register 114"
  group.word ((0xFFFE0000+0x0498))++0x07
      line.word    0x00 "MBCCSR115,Message Buffer Configuration, Control, Status Register 115"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR115  ,Message Buffer Cycle Counter Filter Register 115"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR115  ,Message Buffer Frame ID Register 115"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR115  ,Message Buffer Index Register 115"
  group.word ((0xFFFE0000+0x04A0))++0x07
      line.word    0x00 "MBCCSR116,Message Buffer Configuration, Control, Status Register 116"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR116  ,Message Buffer Cycle Counter Filter Register 116"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR116  ,Message Buffer Frame ID Register 116"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR116  ,Message Buffer Index Register 116"
  group.word ((0xFFFE0000+0x04A8))++0x07
      line.word    0x00 "MBCCSR117,Message Buffer Configuration, Control, Status Register 117"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR117  ,Message Buffer Cycle Counter Filter Register 117"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR117  ,Message Buffer Frame ID Register 117"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR117  ,Message Buffer Index Register 117"
  group.word ((0xFFFE0000+0x04B0))++0x07
      line.word    0x00 "MBCCSR118,Message Buffer Configuration, Control, Status Register 118"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR118  ,Message Buffer Cycle Counter Filter Register 118"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR118  ,Message Buffer Frame ID Register 118"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR118  ,Message Buffer Index Register 118"
  group.word ((0xFFFE0000+0x04B8))++0x07
      line.word    0x00 "MBCCSR119,Message Buffer Configuration, Control, Status Register 119"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR119  ,Message Buffer Cycle Counter Filter Register 119"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR119  ,Message Buffer Frame ID Register 119"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR119  ,Message Buffer Index Register 119"
  TEXTLINE ""
  group.word ((0xFFFE0000+0x04C0))++0x07
      line.word    0x00 "MBCCSR120,Message Buffer Configuration, Control, Status Register 120"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR120  ,Message Buffer Cycle Counter Filter Register 120"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR120  ,Message Buffer Frame ID Register 120"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR120  ,Message Buffer Index Register 120"
  group.word ((0xFFFE0000+0x04C8))++0x07
      line.word    0x00 "MBCCSR121,Message Buffer Configuration, Control, Status Register 121"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR121  ,Message Buffer Cycle Counter Filter Register 121"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR121  ,Message Buffer Frame ID Register 121"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR121  ,Message Buffer Index Register 121"
  group.word ((0xFFFE0000+0x04D0))++0x07
      line.word    0x00 "MBCCSR122,Message Buffer Configuration, Control, Status Register 122"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR122  ,Message Buffer Cycle Counter Filter Register 122"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR122  ,Message Buffer Frame ID Register 122"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR122  ,Message Buffer Index Register 122"
  group.word ((0xFFFE0000+0x04D8))++0x07
      line.word    0x00 "MBCCSR123,Message Buffer Configuration, Control, Status Register 123"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR123  ,Message Buffer Cycle Counter Filter Register 123"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR123  ,Message Buffer Frame ID Register 123"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR123  ,Message Buffer Index Register 123"
  group.word ((0xFFFE0000+0x04E0))++0x07
      line.word    0x00 "MBCCSR124,Message Buffer Configuration, Control, Status Register 124"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR124  ,Message Buffer Cycle Counter Filter Register 124"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR124  ,Message Buffer Frame ID Register 124"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR124  ,Message Buffer Index Register 124"
  group.word ((0xFFFE0000+0x04E8))++0x07
      line.word    0x00 "MBCCSR125,Message Buffer Configuration, Control, Status Register 125"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR125  ,Message Buffer Cycle Counter Filter Register 125"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR125  ,Message Buffer Frame ID Register 125"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR125  ,Message Buffer Index Register 125"
  group.word ((0xFFFE0000+0x04F0))++0x07
      line.word    0x00 "MBCCSR126,Message Buffer Configuration, Control, Status Register 126"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR126  ,Message Buffer Cycle Counter Filter Register 126"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR126  ,Message Buffer Frame ID Register 126"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR126  ,Message Buffer Index Register 126"
  group.word ((0xFFFE0000+0x04F8))++0x07
      line.word    0x00 "MBCCSR127,Message Buffer Configuration, Control, Status Register 127"
      hexmask.word 0x02 0.--15. 1. "  MBCCFR127  ,Message Buffer Cycle Counter Filter Register 127"
      hexmask.word 0x04 0.--15. 1. "  MBFIDR127  ,Message Buffer Frame ID Register 127"
      hexmask.word 0x06 0.--15. 1. "  MBIDXR127  ,Message Buffer Index Register 127"
  TEXTLINE ""
  tree.end

tree.end

width 9.
config 9. 8.

endif

sif (cpu()=="MPC5561")

tree "Parallel Digital Interface"

group.long 0xFFFE8000++0x03
  line.long    0x00 "PDIMCR,PDI Module Configuration Register"
    bitfld.long  0 30.--31.         "OP_MODE      ,This field specifies the PDI operation mode" "res.,ADC,ISM,BIST"
    bitfld.long  0 29.            "      DPK_MODE     ,Determines how the samples will be stored in the FIFO element" "0,1"
    bitfld.long  0 28.            "         DATA_EN      ,Disable latching in of sensor data to the PDI" "0,1"
TEXTLINE "                "    
    bitfld.long  0 27.            "  ADC_CH_EN    ,Provide a way to disable the ADC Channel Mux Select sequence for new START_CH and NUM_CH fields to be reprogrammed" "0,1"
    bitfld.long  0 21.--23.       "         PORT_WIDTH   ,Specifies the port width of the sensor data" "8 bits,10 bits,12 bits,14 bits,16 bits,res.,res.,res."
    bitfld.long  0 20.            "   SEN_CLK_EDGE ,Selects the active clock edge to latch data" "rising,falling"
TEXTLINE "                "    
    bitfld.long  0 18.            "  FV_POL       ,Sets the polarity of the Frame Valid signal" "act low,act high"
    bitfld.long  0 17.            "  LV_POL       ,Sets the polarity of the Line Valid signal" "act low,act high"
    bitfld.long  0 16.            "  INV_DATA     ,Invert the sensor data before latching into the PDI" "0,1"
TEXTLINE "                "    
    bitfld.long  0 15.            "  FIFO_RST     ,Resets the contents of the FIFO" "0,1"
    bitfld.long  0 00.--03.       "         FIFO_TRIGGER ,Generates a DMA request if the number of elements in the FIFO is larger or equal to the FIFO_TRIGGER field" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
TEXTLINE ""    
  
group.long 0xFFFE8004++0x03
  line.long    0x00 "PDIADCCR,PDI ADC Configuration Register"
    bitfld.long  0 04.--06.         "NUM_CH       ,Total number of analog sensor channels to be multiplexed at the input of the ADC." "1,2,3,4,5,6,7,8"
    bitfld.long  0 00.--02.       "         START_CH     ,This field specifies which channel to start the round robin cycling of the ADC Sensor Channel Select signals." "1,2,3,4,5,6,7,8"
TEXTLINE ""    

  
group.long 0xFFFE8008++0x03
  line.long    0x00 "PDISR,PDI Status Register"
    bitfld.long  0 31.              "FIFO_FULL    ,This indicates that the FIFO is completely filled with data" "0,1"
    bitfld.long  0 30.            "         FIFO_EMP     ,This indicates that there is no data in the FIFO" "0,1"
TEXTLINE "                "    
    bitfld.long  0 29.            "  FIFO_OV      ,A FIFO overflow error is asserted when an element is written to the FIFO when it is already full." "0,1"
    bitfld.long  0 28.            "         FIFO_UN      ,A FIFO underflow error is asserted when an attempt to read the FIFO when it is empty" "0,1"
    bitfld.long  0 27.            "         FIFO_TRG     ,This status bit indicates that FIFO trigger event has occured" "0,1"
TEXTLINE "                "    
    bitfld.long  0 22.            "  LINE_VLD     ,This status bit signifies that a horizontal line valid event where the ipp_di_pdi_hsync signal has transitioned to be active has occured" "0,1"
    bitfld.long  0 21.            "         FRM_VLD      ,This status bit indicates that a vertical frame valid event where the Frame-Valid signal has transitioned to be active has occured" "0,1"
TEXTLINE ""    
  
group.long 0xFFFE800C++0x03
  line.long    0x00 "PDIINTER,PDI Interrupt Enable Register"
    bitfld.long  0 29.              "FIFO_OV      ,A FIFO overflow error interrupt enable" "0,1"
    bitfld.long  0 28.            "         FIFO_UN      ,A FIFO underflow error interrupt enable" "0,1"
    bitfld.long  0 27.            "         FIFO_TRG     ,FIFO trigger event interrupt enable" "0,1"
TEXTLINE "                "    
    bitfld.long  0 22.            "  LINE_VLD     ,line valid event interrupt enable" "0,1"
    bitfld.long  0 21.            "         FRM_VLD      ,frame valid event  interrupt enable" "0,1"
TEXTLINE ""    
  
group.long 0xFFFE8010++0x03
  line.long    0x00 "PDIADCCR,PDI Active Frame Origin Register"
    hexmask.long.word 0 16.--27. 1.     "ACT_FRM_ORG_X  ,PDI Active Frame top left corner X coordinate"
    hexmask.long.word 0 00.--11. 1.   "  ACT_FRM_ORG_Y  ,PDI Active Frame top corner Y coordinate"

group.long 0xFFFE8014++0x03
  line.long    0x00 "PDIAFSR,PDI Active Frame Size Register"
    hexmask.long.word 0 16.--27. 1.     "ACT_FRM_HEIGHT ,PDI Active Frame Height"
    hexmask.long.word 0 00.--11. 1.   "  ACT_FRM_WIDTH  ,PDI Active Frame Width"
TEXTLINE ""    

group.long 0xFFFE8018++0x03
  line.long    0x00 "PDIBIST1R,PDI Built in Self Test 1 Register"
    hexmask.long.word 0 00.--15. 1.   "TEST_VALUE_1   ,Specifies the internal built in pattern to be generated"
  
group.long 0xFFFE801C++0x03
  line.long    0x00 "PDIBIST2R,PDI Built in Self Test 2 Register"
    hexmask.long.word 0 16.--31. 1.   "TEST_VALUE_2   ,Test Value 2 used to populate the test mode data patterns"
    hexmask.long.word 0 00.--15. 1.   "  TEST_VALUE_3   ,Test Value 3 used to populate the test mode data patterns"

tree.end

endif


config 16. 8.
width 9. 10.

base DBG:0x00
tree "Nexus Registers"

tree "CPU trace control registers"
tree "Debug Register"
 group 0x200--0x203
 line.long 0x00 "DID, Device ID Register"
 hexmask.long.word 0x00 28.--31. 1    "PRN    , Part Revision Number" 
 hexmask.long.word 0x00 22.--27. 1  "  DC     , Design Center" 
 hexmask.long.word 0x00 12.--21. 1  "  PIN    , Part Identification Number" 
 hexmask.long.word 0x00 01.--11. 1  "  MIC    , Manufacturer Identification Code" 
textline ""
 group 0x1fc--0x1ff
 line.long 0x00 "PCR, Port Configuration Register"
 bitfld.long 0x00 31.                "FPM    ,Full Port Mode"               "red ,full"
 bitfld.long 0x00 30.              "  MCKOGT ,MCKO Clock Gating Control"    "dis ,ena"
 bitfld.long 0x00 29.              "  MCKOEN ,MCKO Enable"                  "off ,on"
 bitfld.long 0x00 26.--28.         "  MCKODV ,MCKO Division Factor"         "1/1 ,1/2,res.,1/4,res.,res.,res.,1/8"
 bitfld.long 0x00 0.               "  PSTAT  ,Processor Status Mode Enable" "dis ,ena"
textline ""
 group 0x10--0x13
 line.long 0x00 "DC1,Development Control Register 1"
 bitfld.long 0x00 31.                "OPC    , Output Port Mode Control"  "red ,full"
 bitfld.long 0x00 29.--30.         "  MCKDV  , MCKO Clock Divide Ratio"   "1   ,1/2,1/4,1/8"
 bitfld.long 0x00 27.--28.         "  EOC    , EVTO Control"              "WP  ,DBM,TiS,res"
 bitfld.long 0x00 25.              "  PTM    , Program Trace Mehod"       "BTM ,BHTM"
 bitfld.long 0x00 24.              "  WEN    , Watchpoint Trace Enable"   "dis ,ena"
textline "                "
 bitfld.long 0x00 5.--7.           "  OVC    , Overrun Control"           "OvrM,,,dely,,,,,"
 bitfld.long 0x00 3.--4.           "  EIC    , EVTI Control"              "sync,DBrq,,,"
 bitfld.long 0x00 2.               "  PT-TM  , Program Trace"             "dis ,ena"
 bitfld.long 0x00 1.               "  DT-TM  , Data Trace"                "dis ,ena"
 bitfld.long 0x00 0.               "  OT-TM  , Ownership Trace"           "dis ,ena"
textline ""
 group 0x18--0x1B
 line.long 0x0 "DC2,Development Control Register 2"
 bitfld.long 0x0 31.                 "EWC7(IAC1)  , Watchpoint#0 (IAC1) triggers EVTO"  "no,yes"
 bitfld.long 0x0 30.               "  EWC6(IAC2)  , Watchpoint#1 (IAC2) triggers EVTO"  "no,yes"
 bitfld.long 0x0 29.               "  EWC5(IAC3)  , Watchpoint#2 (IAC3) triggers EVTO"  "no,yes"
 bitfld.long 0x0 28.               "  EWC4(IAC4)  , Watchpoint#3 (IAC4) triggers EVTO"  "no,yes"
textline "                "
 bitfld.long 0x0 27.               "  EWC3(DAC1)  , Watchpoint#4 (DAC1) triggers EVTO"  "no,yes"
 bitfld.long 0x0 26.               "  EWC2(DAC2)  , Watchpoint#5 (DAC2) triggers EVTO"  "no,yes"
 bitfld.long 0x0 25.               "  EWC1(DCNT1) , Watchpoint#6 (DCNT1) triggers EVTO" "no,yes"
 bitfld.long 0x0 24.               "  EWC0(DCNT2) , Watchpoint#7 (DCNT2) triggers EVTO" "no,yes"
textline ""
 group 0x20--0x23
 line.long 0x0 "DS,Development Status Register"
 bitfld.long 0x0 31.      "DBG ,Debug Mode Status" "running,debug mode"
 bitfld.long 0x0 26.--27. "  LPC ,CPU low power mode status " "run,halted,stopped,res."
 bitfld.long 0x0 25.      "  CHK ,CPU Checkstop Status" "normal,checkstop"
 textline ""
tree.end

tree "Nexus Memory Access Registers"
  group 0x38--0x3B
  line.long 0x0  "RWCS,Read/Write Access Control/Status "
  bitfld.long 0x0 31.          "AC  , Access Control" "end access,start access"
  bitfld.long 0x0 30.        " RW  , Read/Write Select" "read,write"
  bitfld.long 0x0 27.--29.   "  SZ   , Word Size" " 8b,16b,32b,64b,res,res,res,res"
  TEXTLINE "                "
  bitfld.long 0x0 24.--26.   "  MAP , Map Select" "primary,res.,res.,res.,res.,res.,res.,res."
  bitfld.long 0x0 22.--23.   "      PR  , Read/Write Acces Priority" "res,res,res,high"
  hexmask.long 0x0 2.--15. 1 "   CNT , Number of accesses of word size SZ" 
  TEXTLINE "                "
  bitfld.long 0x0 1.         "  ERR , Read/Write Access Error" "0,1"
  bitfld.long 0x0 0.         "            DV  , Read/Write Access Data valid" "0,1"
  TEXTLINE ""

  group 0x48--0x4b
  line.long 0x0 "RWA,Read/Write Access Address"
  TEXTLINE ""
  group 0x50--0x53
  line.long 0x0 "RWD,Read/Write Access Data"
tree.end

tree "Watchpoint Trigger Register"
 group 0x58--0x5b
 line.long 0x0 "WT,Watchpoint Trigger"
   bitfld.long 0x0 (29.)--(31.) "PTS ,Program Trace Start"   "dis,IAC1,IAC2,IAC3,IAC4,DAC1,DAC2,DCNT1/2"
   bitfld.long 0x0 (26.)--(28.) "  PTE ,Program Trace End"   "dis,IAC1,IAC2,IAC3,IAC4,DAC1,DAC2,DCNT1/2"
   bitfld.long 0x0 (23.)--(25.) "  DTS ,Data Trace Start"    "dis,IAC1,IAC2,IAC3,IAC4,DAC1,DAC2,DCNT1/2"
   bitfld.long 0x0 (20.)--(22.) "  DTE ,Data Trace End"      "dis,IAC1,IAC2,IAC3,IAC4,DAC1,DAC2,DCNT1/2"
tree.end

sif (CPU()!="MPC5633M")&&(CPU()!="MPC5634M")&&(CPU()!="SPC563M60")
tree "Data Trace Control Register"
 group 0x68--0x6b
 line.long 0x0 "DTC,Data Trace Control Register"
   bitfld.long 0x0 (30.)--(31.) "RWT1 , Read/Write Trace 1" " dis, DRT, DWT,DRWT"
   bitfld.long 0x0 (28.)--(29.) "  RWT2 , Read/Write Trace 2" " dis, DRT, DWT,DRWT"
   bitfld.long 0x0 7. "  RC1 , Range Control 1" " inr,outr"
   bitfld.long 0x0 6. "  RC2 , Range Control 2" " inr,outr"
   bitfld.long 0x0 3. "  DI1 , Data/Instruction Access Control 1" "data,inst"
   bitfld.long 0x0 6. "  DI2 , Data/Instruction Access Control 2" "data,inst"

 TEXTLINE ""

 group 0x70--0x73
 line.long 0x0 "DTSA1 , Data Trace Start Address 1"
 group 0x78--0x7b
 line.long 0x0 "DTSA2 , Data Trace Start Address 2"
 
 TEXTLINE ""
 
 group 0x90--0x93
 line.long 0x0 "DTEA1 , Data Trace End Address 1"
 group 0x98--0x9b
 line.long 0x0 "DTEA2 , Data Trace End Address 2"
tree.end
endif


tree.end

sif (CPU()!="MPC5633M")&&(CPU()!="MPC5634M")&&(CPU()!="SPC563M60")
config 16. 8.
width 9. 10.

tree "DMA Trace Control Registers"
 group (0x800+0x0008)++3
 line.long 0x0 "DC1,Development Control Register 1"
 bitfld.long 0x00 31.        "OPC   , Output Port Mode Control" "redu ,full"
 bitfld.long 0x00 29.--30. "  MDIV  , MCKO Clock Divide Ratio"  "1    ,1/2,1/4,1/8"
 bitfld.long 0x00 27.--28. "  EOC   , EVTO Control"             "WP   ,DBM,res.,res."
 textline "                "
 bitfld.long 0x00 24.      "  WEN   , Watchpoint Trace Enable"  "dis  ,ena"
 bitfld.long 0x00 3.--4.   "  EIC   , EVTI Control"             "sync ,res,DR,,"
 bitfld.long 0x00 1.       "  DT-TM , Data Trace"                        "dis  ,ena"

 group (0x800+0x000c)++3
 line.long 0x0 "DC2,Development Control Register 2"
 bitfld.long 0x0 27.         "EWC3  , Watchpoint#4 (BWA1) triggers EVTO" "no   ,yes"
 bitfld.long 0x0 26.       "  EWC2  , Watchpoint#5 (BWA2) triggers EVTO" "no   ,yes"

 group (0x800+0x002c)++3
 line.long 0x0 "WT,Watchpoint Trigger"
   bitfld.long 0x0 (23.)--(25.)   "DTS   ,Data Trace Start"               "dis  ,res,res,res,res,BWA1,BWA2,res"
   bitfld.long 0x0 (20.)--(22.) "  DTE   ,Data Trace End"                 "dis  ,res,res,res,res,BWA1,BWA2,res"

 group (0x800+0x0034)++3
 line.long 0x0 "DTC,Data Trace Control Register"
   bitfld.long 0x0 (30.)--(31.)   "RWT1  , Read/Write Trace 1"            "dis  ,read,write,rw"
   bitfld.long 0x0 (28.)--(29.) "  RWT2  , Read/Write Trace 2"            "dis  ,read,write,rw"
   bitfld.long 0x0 7.           "  RC1   , Range Control 1"               "in   ,out"
   bitfld.long 0x0 6.           "  RC2   , Range Control 2"               "in   ,out"

 TEXTLINE ""

 group (0x800+0x0038)++3
 line.long 0x0 "DTSA1,Data Trace Start Address 1"
 group (0x800+0x003c)++3
 line.long 0x0 "DTSA2,Data Trace Start Address 2"

 TEXTLINE ""

 group (0x800+0x0048)++3
 line.long 0x0 "DTEA1,Data Trace End Address 1"
 group (0x800+0x004c)++3
 line.long 0x0 "DTEA2,Data Trace End Address 2"

 TEXTLINE ""

 group (0x800+0x0058)++3
 line.long 0x0 "BWC1,Breakpoint/Watchpoint Control Register"
   bitfld.long 0x0 30.--31.   "BWE1   ,Breakpoint/watchpoint #1 enable"            "dis  ,res,res,en"
   bitfld.long 0x0 28.--29. "  BRW1   ,Breakpoint/watchpoint #1 read/write select" "read ,write,rw,res."
   bitfld.long 0x0 16.--17. "  BWR1   ,Breakpoint/watchpoint #1 register compare"  "off  ,res.,BWA1,res."
   bitfld.long 0x0 15.      "  BWT1   ,Breakpoint/watchpoint #1 type"              "res. ,data"

 group (0x800+0x005C)++3
 line.long 0x0 "BWC2,Breakpoint/Watchpoint Control Register"
   bitfld.long 0x0 30.--31.   "BWE2   ,Breakpoint/watchpoint #2 enable"             "dis  ,res,res,en"
   bitfld.long 0x0 28.--29. "  BRW2   ,Breakpoint/watchpoint #2 read/write select"  "read ,write,rw,res."
   bitfld.long 0x0 16.--17. "  BWR2   ,Breakpoint/watchpoint #2 register compare"   "off  ,res.,BWA2,res."
   bitfld.long 0x0 15.      "  BWT2   ,Breakpoint/watchpoint #2 type"               "res. ,data"

 TEXTLINE ""

 group (0x800+0x0078)++3
 line.long 0x0 "BWA1,Breakpoint/Watchpoint Address 1 Register"
 group (0x800+0x007C)++3
 line.long 0x0 "BWA2,Breakpoint/Watchpoint Address 2 Register"
tree.end

endif

sif CPUIS("MPC5674*")
config 16. 8.
width 9. 10.

tree "DMA2 Trace Control Registers"
 group (0xC00+0x0008)++3
 line.long 0x0 "DC1,Development Control Register 1"
 bitfld.long 0x00 31.        "OPC   , Output Port Mode Control" "redu ,full"
 bitfld.long 0x00 29.--30. "  MDIV  , MCKO Clock Divide Ratio"  "1    ,1/2,1/4,1/8"
 bitfld.long 0x00 27.--28. "  EOC   , EVTO Control"             "WP   ,DBM,res.,res."
 textline "                "
 bitfld.long 0x00 24.      "  WEN   , Watchpoint Trace Enable"  "dis  ,ena"
 bitfld.long 0x00 3.--4.   "  EIC   , EVTI Control"             "sync ,res,DR,,"
 bitfld.long 0x00 1.       "  DT-TM , Data Trace"                        "dis  ,ena"

 group (0xC00+0x000c)++3
 line.long 0x0 "DC2,Development Control Register 2"
 bitfld.long 0x0 27.         "EWC3  , Watchpoint#4 (BWA1) triggers EVTO" "no   ,yes"
 bitfld.long 0x0 26.       "  EWC2  , Watchpoint#5 (BWA2) triggers EVTO" "no   ,yes"

 group (0xC00+0x002c)++3
 line.long 0x0 "WT,Watchpoint Trigger"
   bitfld.long 0x0 (23.)--(25.)   "DTS   ,Data Trace Start"               "dis  ,res,res,res,res,BWA1,BWA2,res"
   bitfld.long 0x0 (20.)--(22.) "  DTE   ,Data Trace End"                 "dis  ,res,res,res,res,BWA1,BWA2,res"

 group (0xC00+0x0034)++3
 line.long 0x0 "DTC,Data Trace Control Register"
   bitfld.long 0x0 (30.)--(31.)   "RWT1  , Read/Write Trace 1"            "dis  ,read,write,rw"
   bitfld.long 0x0 (28.)--(29.) "  RWT2  , Read/Write Trace 2"            "dis  ,read,write,rw"
   bitfld.long 0x0 7.           "  RC1   , Range Control 1"               "in   ,out"
   bitfld.long 0x0 6.           "  RC2   , Range Control 2"               "in   ,out"

 TEXTLINE ""

 group (0xC00+0x0038)++3
 line.long 0x0 "DTSA1,Data Trace Start Address 1"
 group (0xC00+0x003c)++3
 line.long 0x0 "DTSA2,Data Trace Start Address 2"

 TEXTLINE ""

 group (0xC00+0x0048)++3
 line.long 0x0 "DTEA1,Data Trace End Address 1"
 group (0xC00+0x004c)++3
 line.long 0x0 "DTEA2,Data Trace End Address 2"

 TEXTLINE ""

 group (0xC00+0x0058)++3
 line.long 0x0 "BWC1,Breakpoint/Watchpoint Control Register"
   bitfld.long 0x0 30.--31.   "BWE1   ,Breakpoint/watchpoint #1 enable"            "dis  ,res,res,en"
   bitfld.long 0x0 28.--29. "  BRW1   ,Breakpoint/watchpoint #1 read/write select" "read ,write,rw,res."
   bitfld.long 0x0 16.--17. "  BWR1   ,Breakpoint/watchpoint #1 register compare"  "off  ,res.,BWA1,res."
   bitfld.long 0x0 15.      "  BWT1   ,Breakpoint/watchpoint #1 type"              "res. ,data"

 group (0xC00+0x005C)++3
 line.long 0x0 "BWC2,Breakpoint/Watchpoint Control Register"
   bitfld.long 0x0 30.--31.   "BWE2   ,Breakpoint/watchpoint #2 enable"             "dis  ,res,res,en"
   bitfld.long 0x0 28.--29. "  BRW2   ,Breakpoint/watchpoint #2 read/write select"  "read ,write,rw,res."
   bitfld.long 0x0 16.--17. "  BWR2   ,Breakpoint/watchpoint #2 register compare"   "off  ,res.,BWA2,res."
   bitfld.long 0x0 15.      "  BWT2   ,Breakpoint/watchpoint #2 type"               "res. ,data"

 TEXTLINE ""

 group (0xC00+0x0078)++3
 line.long 0x0 "BWA1,Breakpoint/Watchpoint Address 1 Register"
 group (0xC00+0x007C)++3
 line.long 0x0 "BWA2,Breakpoint/Watchpoint Address 2 Register"
tree.end

endif

sif (cpu()=="MPC5561")||(CPUIS("MPC5674*"))
 tree "FlexRay Trace Control Register"
  group 0xA08++3
  line.long 0x0 "DC1,Development Control Register 1"
  bitfld.long 0x00 31.        "OPC   , Output Port Mode Control" "redu ,full"
  bitfld.long 0x00 29.--30. "  MDIV  , MCKO Clock Divide Ratio"  "1    ,1/2,1/4,1/8"
  bitfld.long 0x00 27.--28. "  EOC   , EVTO Control"             "WP   ,DBM,res.,res."
  textline "                "
  bitfld.long 0x00 24.        "WEN   , Watchpoint Trace Enable"  "dis  ,ena"
  bitfld.long 0x00 3.--4.   "  EIC   , EVTI Control"             "sync ,res,DR,,"
  bitfld.long 0x00 1.       "  DT-TM , Data Trace"                        "dis  ,ena"

  group 0xA0c++3
  line.long 0x0 "DC2,Development Control Register 2"
  bitfld.long 0x0 27.         "EWC3  , Watchpoint#4 (BWA1) triggers EVTO" "no   ,yes"
  bitfld.long 0x0 26.       "  EWC2  , Watchpoint#5 (BWA2) triggers EVTO" "no   ,yes"

  group 0xA2C++3
  line.long 0x0 "WT,Watchpoint Trigger"
    bitfld.long 0x0 (23.)--(25.)   "DTS   ,Data Trace Start"               "dis  ,res,res,res,res,BWA1,BWA2,res"
    bitfld.long 0x0 (20.)--(22.) "  DTE   ,Data Trace End"                 "dis  ,res,res,res,res,BWA1,BWA2,res"

  group 0xA34++3
  line.long 0x0 "DTC,Data Trace Control Register"
    bitfld.long 0x0 (30.)--(31.)   "RWT1  , Read/Write Trace 1"            "dis  ,read,write,rw"
    bitfld.long 0x0 (28.)--(29.) "  RWT2  , Read/Write Trace 2"            "dis  ,read,write,rw"
    bitfld.long 0x0 7.           "  RC1   , Range Control 1"               "in   ,out"
    bitfld.long 0x0 6.           "  RC2   , Range Control 2"               "in   ,out"

  TEXTLINE ""

  group 0xA38++3
  line.long 0x0 "DTSA1,Data Trace Start Address 1"
  group 0xA3C++3
  line.long 0x0 "DTSA2,Data Trace Start Address 2"

  TEXTLINE ""

  group 0xA48++3
  line.long 0x0 "DTEA1,Data Trace End Address 1"
  group 0xA4c++3
  line.long 0x0 "DTEA2,Data Trace End Address 2"

  TEXTLINE ""

  group 0xA58++3
  line.long 0x0 "BWC1,Breakpoint/Watchpoint Control Register"
    bitfld.long 0x0 30.--31.   "BWE1   ,Breakpoint/watchpoint #1 enable"            "dis  ,res,res,en"
    bitfld.long 0x0 28.--29. "  BRW1   ,Breakpoint/watchpoint #1 read/write select" "read ,write,rw,res."
    bitfld.long 0x0 16.--17. "  BWR1   ,Breakpoint/watchpoint #1 register compare"  "off  ,res.,BWA1,res."
    bitfld.long 0x0 15.      "  BWT1   ,Breakpoint/watchpoint #1 type"              "res. ,data"

  group 0xA5c++3
  line.long 0x0 "BWC2,Breakpoint/Watchpoint Control Register"
    bitfld.long 0x0 30.--31.   "BWE2   ,Breakpoint/watchpoint #2 enable"             "dis  ,res,res,en"
    bitfld.long 0x0 28.--29. "  BRW2   ,Breakpoint/watchpoint #2 read/write select"  "read ,write,rw,res."
    bitfld.long 0x0 16.--17. "  BWR2   ,Breakpoint/watchpoint #2 register compare"   "off  ,res.,BWA2,res."
    bitfld.long 0x0 15.      "  BWT2   ,Breakpoint/watchpoint #2 type"               "res. ,data"

  TEXTLINE ""

  group 0xA78++3
  line.long 0x0 "BWA1,Breakpoint/Watchpoint Address 1 Register"
  group 0xA7C++3
  line.long 0x0 "BWA2,Breakpoint/Watchpoint Address 2 Register"
 tree.end
endif


config 16. 8.
width 9. 10.

tree "eTPU1 Control Register"

tree "Device ID Register"
group (0x400+0x00)++3
line.long 0x0 "DID,Device ID Register"
tree.end

tree "Debug and Trace Control Registers"

group (0x400+0x114)++3
line.long 0x0 "MDR,Microinstruction Debug Register" 
TEXTLINE ""

group (0x400+0x118)++3
line.long 0x0 "MPC,Microinstruction Counter Debug Register" 
TEXTLINE ""

group (0x400+0x11c)++3
line.long 0x0 "CFSR,Channel Flag Status Register" 
  bitfld.long 0x0 31.      " V     , EAU Overflow Flag" "0,1"
  bitfld.long 0x0 30.      " N     , EAU Negative Flag" "0,1"
  bitfld.long 0x0 29.      " C     , EAU Carry Flag" "0,1"
  bitfld.long 0x0 28.      " Z     , EAU Carry Flag" "0,1"
 textline "                  "
  bitfld.long 0x0 27.      " MV    , MAC/Divide Unit Overflow Flag" "0,1"
  bitfld.long 0x0 26.      " MN    , MAC/Divide Unit Negative Flag" "0,1"
  bitfld.long 0x0 25.      " MC    , MAC/Divide Unit Carry Flag" "0,1"
  bitfld.long 0x0 24.      " MZ    , MAC/Divide Unit Carry Flag" "0,1"
 textline "                  "
  bitfld.long 0x0 23.      " TDL1  , Channel Transition Detection Latch 1Channel Transition" "0,1"
  bitfld.long 0x0 22.      " TDL2  , Channel Transition Detection Latch 2" "0,1"
  bitfld.long 0x0 21.      " MRL1  , Channel Match Recognition Latch 1" "0,1"
  bitfld.long 0x0 20.      " MRL2  , Channel Match Recognition Latch 2" "0,1"
 textline "                  "
  bitfld.long 0x0 19.      " LSR   , Channel Link Service Register" "0,1"
  bitfld.long 0x0 18.      " SMLCK , Channel Semaphore Flag" "0,1"
  bitfld.long 0x0 16.--17. " FM    , Channel Function Mode" "00,01,10,11"
 textline "                  "
  bitfld.long 0x0 15.      " SRI   , Service Request Inhibit" "0,1"
  bitfld.long 0x0 12.--14. " HSR   , Host Service Request" "0,1,2,3,4,5,6,7"
 textline "                  "
  bitfld.long 0x0 11.      " FLAG0 , Channel State Resolution Flag 0" "0,1"
  bitfld.long 0x0 10.      " FLAG1 , Channel State Resolution Flag 1" "0,1"
  bitfld.long 0x0 9.       " MRLE1 , Channel Match Recognition Latch Enable 1" "0,1"
  bitfld.long 0x0 8.       " MRLE2 , Channel Match Recognition Latch Enable 2" "0,1"
 textline "                  "
  bitfld.long 0x0 7.       " ITDL1 , Internal Channel Transition Detection" "0,1"
  bitfld.long 0x0 6.       " ITDL2 , Internal Channel Transition Detection" "0,1"
  bitfld.long 0x0 5.       " IMRL1 , Internal Channel Match Recognition" "0,1"
  bitfld.long 0x0 4.       " IMRL2 , Internal Channel Match Recognition" "0,1"
 textline "                  "
  bitfld.long 0x0 3.       " PSS   , Pin Sampled State" "0,1"
  bitfld.long 0x0 2.       " PSTI  , Pin State Input" "0,1"
  bitfld.long 0x0 1.       " PSTO  , Pin State Output" "0,1"
  bitfld.long 0x0 0.       " OBE   , Output Buffer Enable" "0,1"
TEXTLINE ""

group (0x400+0x08)++3 
line.long 0x0 "DC,Development Control Register"
bitfld.long 0x00 31.           "  CHW     ,ENGINEn CHAN register write trace" "0,1"
bitfld.long 0x00 30.           "  PINS    ,Stop pins in debug mode" "0,1"
bitfld.long 0x00 29.           "  CLKS    ,Stop TCR clocks" "0,1"
bitfld.long 0x00 28.           "  CBT     ,Client breakpoint timing" "0,1"
TEXTLINE "                  "
bitfld.long 0x00 27.           "  HTWN    ,Halt on twin engine breakpoint" "0,1"
bitfld.long 0x00 26.           "  EBC     ,EVTO breakpoint controller" "0,1"
bitfld.long 0x00 24.           "  CBR     ,Clear breakpoint request" "0,1"
bitfld.long 0x00 14.           "  CBI     ,Client breakpoint input" "0,1"
TEXTLINE "                  "
bitfld.long 0x00 13.           "  DBE     ,Debug enable" "0,1"
bitfld.long 0x00 12.           "  DBR     ,Debug request" "0,1"
bitfld.long 0x00 08.           "  SS      ,Single step enable" "0,1"
bitfld.long 0x00 05.--07.      "  OVC     ,Overrun control" "message,res.,res.,stall,res.,res.,res.,res."
TEXTLINE "                  "
bitfld.long 0x00 03.--04.      "  EIC   ,ENGINEn EVTI control." "snc,brk,nop,res"
bitfld.long 0x00 2.            "  PT-TM   , Program Trace" "0,1"
bitfld.long 0x00 1.            "  DT-TM   , Data Trace" "0,1"
bitfld.long 0x00 0.            "  OT-TM   , Ownership Trace" "0,1"
TEXTLINE ""

group (0x400+0x10)++3
line.long 0x0 "DS,Development Status Register"
bitfld.long 0x0 28.            "  HAT    ,Halted with active thread." " 0,1"
bitfld.long 0x0 27.            "  IIBP   ,Illegal instruction breakpoint status." " 0,1"
bitfld.long 0x0 26.            "  CBP    ,Client breakpoint status." " 0,1"
bitfld.long 0x0 25.            "  TBP    ,Twin breakpoint status." " 0,1"
TEXTLINE "                  "
bitfld.long 0x0 24.            "  EBP    ,EVTI breakpoint status." " 0,1"
bitfld.long 0x0 14.            "  BWC1   ,BWC1 breakpoint status." " 0,1"
bitfld.long 0x0 13.            "  BWC2   ,BWC2 breakpoint status." " 0,1"
bitfld.long 0x0 12.            "  CHAN   ,CHAN breakpoint status." " 0,1"
TEXTLINE "                  "
bitfld.long 0x0 11.            "  HSR    ,HSR breakpoint status." " 0,1"
bitfld.long 0x0 10.            "  LINK   ,LINK breakpoint status." " 0,1"
bitfld.long 0x0 09.            "  MRL    ,MRL breakpoint status." " 0,1"
bitfld.long 0x0 08.            "  TDL    ,TDL breakpoint status." " 0,1"
TEXTLINE "                  "
bitfld.long 0x0 05.            "  DBS    ,Debug status" " 0,1"
bitfld.long 0x0 04.            "  STP    ,Stop status" " 0,1"
bitfld.long 0x0 03.            "  HWE    ,Hardware error status" " 0,1"
bitfld.long 0x0 02.            "  HWB    ,Hardware breakpoint status" " 0,1"
TEXTLINE "                  "
bitfld.long 0x0 01.            "  SWB    ,Software breakpoint status" " 0,1"
bitfld.long 0x0 00.            "  SSS    ,Single step status" " 0,1"
TEXTLINE ""

group (0x400+0x2c)++3
line.long 0x0 "WT,Watchpoint Trigger"
  bitfld.long 0x0 (29.)--(31.) "  PTS  ,Program Trace Start" " dis, WP0, WP1, WP2, WP3, WP4, WP5,WP67,"
  bitfld.long 0x0 (26.)--(28.) "  PTE  ,Program Trace End" " dis, WP0, WP1, WP2, WP3, WP4, WP5,WP67,"
  bitfld.long 0x0 (23.)--(25.) "  DTS  ,Data Trace Start" " dis, WP0, WP1, WP2, WP3, WP4, WP5,WP67,"
  bitfld.long 0x0 (20.)--(22.) "  DTE  ,Data Trace End" " dis, WP0, WP1, WP2, WP3, WP4, WP5,WP67,"
TEXTLINE ""

  group (0x400+0x34)++3
  line.long 0x0 "DTC,Data Trace Control Register"
    bitfld.long 0x0 (30.)--(31.) "  RWT0 ,Read/Write Trace 0" " dis, DRT, DWT,DRWT"
    bitfld.long 0x0 (28.)--(29.) "  RWT1 ,Read/Write Trace 1" " dis, DRT, DWT,DRWT"
    bitfld.long 0x0 (26.)--(27.) "  RWT2 ,Read/Write Trace 2" " dis, DRT, DWT,DRWT"
    bitfld.long 0x0 (24.)--(25.) "  RWT3 ,Read/Write Trace 3" " dis, DRT, DWT,DRWT"
TEXTLINE "                  "
    bitfld.long 0x0 7.           "  RC0  ,Range Control 0" " inr,outr"
    bitfld.long 0x0 6.           "  RC1  ,Range Control 1" " inr,outr"
    bitfld.long 0x0 5.           "  RC2  ,Range Control 2" " inr,outr"
    bitfld.long 0x0 4.           "  RC3  ,Range Control 3" " inr,outr"
TEXTLINE ""
    
  group (0x400+0x104)++3
  line.long 0x0 "DTAR0,Data Trace Address Range 0" 
  hexmask.long.word 0x0 18.--29. 1   "  DTSA ,Data Trace Start Address"
  hexmask.long.word 0x0  2.--13. 1   "  DTEA ,Data Trace End Address"

  group (0x400+0x108)++3
  line.long 0x0 "DTAR1,Data Trace Address Range 1" 
  hexmask.long.word 0x0 18.--29. 1   "  DTSA ,Data Trace Start Address"
  hexmask.long.word 0x0  2.--13. 1   "  DTEA ,Data Trace End Address"

  group (0x400+0x10c)++3
  line.long 0x0 "DTAR2,Data Trace Address Range 2" 
  hexmask.long.word 0x0 18.--29. 1   "  DTSA ,Data Trace Start Address"
  hexmask.long.word 0x0  2.--13. 1   "  DTEA ,Data Trace End Address"

  group (0x400+0x110)++3
  line.long 0x0 "DTAR3,Data Trace Address Range 3" 
  hexmask.long.word 0x0 18.--29. 1   "  DTSA ,Data Trace Start Address"
  hexmask.long.word 0x0  2.--13. 1   "  DTEA ,Data Trace End Address"
TEXTLINE ""
   
group (0x400+0x58)++3
line.long 0x0 "BWC1,Breakpoint/Watchpoint Control Register"
  bitfld.long 0x0 (30.)--(31.) "  BWE1 ,Breakpoint/Watchpoint" " dis, BP, res, WP"
  bitfld.long 0x0 (28.)--(29.) "  BRW1  ,Read/Write Select" " RD, WR, RW, res"
  bitfld.long 0x0 (20.)--(23.) "  BME1 ,Data Mask Enable" "0000,0001,0010,0011,0100,0101,0110,0111,1000,1001,1010,1011,1100,1101,1110,1111"
  bitfld.long 0x0 (15.)--(17.) "  BWO  ,Breakpoint/Watchpoint Operand" "dis,dis,res,DATAVALUE(WR),INSTRADDR,DATAADDR(R/W),res.,DATAADDR+VALUE(WR)"
TEXTLINE "                  "
  bitfld.long 0x0 14.          "  EOC  ,EVTO Control" " dis,ENA"
  hexmask.long.byte 0x0 6.--10. 1   "  SCMSK ,Serviced Channel Mask Value "
  hexmask.long.byte 0x0 0.--4. 1    "  SCMV  ,Serviced Channel Match Value "
TEXTLINE ""

group (0x400+0x5c)++3
line.long 0x0 "BWC2,Breakpoint/Watchpoint Control Register"
  bitfld.long 0x0 (30.)--(31.) "  BWE1 ,Breakpoint/Watchpoint" " dis, BP, res, WP"
  bitfld.long 0x0 (28.)--(29.) "  BRW1  ,Read/Write Select" " RD, WR, RW, res"
  bitfld.long 0x0 (20.)--(23.) "  BME1 ,Data Mask Enable" "0000,0001,0010,0011,0100,0101,0110,0111,1000,1001,1010,1011,1100,1101,1110,1111"
  bitfld.long 0x0 (15.)--(17.) "  BWO  ,Breakpoint/Watchpoint Operand" "dis,dis,res,DATAVALUE(WR),INSTRADDR,DATAADDR(R/W),res.,DATAADDR+VALUE(WR)"
TEXTLINE "                  "
  bitfld.long 0x0 14.          "  EOC  ,EVTO Control" " dis,ENA"
  hexmask.word 0x0 6.--10. 1   "  SCMSK ,Serviced Channel Mask Value "
  hexmask.word 0x0 0.--4. 1    "  SCMV ,Serviced Channel Match Value "
TEXTLINE ""

group (0x400+0x60)++3
line.long 0x0 "BWC3,Breakpoint/Watchpoint Control Register"
  hexmask.long.byte 0x0 24.--28. 1  "  SCMV  ,Serviced Channel Match Value "
  hexmask.long.byte 0x0 16.--20. 1  " SCMSK ,Serviced Channel Mask Value "
  bitfld.long 0x0 (12.)--(14.) "  BCRW  ,Break on Channel Register Write" "000,001,010,011,100,101,110,111"
  bitfld.long 0x0 (9.)--(11.)  "  BHSR  ,Break on Host Service Request " "000,001,010,011,100,101,110,111"
TEXTLINE "                  "
  bitfld.long 0x0 (6.)--(8.)   "  BLINK  ,Break on Link Service Request " "000,001,010,011,100,101,110,111"
  bitfld.long 0x0 (3.)--(5.)   " BMRL   ,Break on Match Recognition Request " "000,001,010,011,100,101,110,111"
  bitfld.long 0x0 (0.)--(2.)   "  BTDL  ,Break on Transition Detect Request " "000,001,010,011,100,101,110,111"
TEXTLINE ""
  
group (0x400+0x78)++3
line.long 0x0 "BWA1 , Breakpoint/Watchpoint Address 1 Register"
 hexmask.long.word 0x0 18.--31. 1   "  BWAM  ,Breakpoint/Watchpoint Address Mask "
 hexmask.long.word 0x0 2.--15. 1    " BWA   , Breakpoint/Watchpoint Address "

group (0x400+0x7c)++3
line.long 0x0 "BWA2 , Breakpoint/Watchpoint Address 2 Register"
 hexmask.long.word 0x0 18.--31. 1   "  BWAM  ,Breakpoint/Watchpoint Address Mask "
 hexmask.long.word 0x0 2.--15. 1    " BWA   ,Breakpoint/Watchpoint Address "
TEXTLINE ""

group (0x400+0x98)++3
line.long 0x0 "BWD1,Breakpoint/Watchpoint Data 1 Register"

group (0x400+0x9c)++3
line.long 0x0 "BWD2,Breakpoint/Watchpoint Data 2 Register"
TEXTLINE ""

group (0x400+0x100)++3
line.long 0x0 "PTCE,Program Trace Channel Enable" 
TEXTLINE ""

tree.end

tree.end


sif (CPU()=="MPC5554")||(CPU()=="MPC5566")||(CPUIS("MPC5674*"))
config 16. 8.
width 9. 10.

tree "eTPU2 Control Register"

tree "Device ID Register"
group (0x600+0x00)++3
line.long 0x0 "DID,Device ID Register"
tree.end

tree "Debug and Trace Control Registers"

group (0x600+0x114)++3
line.long 0x0 "MDR,Microinstruction Debug Register" 
TEXTLINE ""

group (0x600+0x118)++3
line.long 0x0 "MPC,Microinstruction Counter Debug Register" 
TEXTLINE ""

group (0x600+0x11c)++3
line.long 0x0 "CFSR,Channel Flag Status Register" 
  bitfld.long 0x0 31.      " V     , EAU Overflow Flag" "0,1"
  bitfld.long 0x0 30.      " N     , EAU Negative Flag" "0,1"
  bitfld.long 0x0 29.      " C     , EAU Carry Flag" "0,1"
  bitfld.long 0x0 28.      " Z     , EAU Carry Flag" "0,1"
 textline "                  "
  bitfld.long 0x0 27.      " MV    , MAC/Divide Unit Overflow Flag" "0,1"
  bitfld.long 0x0 26.      " MN    , MAC/Divide Unit Negative Flag" "0,1"
  bitfld.long 0x0 25.      " MC    , MAC/Divide Unit Carry Flag" "0,1"
  bitfld.long 0x0 24.      " MZ    , MAC/Divide Unit Carry Flag" "0,1"
 textline "                  "
  bitfld.long 0x0 23.      " TDL1  , Channel Transition Detection Latch 1Channel Transition" "0,1"
  bitfld.long 0x0 22.      " TDL2  , Channel Transition Detection Latch 2" "0,1"
  bitfld.long 0x0 21.      " MRL1  , Channel Match Recognition Latch 1" "0,1"
  bitfld.long 0x0 20.      " MRL2  , Channel Match Recognition Latch 2" "0,1"
 textline "                  "
  bitfld.long 0x0 19.      " LSR   , Channel Link Service Register" "0,1"
  bitfld.long 0x0 18.      " SMLCK , Channel Semaphore Flag" "0,1"
  bitfld.long 0x0 16.--17. " FM    , Channel Function Mode" "00,01,10,11"
 textline "                  "
  bitfld.long 0x0 15.      " SRI   , Service Request Inhibit" "0,1"
  bitfld.long 0x0 12.--14. " HSR   , Host Service Request" "0,1,2,3,4,5,6,7"
 textline "                  "
  bitfld.long 0x0 11.      " FLAG0 , Channel State Resolution Flag 0" "0,1"
  bitfld.long 0x0 10.      " FLAG1 , Channel State Resolution Flag 1" "0,1"
  bitfld.long 0x0 9.       " MRLE1 , Channel Match Recognition Latch Enable 1" "0,1"
  bitfld.long 0x0 8.       " MRLE2 , Channel Match Recognition Latch Enable 2" "0,1"
 textline "                  "
  bitfld.long 0x0 7.       " ITDL1 , Internal Channel Transition Detection" "0,1"
  bitfld.long 0x0 6.       " ITDL2 , Internal Channel Transition Detection" "0,1"
  bitfld.long 0x0 5.       " IMRL1 , Internal Channel Match Recognition" "0,1"
  bitfld.long 0x0 4.       " IMRL2 , Internal Channel Match Recognition" "0,1"
 textline "                  "
  bitfld.long 0x0 3.       " PSS   , Pin Sampled State" "0,1"
  bitfld.long 0x0 2.       " PSTI  , Pin State Input" "0,1"
  bitfld.long 0x0 1.       " PSTO  , Pin State Output" "0,1"
  bitfld.long 0x0 0.       " OBE   , Output Buffer Enable" "0,1"
TEXTLINE ""

group (0x600+0x08)++3 
line.long 0x0 "DC,Development Control Register"
bitfld.long 0x00 31.           "  CHW     ,ENGINEn CHAN register write trace" "0,1"
bitfld.long 0x00 30.           "  PINS    ,Stop pins in debug mode" "0,1"
bitfld.long 0x00 29.           "  CLKS    ,Stop TCR clocks" "0,1"
bitfld.long 0x00 28.           "  CBT     ,Client breakpoint timing" "0,1"
TEXTLINE "                  "
bitfld.long 0x00 27.           "  HTWN    ,Halt on twin engine breakpoint" "0,1"
bitfld.long 0x00 26.           "  EBC     ,EVTO breakpoint controller" "0,1"
bitfld.long 0x00 24.           "  CBR     ,Clear breakpoint request" "0,1"
bitfld.long 0x00 14.           "  CBI     ,Client breakpoint input" "0,1"
TEXTLINE "                  "
bitfld.long 0x00 13.           "  DBE     ,Debug enable" "0,1"
bitfld.long 0x00 12.           "  DBR     ,Debug request" "0,1"
bitfld.long 0x00 08.           "  SS      ,Single step enable" "0,1"
bitfld.long 0x00 05.--07.      "  OVC     ,Overrun control" "message,res.,res.,stall,res.,res.,res.,res."
TEXTLINE "                  "
bitfld.long 0x00 03.--04.      "  EIC   ,ENGINEn EVTI control." "snc,brk,nop,res"
bitfld.long 0x00 2.            "  PT-TM   , Program Trace" "0,1"
bitfld.long 0x00 1.            "  DT-TM   , Data Trace" "0,1"
bitfld.long 0x00 0.            "  OT-TM   , Ownership Trace" "0,1"
TEXTLINE ""

group (0x600+0x10)++3
line.long 0x0 "DS,Development Status Register"
bitfld.long 0x0 28.            "  HAT    ,Halted with active thread." " 0,1"
bitfld.long 0x0 27.            "  IIBP   ,Illegal instruction breakpoint status." " 0,1"
bitfld.long 0x0 26.            "  CBP    ,Client breakpoint status." " 0,1"
bitfld.long 0x0 25.            "  TBP    ,Twin breakpoint status." " 0,1"
TEXTLINE "                  "
bitfld.long 0x0 24.            "  EBP    ,EVTI breakpoint status." " 0,1"
bitfld.long 0x0 14.            "  BWC1   ,BWC1 breakpoint status." " 0,1"
bitfld.long 0x0 13.            "  BWC2   ,BWC2 breakpoint status." " 0,1"
bitfld.long 0x0 12.            "  CHAN   ,CHAN breakpoint status." " 0,1"
TEXTLINE "                  "
bitfld.long 0x0 11.            "  HSR    ,HSR breakpoint status." " 0,1"
bitfld.long 0x0 10.            "  LINK   ,LINK breakpoint status." " 0,1"
bitfld.long 0x0 09.            "  MRL    ,MRL breakpoint status." " 0,1"
bitfld.long 0x0 08.            "  TDL    ,TDL breakpoint status." " 0,1"
TEXTLINE "                  "
bitfld.long 0x0 05.            "  DBS    ,Debug status" " 0,1"
bitfld.long 0x0 04.            "  STP    ,Stop status" " 0,1"
bitfld.long 0x0 03.            "  HWE    ,Hardware error status" " 0,1"
bitfld.long 0x0 02.            "  HWB    ,Hardware breakpoint status" " 0,1"
TEXTLINE "                  "
bitfld.long 0x0 01.            "  SWB    ,Software breakpoint status" " 0,1"
bitfld.long 0x0 00.            "  SSS    ,Single step status" " 0,1"
TEXTLINE ""

group (0x600+0x2c)++3
line.long 0x0 "WT,Watchpoint Trigger"
  bitfld.long 0x0 (29.)--(31.) "  PTS  ,Program Trace Start" " dis, WP0, WP1, WP2, WP3, WP4, WP5,WP67,"
  bitfld.long 0x0 (26.)--(28.) "  PTE  ,Program Trace End" " dis, WP0, WP1, WP2, WP3, WP4, WP5,WP67,"
  bitfld.long 0x0 (23.)--(25.) "  DTS  ,Data Trace Start" " dis, WP0, WP1, WP2, WP3, WP4, WP5,WP67,"
  bitfld.long 0x0 (20.)--(22.) "  DTE  ,Data Trace End" " dis, WP0, WP1, WP2, WP3, WP4, WP5,WP67,"
TEXTLINE ""

  group (0x600+0x34)++3
  line.long 0x0 "DTC,Data Trace Control Register"
    bitfld.long 0x0 (30.)--(31.) "  RWT0 ,Read/Write Trace 0" " dis, DRT, DWT,DRWT"
    bitfld.long 0x0 (28.)--(29.) "  RWT1 ,Read/Write Trace 1" " dis, DRT, DWT,DRWT"
    bitfld.long 0x0 (26.)--(27.) "  RWT2 ,Read/Write Trace 2" " dis, DRT, DWT,DRWT"
    bitfld.long 0x0 (24.)--(25.) "  RWT3 ,Read/Write Trace 3" " dis, DRT, DWT,DRWT"
TEXTLINE "                  "
    bitfld.long 0x0 7.           "  RC0  ,Range Control 0" " inr,outr"
    bitfld.long 0x0 6.           "  RC1  ,Range Control 1" " inr,outr"
    bitfld.long 0x0 5.           "  RC2  ,Range Control 2" " inr,outr"
    bitfld.long 0x0 4.           "  RC3  ,Range Control 3" " inr,outr"
TEXTLINE ""
    
  group (0x600+0x104)++3
  line.long 0x0 "DTAR0,Data Trace Address Range 0" 
  hexmask.long.word 0x0 18.--29. 1   "  DTSA ,Data Trace Start Address"
  hexmask.long.word 0x0  2.--13. 1   "  DTEA ,Data Trace End Address"

  group (0x600+0x108)++3
  line.long 0x0 "DTAR1,Data Trace Address Range 1" 
  hexmask.long.word 0x0 18.--29. 1   "  DTSA ,Data Trace Start Address"
  hexmask.long.word 0x0  2.--13. 1   "  DTEA ,Data Trace End Address"

  group (0x600+0x10c)++3
  line.long 0x0 "DTAR2,Data Trace Address Range 2" 
  hexmask.long.word 0x0 18.--29. 1   "  DTSA ,Data Trace Start Address"
  hexmask.long.word 0x0  2.--13. 1   "  DTEA ,Data Trace End Address"

  group (0x600+0x110)++3
  line.long 0x0 "DTAR3,Data Trace Address Range 3" 
  hexmask.long.word 0x0 18.--29. 1   "  DTSA ,Data Trace Start Address"
  hexmask.long.word 0x0  2.--13. 1   "  DTEA ,Data Trace End Address"
TEXTLINE ""
   
group (0x600+0x58)++3
line.long 0x0 "BWC1,Breakpoint/Watchpoint Control Register"
  bitfld.long 0x0 (30.)--(31.) "  BWE1 ,Breakpoint/Watchpoint" " dis, BP, res, WP"
  bitfld.long 0x0 (28.)--(29.) "  BRW1  ,Read/Write Select" " RD, WR, RW, res"
  bitfld.long 0x0 (20.)--(23.) "  BME1 ,Data Mask Enable" "0000,0001,0010,0011,0100,0101,0110,0111,1000,1001,1010,1011,1100,1101,1110,1111"
  bitfld.long 0x0 (15.)--(17.) "  BWO  ,Breakpoint/Watchpoint Operand" "dis,dis,res,DATAVALUE(WR),INSTRADDR,DATAADDR(R/W),res.,DATAADDR+VALUE(WR)"
TEXTLINE "                  "
  bitfld.long 0x0 14.          "  EOC  ,EVTO Control" " dis,ENA"
  hexmask.long.byte 0x0 6.--10. 1   "  SCMSK ,Serviced Channel Mask Value "
  hexmask.long.byte 0x0 0.--4. 1    "  SCMV  ,Serviced Channel Match Value "
TEXTLINE ""

group (0x600+0x5c)++3
line.long 0x0 "BWC2,Breakpoint/Watchpoint Control Register"
  bitfld.long 0x0 (30.)--(31.) "  BWE1 ,Breakpoint/Watchpoint" " dis, BP, res, WP"
  bitfld.long 0x0 (28.)--(29.) "  BRW1  ,Read/Write Select" " RD, WR, RW, res"
  bitfld.long 0x0 (20.)--(23.) "  BME1 ,Data Mask Enable" "0000,0001,0010,0011,0100,0101,0110,0111,1000,1001,1010,1011,1100,1101,1110,1111"
  bitfld.long 0x0 (15.)--(17.) "  BWO  ,Breakpoint/Watchpoint Operand" "dis,dis,res,DATAVALUE(WR),INSTRADDR,DATAADDR(R/W),res.,DATAADDR+VALUE(WR)"
TEXTLINE "                  "
  bitfld.long 0x0 14.          "  EOC  ,EVTO Control" " dis,ENA"
  hexmask.word 0x0 6.--10. 1   "  SCMSK ,Serviced Channel Mask Value "
  hexmask.word 0x0 0.--4. 1    "  SCMV ,Serviced Channel Match Value "
TEXTLINE ""

group (0x600+0x60)++3
line.long 0x0 "BWC3,Breakpoint/Watchpoint Control Register"
  hexmask.long.byte 0x0 24.--28. 1  "  SCMV  ,Serviced Channel Match Value "
  hexmask.long.byte 0x0 16.--20. 1  " SCMSK ,Serviced Channel Mask Value "
  bitfld.long 0x0 (12.)--(14.) "  BCRW  ,Break on Channel Register Write" "000,001,010,011,100,101,110,111"
  bitfld.long 0x0 (9.)--(11.)  "  BHSR  ,Break on Host Service Request " "000,001,010,011,100,101,110,111"
TEXTLINE "                  "
  bitfld.long 0x0 (6.)--(8.)   "  BLINK  ,Break on Link Service Request " "000,001,010,011,100,101,110,111"
  bitfld.long 0x0 (3.)--(5.)   " BMRL   ,Break on Match Recognition Request " "000,001,010,011,100,101,110,111"
  bitfld.long 0x0 (0.)--(2.)   "  BTDL  ,Break on Transition Detect Request " "000,001,010,011,100,101,110,111"
TEXTLINE ""
  
group (0x600+0x78)++3
line.long 0x0 "BWA1 , Breakpoint/Watchpoint Address 1 Register"
 hexmask.long.word 0x0 18.--31. 1   "  BWAM  ,Breakpoint/Watchpoint Address Mask "
 hexmask.long.word 0x0 2.--15. 1    " BWA   , Breakpoint/Watchpoint Address "

group (0x600+0x7c)++3
line.long 0x0 "BWA2 , Breakpoint/Watchpoint Address 2 Register"
 hexmask.long.word 0x0 18.--31. 1   "  BWAM  ,Breakpoint/Watchpoint Address Mask "
 hexmask.long.word 0x0 2.--15. 1    " BWA   ,Breakpoint/Watchpoint Address "
TEXTLINE ""

group (0x600+0x98)++3
line.long 0x0 "BWD1,Breakpoint/Watchpoint Data 1 Register"

group (0x600+0x9c)++3
line.long 0x0 "BWD2,Breakpoint/Watchpoint Data 2 Register"
TEXTLINE ""

group (0x600+0x100)++3
line.long 0x0 "PTCE,Program Trace Channel Enable" 
TEXTLINE ""

tree.end

tree.end

endif

tree.end


TEXTLINE ""
