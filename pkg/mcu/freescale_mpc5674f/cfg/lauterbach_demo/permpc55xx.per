  bitfld.long  0x00 28.--30.         "  CTAS ,Clock and transfer attributes select" "DSPI_CTAR0,DSPI_CTAR1,DSPI_CTAR2,DSPI_CTAR3,DSPI_CTAR4,DSPI_CTAR5,DSPI_CTAR6,DSPI_CTAR7"
  bitfld.long  0x00 27.              "  EOQ ,End-of-queue." "0,1"
  bitfld.long  0x00 26.              "  CTCNT ,Clear SPI_TCNT" "0,1"
  bitfld.long  0x00 23.              "  PCS7-0 ,Peripheral chip select 7" "0,1"
  bitfld.long  0x00 22.              ",Peripheral chip select 6" "0,1"
  bitfld.long  0x00 21.              ",Peripheral chip select 5" "0,1"
  bitfld.long  0x00 20.              ",Peripheral chip select 4" "0,1"
  bitfld.long  0x00 19.              " ,Peripheral chip select 3" "0,1"
  bitfld.long  0x00 18.              ",Peripheral chip select 2" "0,1"
  bitfld.long  0x00 17.              ",Peripheral chip select 1" "0,1"
  bitfld.long  0x00 16.              ",Peripheral chip select 0" "0,1"
  hexmask.long.word 0x00 00.--15. 1. "  TXDATA ,Transfer data"
TEXTLINE ""

wgroup.long (0xFFF98000+0x38)++0x03
  hide.long    0x00 "POPR,DSPI POP RX FIFO Register"
  IN
TEXTLINE ""

group.long (0xFFF98000+0x3C)++0x03
  line.long    0x00 "TXFR00,Transmit FIFO Register 0"
group.long (0xFFF98000+0x40)++0x03
  line.long    0x00 "TXFR01,Transmit FIFO Register 1"
group.long (0xFFF98000+0x44)++0x03
  line.long    0x00 "TXFR02,Transmit FIFO Register 2"
group.long (0xFFF98000+0x48)++0x03
  line.long    0x00 "TXFR03,Transmit FIFO Register 3"
group.long (0xFFF98000+0x4C)++0x03
  line.long    0x00 "TXFR04,Transmit FIFO Register 4"
group.long (0xFFF98000+0x50)++0x03
  line.long    0x00 "TXFR05,Transmit FIFO Register 5"
group.long (0xFFF98000+0x54)++0x03
  line.long    0x00 "TXFR06,Transmit FIFO Register 6"
group.long (0xFFF98000+0x58)++0x03
  line.long    0x00 "TXFR07,Transmit FIFO Register 7"
group.long (0xFFF98000+0x5C)++0x03
  line.long    0x00 "TXFR08,Transmit FIFO Register 8"
group.long (0xFFF98000+0x60)++0x03
  line.long    0x00 "TXFR09,Transmit FIFO Register 9"
group.long (0xFFF98000+0x64)++0x03
  line.long    0x00 "TXFR10,Transmit FIFO Register 10"
group.long (0xFFF98000+0x68)++0x03
  line.long    0x00 "TXFR11,Transmit FIFO Register 11"
group.long (0xFFF98000+0x6C)++0x03
  line.long    0x00 "TXFR12,Transmit FIFO Register 12"
group.long (0xFFF98000+0x70)++0x03
  line.long    0x00 "TXFR13,Transmit FIFO Register 13"
group.long (0xFFF98000+0x74)++0x03
  line.long    0x00 "TXFR14,Transmit FIFO Register 14"



TEXTLINE ""

group.long (0xFFF98000+0x7C)++0x03
  line.long    0x00 "RXFR0,DSPI Receive FIFO Register"
  hexmask.word 0x02 00.--15. 1.      "RXDATA ,Receive data"

group.long (0xFFF98000+0x80)++0x03
  line.long    0x00 "RXFR1,DSPI Receive FIFO Register"
  hexmask.word 0x02 00.--15. 1.      "RXDATA ,Receive data"

group.long (0xFFF98000+0x84)++0x03
  line.long    0x00 "RXFR2,DSPI Receive FIFO Register"
  hexmask.word 0x02 00.--15. 1.      "RXDATA ,Receive data"

group.long (0xFFF98000+0x88)++0x03
  line.long    0x00 "RXFR3,DSPI Receive FIFO Register"
  hexmask.word 0x02 00.--15. 1.      "RXDATA ,Receive data"

TEXTLINE ""

group.long (0xFFF98000+0xBC)++0x03
  line.long    0x00 "DSICR,DSPI DSI Configuration Register"
  bitfld.long  0x00 31.              "MTOE ,Multiple transfer operation enable" "0,1"
  hexmask.byte 0x00 00.--05. 1.      "   MTOCNT  ,Multiple transfer operation count"
  bitfld.long  0x00 19.              "  TXSS ,Transmit data source select" "0,1"
  bitfld.long  0x00 18.              "  TPOL  ,Trigger polarity" "0,1"
  bitfld.long  0x00 17.              "  TRRE  ,Trigger reception enable" "0,1"
  bitfld.long  0x00 16.              "  CID   ,Change in data transfer enable" "0,1"
  TEXTLINE "                "
  bitfld.long  0x00 15.              "  DCONT ,DSI continuous peripheral chip select enable" "0,1"
  bitfld.long  0x00 12.--14.         "  DSICTAS ,DSI Clock and Transfer Attributes select" "DSPI_CTAR0,DSPI_CTAR1,DSPI_CTAR2,DSPI_CTAR3,DSPI_CTAR4,DSPI_CTAR5,DSPI_CTAR6,DSPI_CTAR7"
  bitfld.long  0x00 23.              "  DPCS7-0 ,Peripheral chip select 7" "0,1"
  bitfld.long  0x00 22.              ",Peripheral chip select 6" "0,1"
  bitfld.long  0x00 21.              ",Peripheral chip select 5" "0,1"
  bitfld.long  0x00 20.              ",Peripheral chip select 4" "0,1"
  bitfld.long  0x00 19.              " ,Peripheral chip select 3" "0,1"
  bitfld.long  0x00 18.              ",Peripheral chip select 2" "0,1"
  bitfld.long  0x00 17.              ",Peripheral chip select 1" "0,1"
  bitfld.long  0x00 16.              ",Peripheral chip select 0" "0,1"
TEXTLINE ""

group.long (0xFFF98000+0xC0)++0x03
  line.long    0x00 "SDR,DSPI DSI Serialization Data Register"

group.long (0xFFF98000+0xC4)++0x03
  line.long    0x00 "ASDR,DSPI DSI Serialization Data Register"

group.long (0xFFF98000+0xC8)++0x03
  line.long    0x00 "COMPR,DSPI Transmit Comparison Register"

group.long (0xFFF98000+0xCC)++0x03
  line.long    0x00 "DDR,DSPI Deserialization Data Register"


sif (cpu()=="MPC5632M")||(cpu()=="MPC5633M")||(cpu()=="MPC5634M")||(cpu()=="SPC563M54")||(cpu()=="SPC563M60")||(cpu()=="SPC563M64")||(CPUIS("MPC5674*"))
 TEXTLINE ""

 group.long (0xFFF98000+0xD0)++0x03
   line.long    0x00 "DSICR1,DSPI DSI Configuration Register 1"
   bitfld.long  0x00 24.--28.         "TSBCNT ,Timed Serial Bus Operation Count" "res(0),res(1),res(2),res(3),res(4),5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
  bitfld.long  0x00 23.              "  DPCS7-0 ,Peripheral chip select 7" "0,1"
  bitfld.long  0x00 22.              ",Peripheral chip select 6" "0,1"
  bitfld.long  0x00 21.              ",Peripheral chip select 5" "0,1"
  bitfld.long  0x00 20.              ",Peripheral chip select 4" "0,1"
  bitfld.long  0x00 19.              " ,Peripheral chip select 3" "0,1"
  bitfld.long  0x00 18.              ",Peripheral chip select 2" "0,1"
  bitfld.long  0x00 17.              ",Peripheral chip select 1" "0,1"
  bitfld.long  0x00 16.              ",Peripheral chip select 0" "0,1"

endif
 
   
tree.end

  sif (cpu()=="MPC5533")||(cpu()=="MPC5534")||(cpu()=="MPC5553")||(cpu()=="MPC5554")||(cpu()=="MPC5565")||(cpu()=="MPC5566")||(cpu()=="MPC5567")||(CPUIS("MPC5674*"))
tree "DSPI D"

group.long 0xFFF9C000++0x03
  line.long    0x00 "MCR,Module Configuration Register"
  bitfld.long  0x00 31.                "MSTR      ,Master/slave mode select" "S,M"
  bitfld.long  0x00 30.              "  CONT_SCKE ,Continuous SCK enable" "0,1"
  bitfld.long  0x00 28.--29.         "  DCONF   ,DSPI configuration" "SPI,DSI,CSI,res"
  bitfld.long  0x00 27.              "  FRZ       ,Freeze" "0,1"
  TEXTLINE "                "
  bitfld.long  0x00 26.              "  MTFE      ,Modified timing format enable" "0,1"
  bitfld.long  0x00 25.              "  PCSSE     ,Peripheral chip select strobe enable" "0,1"
  bitfld.long  0x00 24.              "  ROOE      ,Receive FIFO overflow overwrite enable" "0,1"
  bitfld.long  0x00 23.              "  PCSIS7-0  ,Peripheral chip select 7 inactive state" "L,H"
  bitfld.long  0x00 22.              ",Peripheral chip select 6 inactive state" "L,H"
  bitfld.long  0x00 21.              ",Peripheral chip select 5 inactive state" "L,H"
  bitfld.long  0x00 20.              ",Peripheral chip select 4 inactive state" "L,H"
  bitfld.long  0x00 19.              " ,Peripheral chip select 3 inactive state" "L,H"
  bitfld.long  0x00 18.              ",Peripheral chip select 2 inactive state" "L,H"
  bitfld.long  0x00 17.              ",Peripheral chip select 1 inactive state" "L,H"
  bitfld.long  0x00 16.              ",Peripheral chip select 0 inactive state" "L,H"
  TEXTLINE "                "
  bitfld.long  0x00 15.              "  DOZE      ,Doze enable" "0,1"
  bitfld.long  0x00 14.              "  MDIS      ,Module disable" "0,1"
  TEXTLINE "                "
  bitfld.long  0x00 13.              "  DIS_TXF   ,Disable transmit FIFO" "0,1"
  bitfld.long  0x00 12.              "  DIS_RXF   ,Disable receive FIFO" "0,1"
  bitfld.long  0x00 11.              "  CLR_TXF   ,Clear TX FIFO" "0,1"
  bitfld.long  0x00 10.              "  CLR_RXF   ,Clear RX FIFO." "0,1"
  TEXTLINE "                "
  bitfld.long  0x00 08.--09.         "  SMPL_PT ,Sample point" "  0,  1,  2,res"
  bitfld.long  0x00 00.              "  HALT      ,Halt" "0,1"
TEXTLINE ""

group.long (0xFFF9C000+0x08)++0x03
  line.long    0x00 "TCR,Transfer Count Register"
  hexmask.word 0x00 00.--15. 1. "TCNT , SPI transfer counter"
TEXTLINE ""

group.long (0xFFF9C000+0x0C)++0x03
  line.long    0x00 "CTAR0,Clock and Transfer Attributes Register"
  bitfld.long  0x00 31.                "DBR        ,Double baud rate" "0,1"
  bitfld.long  0x00 27.--30.         "  FMSZ     ,Framesize" "res,res,res,  4 bits,  5 bits,  6 bits,  7 bits,  8 bits,  9 bits, 10 bits, 11 bits, 12 bits, 13 bits, 14 bits, 15 bits, 16 bits"
  TEXTLINE "                "
  bitfld.long  0x00 26.              "  CPOL    ,Clock polarity" " low,high"
  bitfld.long  0x00 25.              "  CPHA       ,Clock phase" "0,1"
  bitfld.long  0x00 24.              "  LSBFE      ,LSB first enable" "0,1"
  TEXTLINE "                "
  bitfld.long  0x00 22.--23.         "  PCSSCK    ,PCS to SCK delay prescaler" "1x,3x,5x,7x"
  bitfld.long  0x00 20.--21.         "  PASC      ,After SCK delay prescaler" "1x,3x,5x,7x"
  bitfld.long  0x00 18.--19.         "  PDT       ,Delay after transfer prescaler" "1x,3x,5x,7x"
  bitfld.long  0x00 16.--17.         "  PBR       ,Baud rate prescaler" "2x,3x,5x,7x"
  TEXTLINE "                "
  bitfld.long  0x00 12.--15.         "  CSSCK ,PCS to SCK delay scaler"     "    2x,    4x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x,65536x"
  bitfld.long  0x00 08.--11.         "  ASC   ,After SCK delay scaler"      "    2x,    4x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x,65536x"
  bitfld.long  0x00 04.--07.         "  DT    ,Delay after transfer scaler" "    2x,    4x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x,65536x"
  bitfld.long  0x00 00.--03.         "  BR    ,Baud rate scaler"            "    2x,    4x,    6x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x"
TEXTLINE ""

group.long (0xFFF9C000+0x10)++0x03
  line.long    0x00 "CTAR1,Clock and Transfer Attributes Register"
  bitfld.long  0x00 31.                "DBR        ,Double baud rate" "0,1"
  bitfld.long  0x00 27.--30.         "  FMSZ     ,Framesize" "res,res,res,  4 bits,  5 bits,  6 bits,  7 bits,  8 bits,  9 bits, 10 bits, 11 bits, 12 bits, 13 bits, 14 bits, 15 bits, 16 bits"
  TEXTLINE "                "
  bitfld.long  0x00 26.              "  CPOL    ,Clock polarity" " low,high"
  bitfld.long  0x00 25.              "  CPHA       ,Clock phase" "0,1"
  bitfld.long  0x00 24.              "  LSBFE      ,LSB first enable" "0,1"
  TEXTLINE "                "
  bitfld.long  0x00 22.--23.         "  PCSSCK    ,PCS to SCK delay prescaler" "1x,3x,5x,7x"
  bitfld.long  0x00 20.--21.         "  PASC      ,After SCK delay prescaler" "1x,3x,5x,7x"
  bitfld.long  0x00 18.--19.         "  PDT       ,Delay after transfer prescaler" "1x,3x,5x,7x"
  bitfld.long  0x00 16.--17.         "  PBR       ,Baud rate prescaler" "2x,3x,5x,7x"
  TEXTLINE "                "
  bitfld.long  0x00 12.--15.         "  CSSCK ,PCS to SCK delay scaler"     "    2x,    4x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x,65536x"
  bitfld.long  0x00 08.--11.         "  ASC   ,After SCK delay scaler"      "    2x,    4x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x,65536x"
  bitfld.long  0x00 04.--07.         "  DT    ,Delay after transfer scaler" "    2x,    4x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x,65536x"
  bitfld.long  0x00 00.--03.         "  BR    ,Baud rate scaler"            "    2x,    4x,    6x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x"
TEXTLINE ""

group.long (0xFFF9C000+0x14)++0x03
  line.long    0x00 "CTAR2,Clock and Transfer Attributes Register"
  bitfld.long  0x00 31.                "DBR        ,Double baud rate" "0,1"
  bitfld.long  0x00 27.--30.         "  FMSZ     ,Framesize" "res,res,res,  4 bits,  5 bits,  6 bits,  7 bits,  8 bits,  9 bits, 10 bits, 11 bits, 12 bits, 13 bits, 14 bits, 15 bits, 16 bits"
  TEXTLINE "                "
  bitfld.long  0x00 26.              "  CPOL    ,Clock polarity" " low,high"
  bitfld.long  0x00 25.              "  CPHA       ,Clock phase" "0,1"
  bitfld.long  0x00 24.              "  LSBFE      ,LSB first enable" "0,1"
  TEXTLINE "                "
  bitfld.long  0x00 22.--23.         "  PCSSCK    ,PCS to SCK delay prescaler" "1x,3x,5x,7x"
  bitfld.long  0x00 20.--21.         "  PASC      ,After SCK delay prescaler" "1x,3x,5x,7x"
  bitfld.long  0x00 18.--19.         "  PDT       ,Delay after transfer prescaler" "1x,3x,5x,7x"
  bitfld.long  0x00 16.--17.         "  PBR       ,Baud rate prescaler" "2x,3x,5x,7x"
  TEXTLINE "                "
  bitfld.long  0x00 12.--15.         "  CSSCK ,PCS to SCK delay scaler"     "    2x,    4x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x,65536x"
  bitfld.long  0x00 08.--11.         "  ASC   ,After SCK delay scaler"      "    2x,    4x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x,65536x"
  bitfld.long  0x00 04.--07.         "  DT    ,Delay after transfer scaler" "    2x,    4x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x,65536x"
  bitfld.long  0x00 00.--03.         "  BR    ,Baud rate scaler"            "    2x,    4x,    6x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x"
TEXTLINE ""

group.long (0xFFF9C000+0x18)++0x03
  line.long    0x00 "CTAR3,Clock and Transfer Attributes Register"
  bitfld.long  0x00 31.                "DBR        ,Double baud rate" "0,1"
  bitfld.long  0x00 27.--30.         "  FMSZ     ,Framesize" "res,res,res,  4 bits,  5 bits,  6 bits,  7 bits,  8 bits,  9 bits, 10 bits, 11 bits, 12 bits, 13 bits, 14 bits, 15 bits, 16 bits"
  TEXTLINE "                "
  bitfld.long  0x00 26.              "  CPOL    ,Clock polarity" " low,high"
  bitfld.long  0x00 25.              "  CPHA       ,Clock phase" "0,1"
  bitfld.long  0x00 24.              "  LSBFE      ,LSB first enable" "0,1"
  TEXTLINE "                "
  bitfld.long  0x00 22.--23.         "  PCSSCK    ,PCS to SCK delay prescaler" "1x,3x,5x,7x"
  bitfld.long  0x00 20.--21.         "  PASC      ,After SCK delay prescaler" "1x,3x,5x,7x"
  bitfld.long  0x00 18.--19.         "  PDT       ,Delay after transfer prescaler" "1x,3x,5x,7x"
  bitfld.long  0x00 16.--17.         "  PBR       ,Baud rate prescaler" "2x,3x,5x,7x"
  TEXTLINE "                "
  bitfld.long  0x00 12.--15.         "  CSSCK ,PCS to SCK delay scaler"     "    2x,    4x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x,65536x"
  bitfld.long  0x00 08.--11.         "  ASC   ,After SCK delay scaler"      "    2x,    4x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x,65536x"
  bitfld.long  0x00 04.--07.         "  DT    ,Delay after transfer scaler" "    2x,    4x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x,65536x"
  bitfld.long  0x00 00.--03.         "  BR    ,Baud rate scaler"            "    2x,    4x,    6x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x"
TEXTLINE ""

group.long (0xFFF9C000+0x1C)++0x03
  line.long    0x00 "CTAR4,Clock and Transfer Attributes Register"
  bitfld.long  0x00 31.                "DBR        ,Double baud rate" "0,1"
  bitfld.long  0x00 27.--30.         "  FMSZ     ,Framesize" "res,res,res,  4 bits,  5 bits,  6 bits,  7 bits,  8 bits,  9 bits, 10 bits, 11 bits, 12 bits, 13 bits, 14 bits, 15 bits, 16 bits"
  TEXTLINE "                "
  bitfld.long  0x00 26.              "  CPOL    ,Clock polarity" " low,high"
  bitfld.long  0x00 25.              "  CPHA       ,Clock phase" "0,1"
  bitfld.long  0x00 24.              "  LSBFE      ,LSB first enable" "0,1"
  TEXTLINE "                "
  bitfld.long  0x00 22.--23.         "  PCSSCK    ,PCS to SCK delay prescaler" "1x,3x,5x,7x"
  bitfld.long  0x00 20.--21.         "  PASC      ,After SCK delay prescaler" "1x,3x,5x,7x"
  bitfld.long  0x00 18.--19.         "  PDT       ,Delay after transfer prescaler" "1x,3x,5x,7x"
  bitfld.long  0x00 16.--17.         "  PBR       ,Baud rate prescaler" "2x,3x,5x,7x"
  TEXTLINE "                "
  bitfld.long  0x00 12.--15.         "  CSSCK ,PCS to SCK delay scaler"     "    2x,    4x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x,65536x"
  bitfld.long  0x00 08.--11.         "  ASC   ,After SCK delay scaler"      "    2x,    4x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x,65536x"
  bitfld.long  0x00 04.--07.         "  DT    ,Delay after transfer scaler" "    2x,    4x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x,65536x"
  bitfld.long  0x00 00.--03.         "  BR    ,Baud rate scaler"            "    2x,    4x,    6x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x"
TEXTLINE ""

group.long (0xFFF9C000+0x20)++0x03
  line.long    0x00 "CTAR5,Clock and Transfer Attributes Register"
  bitfld.long  0x00 31.                "DBR        ,Double baud rate" "0,1"
  bitfld.long  0x00 27.--30.         "  FMSZ     ,Framesize" "res,res,res,  4 bits,  5 bits,  6 bits,  7 bits,  8 bits,  9 bits, 10 bits, 11 bits, 12 bits, 13 bits, 14 bits, 15 bits, 16 bits"
  TEXTLINE "                "
  bitfld.long  0x00 26.              "  CPOL    ,Clock polarity" " low,high"
  bitfld.long  0x00 25.              "  CPHA       ,Clock phase" "0,1"
  bitfld.long  0x00 24.              "  LSBFE      ,LSB first enable" "0,1"
  TEXTLINE "                "
  bitfld.long  0x00 22.--23.         "  PCSSCK    ,PCS to SCK delay prescaler" "1x,3x,5x,7x"
  bitfld.long  0x00 20.--21.         "  PASC      ,After SCK delay prescaler" "1x,3x,5x,7x"
  bitfld.long  0x00 18.--19.         "  PDT       ,Delay after transfer prescaler" "1x,3x,5x,7x"
  bitfld.long  0x00 16.--17.         "  PBR       ,Baud rate prescaler" "2x,3x,5x,7x"
  TEXTLINE "                "
  bitfld.long  0x00 12.--15.         "  CSSCK ,PCS to SCK delay scaler"     "    2x,    4x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x,65536x"
  bitfld.long  0x00 08.--11.         "  ASC   ,After SCK delay scaler"      "    2x,    4x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x,65536x"
  bitfld.long  0x00 04.--07.         "  DT    ,Delay after transfer scaler" "    2x,    4x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x,65536x"
  bitfld.long  0x00 00.--03.         "  BR    ,Baud rate scaler"            "    2x,    4x,    6x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x"
TEXTLINE ""

group.long (0xFFF9C000+0x24)++0x03
  line.long    0x00 "CTAR6,Clock and Transfer Attributes Register"
  bitfld.long  0x00 31.                "DBR        ,Double baud rate" "0,1"
  bitfld.long  0x00 27.--30.         "  FMSZ     ,Framesize" "res,res,res,  4 bits,  5 bits,  6 bits,  7 bits,  8 bits,  9 bits, 10 bits, 11 bits, 12 bits, 13 bits, 14 bits, 15 bits, 16 bits"
  TEXTLINE "                "
  bitfld.long  0x00 26.              "  CPOL    ,Clock polarity" " low,high"
  bitfld.long  0x00 25.              "  CPHA       ,Clock phase" "0,1"
  bitfld.long  0x00 24.              "  LSBFE      ,LSB first enable" "0,1"
  TEXTLINE "                "
  bitfld.long  0x00 22.--23.         "  PCSSCK    ,PCS to SCK delay prescaler" "1x,3x,5x,7x"
  bitfld.long  0x00 20.--21.         "  PASC      ,After SCK delay prescaler" "1x,3x,5x,7x"
  bitfld.long  0x00 18.--19.         "  PDT       ,Delay after transfer prescaler" "1x,3x,5x,7x"
  bitfld.long  0x00 16.--17.         "  PBR       ,Baud rate prescaler" "2x,3x,5x,7x"
  TEXTLINE "                "
  bitfld.long  0x00 12.--15.         "  CSSCK ,PCS to SCK delay scaler"     "    2x,    4x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x,65536x"
  bitfld.long  0x00 08.--11.         "  ASC   ,After SCK delay scaler"      "    2x,    4x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x,65536x"
  bitfld.long  0x00 04.--07.         "  DT    ,Delay after transfer scaler" "    2x,    4x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x,65536x"
  bitfld.long  0x00 00.--03.         "  BR    ,Baud rate scaler"            "    2x,    4x,    6x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x"
TEXTLINE ""

group.long (0xFFF9C000+0x28)++0x03
  line.long    0x00 "CTAR7,Clock and Transfer Attributes Register"
  bitfld.long  0x00 31.                "DBR        ,Double baud rate" "0,1"
  bitfld.long  0x00 27.--30.         "  FMSZ     ,Framesize" "res,res,res,  4 bits,  5 bits,  6 bits,  7 bits,  8 bits,  9 bits, 10 bits, 11 bits, 12 bits, 13 bits, 14 bits, 15 bits, 16 bits"
  TEXTLINE "                "
  bitfld.long  0x00 26.              "  CPOL    ,Clock polarity" " low,high"
  bitfld.long  0x00 25.              "  CPHA       ,Clock phase" "0,1"
  bitfld.long  0x00 24.              "  LSBFE      ,LSB first enable" "0,1"
  TEXTLINE "                "
  bitfld.long  0x00 22.--23.         "  PCSSCK    ,PCS to SCK delay prescaler" "1x,3x,5x,7x"
  bitfld.long  0x00 20.--21.         "  PASC      ,After SCK delay prescaler" "1x,3x,5x,7x"
  bitfld.long  0x00 18.--19.         "  PDT       ,Delay after transfer prescaler" "1x,3x,5x,7x"
  bitfld.long  0x00 16.--17.         "  PBR       ,Baud rate prescaler" "2x,3x,5x,7x"
  TEXTLINE "                "
  bitfld.long  0x00 12.--15.         "  CSSCK ,PCS to SCK delay scaler"     "    2x,    4x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x,65536x"
  bitfld.long  0x00 08.--11.         "  ASC   ,After SCK delay scaler"      "    2x,    4x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x,65536x"
  bitfld.long  0x00 04.--07.         "  DT    ,Delay after transfer scaler" "    2x,    4x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x,65536x"
  bitfld.long  0x00 00.--03.         "  BR    ,Baud rate scaler"            "    2x,    4x,    6x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x"
TEXTLINE ""


group.long (0xFFF9C000+0x2C)++0x03
  line.long    0x00 "SR,DSPI Status Register"
  eventfld.long  0x00 31.                "TCF       ,Transfer complete flag" "0,1"
  eventfld.long  0x00 30.              "  TXRXS     ,TX & RX status" "0,1"
  eventfld.long  0x00 28.              "  EOQF      ,End-of-queue flag" "0,1"
  TEXTLINE "                "
  eventfld.long  0x00 27.              "  TFUF      ,Transmit FIFO underflow flag" "0,1"
  eventfld.long  0x00 25.              "  TFFF      ,Transmit FIFO fill flag" "0,1"
  eventfld.long  0x00 19.              "  RFOF      ,Receive FIFO overflow flag" "0,1"
  eventfld.long  0x00 17.              "  RFDF      ,Receive FIFO drain flag" "0,1"
  TEXTLINE "                "
  bitfld.long  0x00 12.--15.           "  TXCTR    ,TX FIFO Counter" " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.           "  TXNXTPTR ,Transmit next pointer." " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long  0x00 04.--07.           "  RXCTR    ,RX FIFO Counter" " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.           "  POPNXTPTR ,Pop next pointer" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
TEXTLINE ""

group.long (0xFFF9C000+0x30)++0x03
  line.long    0x00 "RSER,DSPI DMA/Interrupt Request Select and Enable Register"
  bitfld.long  0x00 31.                "TCF_RE    ,Transfer complete request enable" "0,1"
  bitfld.long  0x00 28.              "  EOQF_RE   ,End-of-queue request enable" "0,1"
  bitfld.long  0x00 27.              "  TFUF_RE   ,Transmit FIFO underflow request enable" "0,1"
  bitfld.long  0x00 25.              "  TFFF_RE   ,Transmit FIFO fill request enable" "0,1"
  bitfld.long  0x00 24.              "  TFFF_DIRS ,Transmit FIFO fill request select" "INT,DMA"
  TEXTLINE "                "
  bitfld.long  0x00 19.              "  RFOF_RE   ,Receive FIFO overflow request enable" "0,1"
  bitfld.long  0x00 17.              "  RFDF_RE   ,Receive FIFO drain request enable" "0,1"
  bitfld.long  0x00 16.              "  RFDF_DIRS ,Receive FIFO drain request select" "INT,DMA"
TEXTLINE ""

group.long (0xFFF9C000+0x34)++0x03
  line.long    0x00 "PUSHR,DSPI PUSH TX FIFO Register"
  bitfld.long  0x00 31.              "CONT ,Continuous peripheral chip select enable" "0,1"
  bitfld.long  0x00 28.--30.         "  CTAS ,Clock and transfer attributes select" "DSPI_CTAR0,DSPI_CTAR1,DSPI_CTAR2,DSPI_CTAR3,DSPI_CTAR4,DSPI_CTAR5,DSPI_CTAR6,DSPI_CTAR7"
  bitfld.long  0x00 27.              "  EOQ ,End-of-queue." "0,1"
  bitfld.long  0x00 26.              "  CTCNT ,Clear SPI_TCNT" "0,1"
  bitfld.long  0x00 23.              "  PCS7-0 ,Peripheral chip select 7" "0,1"
  bitfld.long  0x00 22.              ",Peripheral chip select 6" "0,1"
  bitfld.long  0x00 21.              ",Peripheral chip select 5" "0,1"
  bitfld.long  0x00 20.              ",Peripheral chip select 4" "0,1"
  bitfld.long  0x00 19.              " ,Peripheral chip select 3" "0,1"
  bitfld.long  0x00 18.              ",Peripheral chip select 2" "0,1"
  bitfld.long  0x00 17.              ",Peripheral chip select 1" "0,1"
  bitfld.long  0x00 16.              ",Peripheral chip select 0" "0,1"
  hexmask.long.word 0x00 00.--15. 1. "  TXDATA ,Transfer data"
TEXTLINE ""

wgroup.long (0xFFF9C000+0x38)++0x03
  hide.long    0x00 "POPR,DSPI POP RX FIFO Register"
  IN
TEXTLINE ""

group.long (0xFFF9C000+0x3C)++0x03
  line.long    0x00 "TXFR00,Transmit FIFO Register 0"
group.long (0xFFF9C000+0x40)++0x03
  line.long    0x00 "TXFR01,Transmit FIFO Register 1"
group.long (0xFFF9C000+0x44)++0x03
  line.long    0x00 "TXFR02,Transmit FIFO Register 2"
group.long (0xFFF9C000+0x48)++0x03
  line.long    0x00 "TXFR03,Transmit FIFO Register 3"
group.long (0xFFF9C000+0x4C)++0x03
  line.long    0x00 "TXFR04,Transmit FIFO Register 4"
group.long (0xFFF9C000+0x50)++0x03
  line.long    0x00 "TXFR05,Transmit FIFO Register 5"
group.long (0xFFF9C000+0x54)++0x03
  line.long    0x00 "TXFR06,Transmit FIFO Register 6"
group.long (0xFFF9C000+0x58)++0x03
  line.long    0x00 "TXFR07,Transmit FIFO Register 7"
group.long (0xFFF9C000+0x5C)++0x03
  line.long    0x00 "TXFR08,Transmit FIFO Register 8"
group.long (0xFFF9C000+0x60)++0x03
  line.long    0x00 "TXFR09,Transmit FIFO Register 9"
group.long (0xFFF9C000+0x64)++0x03
  line.long    0x00 "TXFR10,Transmit FIFO Register 10"
group.long (0xFFF9C000+0x68)++0x03
  line.long    0x00 "TXFR11,Transmit FIFO Register 11"
group.long (0xFFF9C000+0x6C)++0x03
  line.long    0x00 "TXFR12,Transmit FIFO Register 12"
group.long (0xFFF9C000+0x70)++0x03
  line.long    0x00 "TXFR13,Transmit FIFO Register 13"
group.long (0xFFF9C000+0x74)++0x03
  line.long    0x00 "TXFR14,Transmit FIFO Register 14"



TEXTLINE ""

group.long (0xFFF9C000+0x7C)++0x03
  line.long    0x00 "RXFR0,DSPI Receive FIFO Register"
  hexmask.word 0x02 00.--15. 1.      "RXDATA ,Receive data"

group.long (0xFFF9C000+0x80)++0x03
  line.long    0x00 "RXFR1,DSPI Receive FIFO Register"
  hexmask.word 0x02 00.--15. 1.      "RXDATA ,Receive data"

group.long (0xFFF9C000+0x84)++0x03
  line.long    0x00 "RXFR2,DSPI Receive FIFO Register"
  hexmask.word 0x02 00.--15. 1.      "RXDATA ,Receive data"

group.long (0xFFF9C000+0x88)++0x03
  line.long    0x00 "RXFR3,DSPI Receive FIFO Register"
  hexmask.word 0x02 00.--15. 1.      "RXDATA ,Receive data"

TEXTLINE ""

group.long (0xFFF9C000+0xBC)++0x03
  line.long    0x00 "DSICR,DSPI DSI Configuration Register"
  bitfld.long  0x00 31.              "MTOE ,Multiple transfer operation enable" "0,1"
  hexmask.byte 0x00 00.--05. 1.      "   MTOCNT  ,Multiple transfer operation count"
  bitfld.long  0x00 19.              "  TXSS ,Transmit data source select" "0,1"
  bitfld.long  0x00 18.              "  TPOL  ,Trigger polarity" "0,1"
  bitfld.long  0x00 17.              "  TRRE  ,Trigger reception enable" "0,1"
  bitfld.long  0x00 16.              "  CID   ,Change in data transfer enable" "0,1"
  TEXTLINE "                "
  bitfld.long  0x00 15.              "  DCONT ,DSI continuous peripheral chip select enable" "0,1"
  bitfld.long  0x00 12.--14.         "  DSICTAS ,DSI Clock and Transfer Attributes select" "DSPI_CTAR0,DSPI_CTAR1,DSPI_CTAR2,DSPI_CTAR3,DSPI_CTAR4,DSPI_CTAR5,DSPI_CTAR6,DSPI_CTAR7"
  bitfld.long  0x00 23.              "  DPCS7-0 ,Peripheral chip select 7" "0,1"
  bitfld.long  0x00 22.              ",Peripheral chip select 6" "0,1"
  bitfld.long  0x00 21.              ",Peripheral chip select 5" "0,1"
  bitfld.long  0x00 20.              ",Peripheral chip select 4" "0,1"
  bitfld.long  0x00 19.              " ,Peripheral chip select 3" "0,1"
  bitfld.long  0x00 18.              ",Peripheral chip select 2" "0,1"
  bitfld.long  0x00 17.              ",Peripheral chip select 1" "0,1"
  bitfld.long  0x00 16.              ",Peripheral chip select 0" "0,1"
TEXTLINE ""

group.long (0xFFF9C000+0xC0)++0x03
  line.long    0x00 "SDR,DSPI DSI Serialization Data Register"

group.long (0xFFF9C000+0xC4)++0x03
  line.long    0x00 "ASDR,DSPI DSI Serialization Data Register"

group.long (0xFFF9C000+0xC8)++0x03
  line.long    0x00 "COMPR,DSPI Transmit Comparison Register"

group.long (0xFFF9C000+0xCC)++0x03
  line.long    0x00 "DDR,DSPI Deserialization Data Register"


sif (cpu()=="MPC5632M")||(cpu()=="MPC5633M")||(cpu()=="MPC5634M")||(cpu()=="SPC563M54")||(cpu()=="SPC563M60")||(cpu()=="SPC563M64")||(CPUIS("MPC5674*"))
 TEXTLINE ""

 group.long (0xFFF9C000+0xD0)++0x03
   line.long    0x00 "DSICR1,DSPI DSI Configuration Register 1"
   bitfld.long  0x00 24.--28.         "TSBCNT ,Timed Serial Bus Operation Count" "res(0),res(1),res(2),res(3),res(4),5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
  bitfld.long  0x00 23.              "  DPCS7-0 ,Peripheral chip select 7" "0,1"
  bitfld.long  0x00 22.              ",Peripheral chip select 6" "0,1"
  bitfld.long  0x00 21.              ",Peripheral chip select 5" "0,1"
  bitfld.long  0x00 20.              ",Peripheral chip select 4" "0,1"
  bitfld.long  0x00 19.              " ,Peripheral chip select 3" "0,1"
  bitfld.long  0x00 18.              ",Peripheral chip select 2" "0,1"
  bitfld.long  0x00 17.              ",Peripheral chip select 1" "0,1"
  bitfld.long  0x00 16.              ",Peripheral chip select 0" "0,1"

endif
 
   
tree.end

  endif
tree.end


tree "Enhanced Serial Communication Interface (eSCI)"

sif (CPUIS("MPC5674*"))||(cpu()=="MPC5633M")||(cpu()=="MPC5634M")||(cpu()=="SPC563M60")||(cpu()=="SPC563M64")
tree "ESCI A"

group.word 0xFFFB0000++0x01
  line.word    0x00 "BRR,Baud Rate Register"

group.word (0xFFFB0000+0x2)++0x01
  line.word    0x00 "CR1,Configuration Register 1"
  bitfld.word  0x00 15.             "LOOPS    ,Loop select" "0,1" 
  bitfld.word  0x00 13.           "  RSRC     ,Receiver source" "0,1" 
  bitfld.word  0x00 12.           "  M    ,Data format mode" "1-8-1,1-9-1" 
  bitfld.word  0x00 11.           "  WAKE   ,Wakeup condition" "ILW,AMW" 
  TEXTLINE "            "
  bitfld.word  0x00 10.           "  ILT   ,Idle line type" "STRT,STOP" 
  bitfld.word  0x00 09.           "  PE       ,Parity enable" "0,1" 
  bitfld.word  0x00 08.           "  PT    ,Parity type" "EVEN,ODD" 
  bitfld.word  0x00 07.           "  TIE      ,Transmitter interrupt enable" "0,1" 
  TEXTLINE "            "
  bitfld.word  0x00 06.           "  TCIE     ,Transmission complete interrupt enable" "0,1" 
  bitfld.word  0x00 05.           "  RIE      ,Receiver full interrupt enable" "0,1" 
  bitfld.word  0x00 04.           "  ILIE     ,Idle line interrupt enable" "0,1" 
  bitfld.word  0x00 03.           "  TE       ,Transmitter enable" "0,1" 
  TEXTLINE "            "
  bitfld.word  0x00 02.           "  RE       ,Receiver enable" "0,1" 
  bitfld.word  0x00 01.           "  RWU      ,Receiver wakeup" "0,1" 
  bitfld.word  0x00 00.           "  SBK      ,Send break" "0,1" 
TEXTLINE ""

group.word (0xFFFB0000+0x04)++0x01
  line.word    0x00 "CR2,Module Configuration Register 2"
  bitfld.word  0x00 15.             "MDIS     ,Module disable" "0,1" 
  bitfld.word  0x00 14.           "  FBR      ,Fast bit error detection" "0,1"
  bitfld.word  0x00 13.           "  BSTP     ,Bit error/physical bus error stop" "0,1" 
  bitfld.word  0x00 12.           "  IEBERR   ,Enable bit error interrupt" "0,1" 
  TEXTLINE "            "
  bitfld.word  0x00 11.           "  RXDMA    ,Activate RX DMA channel" "0,1" 
  bitfld.word  0x00 10.           "  TXDMA    ,Activate TX DMA channel" "0,1" 
  bitfld.word  0x00 09.           "  BRCL ,Break Character Length" "10/11,13/14" 
  bitfld.word  0x00 08.           "  TXDIR ,TXD pin output driver control" " dis,ena"
  TEXTLINE "            "
  bitfld.word  0x00 07.           "  BESM  ,Bit error sample mode - bit 13" " RC9,RC13"
  bitfld.word  0x00 06.           "  BESTP    ,Transmit Stop on Bit Error" "0,1"
  bitfld.word  0x00 05.           "  RXPOL  ,RXD Pin polarity" "nrm,inv"
  bitfld.word  0x00 04.           "  PMSK     ,Parity Bit Masking" "0,1"
  TEXTLINE "            "
  bitfld.word  0x00 03.           "  ORIE     ,Overrun error interrupt enable" "0,1"
  bitfld.word  0x00 02.           "  NFIE     ,Noise flag interrupt enable" "0,1"
  bitfld.word  0x00 01.           "  FEIE     ,Frame error interrupt enable" "0,1"
  bitfld.word  0x00 00.           "  PFIE     ,Parity flag interrupt enable" "0,1"
TEXTLINE ""

group.word (0xFFFB0000+0x06)++0x01
  line.word    0x00 "SDR,SCI Data Register"
  bitfld.word  0x00 15.             "RN       ,Received Most Significant Bit" "0,1" 
  bitfld.word  0x00 14.           "  TN       ,Transmit Most Significant Bit" "0,1" 
  bitfld.word  0x00 13.           "  ERR      ,Receive Error Bit" "0,1" 
  hexmask.word 0x00 00.--11. 1.   "  D     ,RX/TX Data"
TEXTLINE ""
  
group.word (0xFFFB0000+0x08)++0x01
  line.word    0x00 "IFSR1,Interrupt Flag and Status Register 1"
  eventfld.word  0x00 15.           "TDRE     ,Transmit data register empty flag" "0,1" 
  eventfld.word  0x00 14.         "  TC       ,Transmit complete flag" "0,1" 
  eventfld.word  0x00 13.         "  RDRF     ,Receive data register full flag" "0,1" 
  eventfld.word  0x00 12.         "  IDLE     ,Idle line flag" "0,1" 
  TEXTLINE "            "
  eventfld.word  0x00 11.         "  OR       ,Overrun flag" "0,1" 
  eventfld.word  0x00 10.         "  NF       ,Noise flag" "0,1" 
  eventfld.word  0x00 09.         "  FE       ,Framing error flag" "0,1" 
  eventfld.word  0x00 08.         "  PF       ,Parity error flag" "0,1" 
  TEXTLINE "            "
  eventfld.word  0x00 04.         "  BERR     ,Bit error" "0,1" 
  bitfld.word  0x00 01.           "  TACT     ,Transmitter active flag" "0,1" 
  bitfld.word  0x00 00.           "  RACT     ,Receiver active flag" "0,1" 
TEXTLINE ""
  
group.word (0xFFFB0000+0x0a)++0x01
  line.word    0x00 "IFSR2,Interrupt Flag and Status Register 2"
  eventfld.word  0x00 15.           "RXRDY    ,Receive data ready" "0,1" 
  eventfld.word  0x00 14.         "  TXRDY    ,Transmit data ready" "0,1" 
  eventfld.word  0x00 13.         "  LWAKE    ,Received LIN wakeup signal" "0,1" 
  eventfld.word  0x00 12.         "  STO      ,Slave time out" "0,1" 
  TEXTLINE "            "
  eventfld.word  0x00 11.         "  PBERR    ,Physical bus error" "0,1" 
  eventfld.word  0x00 10.         "  CERR     ,CRC error" "0,1" 
  eventfld.word  0x00 09.         "  CKERR    ,Checksum error" "0,1" 
  eventfld.word  0x00 08.         "  FRC      ,Frame complete" "0,1" 
  TEXTLINE "            "
  eventfld.word  0x00 01.         "  UREQ     ,Unrequested Data Received Interrupt Flag" "0,1" 
  eventfld.word  0x00 00.         "  OVFL     ,LRR overflow" "0,1" 
TEXTLINE ""

group.word (0xFFFB0000+0x0C)++0x01
  line.word    0x00 "LCR1,LIN Control Register 1"
  bitfld.word  0x00 15.             "LRES     ,LIN resynchronize" "0,1" 
  bitfld.word  0x00 14.           "  WU       ,LIN bus wakeup." "0,1" 
  bitfld.word  0x00 12.--13.      "  WUD     ,Wakeup delimiter time" " 4, 8,32,64" 
  bitfld.word  0x00 11.           "  LDBG     ,LIN debug mode" "0,1" 
  TEXTLINE "            "
  bitfld.word  0x00 10.           "  DSF      ,Double stop flags" "0,1" 
  bitfld.word  0x00 09.           "  PRTY     ,Activating parity generation" "0,1" 
  bitfld.word  0x00 08.           "  LIN      ,LIN mode. Switch device into LIN mode" "0,1" 
  bitfld.word  0x00 07.           "  RXIE     ,LIN RXREG ready interrupt enable." "0,1" 
  TEXTLINE "            "
  bitfld.word  0x00 06.           "  TXIE     ,LIN TXREG ready interrupt enable." "0,1" 
  bitfld.word  0x00 05.           "  WUIE     ,RX wakeup interrupt enable." "0,1" 
  bitfld.word  0x00 04.           "  STIE     ,Slave timeout error interrupt enable." "0,1" 
  bitfld.word  0x00 03.           "  PBIE     ,Physical bus error interrupt enable." "0,1" 
  TEXTLINE "            "
  bitfld.word  0x00 02.           "  CIE      ,CRC error interrupt enable." "0,1" 
  bitfld.word  0x00 01.           "  CKIE     ,Checksum error interrupt enable." "0,1" 
  bitfld.word  0x00 00.           "  FCIE     ,Frame complete interrupt enable." "0,1" 
TEXTLINE ""
  
group.word (0xFFFB0000+0x0e)++0x01
  line.word    0x00 "LCR2,LIN Control Register 2"
  bitfld.word  0x00 09.             "UQIE     ,Unrequested Data Received Interrupt Enable" "0,1" 
  bitfld.word  0x00 08.           "  OFIE     ,Overflow Interrupt Enable" "0,1" 

group.byte (0xFFFB0000+0x10)++0x00
  line.byte    0x00 "LTR,LIN Transmit Register"

group.byte (0xFFFB0000+0x14)++0x00
  line.byte    0x00 "LRR,LIN Receive Register"

group.word (0xFFFB0000+0x18)++0x01
  line.word    0x00 "LPR,LIN CRC Polynomial Register"

TEXTLINE ""

group.word (0xFFFB0000+0x1a)++0x01
  line.word    0x00 "CR3,Control Register 3"
  bitfld.word  0x00 12.             "SYNM     ,Synchronization Mode" "0,1" 
  TEXTLINE "            "
  bitfld.word  0x00 11.           "  EROE     ,ERR flag overrun enable" "0,1" 
  bitfld.word  0x00 10.           "  ERFE     ,ERR flag frame error enable" "0,1" 
  bitfld.word  0x00 09.           "  ERPE     ,ERR flag parity error enable" "0,1" 
  TEXTLINE "            "
  bitfld.word  0x00 08.           "  M2       ,Frame Format Mode 2" "0,1" 

tree.end

tree "ESCI B"

group.word 0xFFFB4000++0x01
  line.word    0x00 "BRR,Baud Rate Register"

group.word (0xFFFB4000+0x2)++0x01
  line.word    0x00 "CR1,Configuration Register 1"
  bitfld.word  0x00 15.             "LOOPS    ,Loop select" "0,1" 
  bitfld.word  0x00 13.           "  RSRC     ,Receiver source" "0,1" 
  bitfld.word  0x00 12.           "  M    ,Data format mode" "1-8-1,1-9-1" 
  bitfld.word  0x00 11.           "  WAKE   ,Wakeup condition" "ILW,AMW" 
  TEXTLINE "            "
  bitfld.word  0x00 10.           "  ILT   ,Idle line type" "STRT,STOP" 
  bitfld.word  0x00 09.           "  PE       ,Parity enable" "0,1" 
  bitfld.word  0x00 08.           "  PT    ,Parity type" "EVEN,ODD" 
  bitfld.word  0x00 07.           "  TIE      ,Transmitter interrupt enable" "0,1" 
  TEXTLINE "            "
  bitfld.word  0x00 06.           "  TCIE     ,Transmission complete interrupt enable" "0,1" 
  bitfld.word  0x00 05.           "  RIE      ,Receiver full interrupt enable" "0,1" 
  bitfld.word  0x00 04.           "  ILIE     ,Idle line interrupt enable" "0,1" 
  bitfld.word  0x00 03.           "  TE       ,Transmitter enable" "0,1" 
  TEXTLINE "            "
  bitfld.word  0x00 02.           "  RE       ,Receiver enable" "0,1" 
  bitfld.word  0x00 01.           "  RWU      ,Receiver wakeup" "0,1" 
  bitfld.word  0x00 00.           "  SBK      ,Send break" "0,1" 
TEXTLINE ""

group.word (0xFFFB4000+0x04)++0x01
  line.word    0x00 "CR2,Module Configuration Register 2"
  bitfld.word  0x00 15.             "MDIS     ,Module disable" "0,1" 
  bitfld.word  0x00 14.           "  FBR      ,Fast bit error detection" "0,1"
  bitfld.word  0x00 13.           "  BSTP     ,Bit error/physical bus error stop" "0,1" 
  bitfld.word  0x00 12.           "  IEBERR   ,Enable bit error interrupt" "0,1" 
  TEXTLINE "            "
  bitfld.word  0x00 11.           "  RXDMA    ,Activate RX DMA channel" "0,1" 
  bitfld.word  0x00 10.           "  TXDMA    ,Activate TX DMA channel" "0,1" 
  bitfld.word  0x00 09.           "  BRCL ,Break Character Length" "10/11,13/14" 
  bitfld.word  0x00 08.           "  TXDIR ,TXD pin output driver control" " dis,ena"
  TEXTLINE "            "
  bitfld.word  0x00 07.           "  BESM  ,Bit error sample mode - bit 13" " RC9,RC13"
  bitfld.word  0x00 06.           "  BESTP    ,Transmit Stop on Bit Error" "0,1"
  bitfld.word  0x00 05.           "  RXPOL  ,RXD Pin polarity" "nrm,inv"
  bitfld.word  0x00 04.           "  PMSK     ,Parity Bit Masking" "0,1"
  TEXTLINE "            "
  bitfld.word  0x00 03.           "  ORIE     ,Overrun error interrupt enable" "0,1"
  bitfld.word  0x00 02.           "  NFIE     ,Noise flag interrupt enable" "0,1"
  bitfld.word  0x00 01.           "  FEIE     ,Frame error interrupt enable" "0,1"
  bitfld.word  0x00 00.           "  PFIE     ,Parity flag interrupt enable" "0,1"
TEXTLINE ""

group.word (0xFFFB4000+0x06)++0x01
  line.word    0x00 "SDR,SCI Data Register"
  bitfld.word  0x00 15.             "RN       ,Received Most Significant Bit" "0,1" 
  bitfld.word  0x00 14.           "  TN       ,Transmit Most Significant Bit" "0,1" 
  bitfld.word  0x00 13.           "  ERR      ,Receive Error Bit" "0,1" 
  hexmask.word 0x00 00.--11. 1.   "  D     ,RX/TX Data"
TEXTLINE ""
  
group.word (0xFFFB4000+0x08)++0x01
  line.word    0x00 "IFSR1,Interrupt Flag and Status Register 1"
  eventfld.word  0x00 15.           "TDRE     ,Transmit data register empty flag" "0,1" 
  eventfld.word  0x00 14.         "  TC       ,Transmit complete flag" "0,1" 
  eventfld.word  0x00 13.         "  RDRF     ,Receive data register full flag" "0,1" 
  eventfld.word  0x00 12.         "  IDLE     ,Idle line flag" "0,1" 
  TEXTLINE "            "
  eventfld.word  0x00 11.         "  OR       ,Overrun flag" "0,1" 
  eventfld.word  0x00 10.         "  NF       ,Noise flag" "0,1" 
  eventfld.word  0x00 09.         "  FE       ,Framing error flag" "0,1" 
  eventfld.word  0x00 08.         "  PF       ,Parity error flag" "0,1" 
  TEXTLINE "            "
  eventfld.word  0x00 04.         "  BERR     ,Bit error" "0,1" 
  bitfld.word  0x00 01.           "  TACT     ,Transmitter active flag" "0,1" 
  bitfld.word  0x00 00.           "  RACT     ,Receiver active flag" "0,1" 
TEXTLINE ""
  
group.word (0xFFFB4000+0x0a)++0x01
  line.word    0x00 "IFSR2,Interrupt Flag and Status Register 2"
  eventfld.word  0x00 15.           "RXRDY    ,Receive data ready" "0,1" 
  eventfld.word  0x00 14.         "  TXRDY    ,Transmit data ready" "0,1" 
  eventfld.word  0x00 13.         "  LWAKE    ,Received LIN wakeup signal" "0,1" 
  eventfld.word  0x00 12.         "  STO      ,Slave time out" "0,1" 
  TEXTLINE "            "
  eventfld.word  0x00 11.         "  PBERR    ,Physical bus error" "0,1" 
  eventfld.word  0x00 10.         "  CERR     ,CRC error" "0,1" 
  eventfld.word  0x00 09.         "  CKERR    ,Checksum error" "0,1" 
  eventfld.word  0x00 08.         "  FRC      ,Frame complete" "0,1" 
  TEXTLINE "            "
  eventfld.word  0x00 01.         "  UREQ     ,Unrequested Data Received Interrupt Flag" "0,1" 
  eventfld.word  0x00 00.         "  OVFL     ,LRR overflow" "0,1" 
TEXTLINE ""

group.word (0xFFFB4000+0x0C)++0x01
  line.word    0x00 "LCR1,LIN Control Register 1"
  bitfld.word  0x00 15.             "LRES     ,LIN resynchronize" "0,1" 
  bitfld.word  0x00 14.           "  WU       ,LIN bus wakeup." "0,1" 
  bitfld.word  0x00 12.--13.      "  WUD     ,Wakeup delimiter time" " 4, 8,32,64" 
  bitfld.word  0x00 11.           "  LDBG     ,LIN debug mode" "0,1" 
  TEXTLINE "            "
  bitfld.word  0x00 10.           "  DSF      ,Double stop flags" "0,1" 
  bitfld.word  0x00 09.           "  PRTY     ,Activating parity generation" "0,1" 
  bitfld.word  0x00 08.           "  LIN      ,LIN mode. Switch device into LIN mode" "0,1" 
  bitfld.word  0x00 07.           "  RXIE     ,LIN RXREG ready interrupt enable." "0,1" 
  TEXTLINE "            "
  bitfld.word  0x00 06.           "  TXIE     ,LIN TXREG ready interrupt enable." "0,1" 
  bitfld.word  0x00 05.           "  WUIE     ,RX wakeup interrupt enable." "0,1" 
  bitfld.word  0x00 04.           "  STIE     ,Slave timeout error interrupt enable." "0,1" 
  bitfld.word  0x00 03.           "  PBIE     ,Physical bus error interrupt enable." "0,1" 
  TEXTLINE "            "
  bitfld.word  0x00 02.           "  CIE      ,CRC error interrupt enable." "0,1" 
  bitfld.word  0x00 01.           "  CKIE     ,Checksum error interrupt enable." "0,1" 
  bitfld.word  0x00 00.           "  FCIE     ,Frame complete interrupt enable." "0,1" 
TEXTLINE ""
  
group.word (0xFFFB4000+0x0e)++0x01
  line.word    0x00 "LCR2,LIN Control Register 2"
  bitfld.word  0x00 09.             "UQIE     ,Unrequested Data Received Interrupt Enable" "0,1" 
  bitfld.word  0x00 08.           "  OFIE     ,Overflow Interrupt Enable" "0,1" 

group.byte (0xFFFB4000+0x10)++0x00
  line.byte    0x00 "LTR,LIN Transmit Register"

group.byte (0xFFFB4000+0x14)++0x00
  line.byte    0x00 "LRR,LIN Receive Register"

group.word (0xFFFB4000+0x18)++0x01
  line.word    0x00 "LPR,LIN CRC Polynomial Register"

TEXTLINE ""

group.word (0xFFFB4000+0x1a)++0x01
  line.word    0x00 "CR3,Control Register 3"
  bitfld.word  0x00 12.             "SYNM     ,Synchronization Mode" "0,1" 
  TEXTLINE "            "
  bitfld.word  0x00 11.           "  EROE     ,ERR flag overrun enable" "0,1" 
  bitfld.word  0x00 10.           "  ERFE     ,ERR flag frame error enable" "0,1" 
  bitfld.word  0x00 09.           "  ERPE     ,ERR flag parity error enable" "0,1" 
  TEXTLINE "            "
  bitfld.word  0x00 08.           "  M2       ,Frame Format Mode 2" "0,1" 

tree.end

  sif (CPUIS("MPC5674*")) 
tree "ESCI C"

group.word 0xFFFB8000++0x01
  line.word    0x00 "BRR,Baud Rate Register"

group.word (0xFFFB8000+0x2)++0x01
  line.word    0x00 "CR1,Configuration Register 1"
  bitfld.word  0x00 15.             "LOOPS    ,Loop select" "0,1" 
  bitfld.word  0x00 13.           "  RSRC     ,Receiver source" "0,1" 
  bitfld.word  0x00 12.           "  M    ,Data format mode" "1-8-1,1-9-1" 
  bitfld.word  0x00 11.           "  WAKE   ,Wakeup condition" "ILW,AMW" 
  TEXTLINE "            "
  bitfld.word  0x00 10.           "  ILT   ,Idle line type" "STRT,STOP" 
  bitfld.word  0x00 09.           "  PE       ,Parity enable" "0,1" 
  bitfld.word  0x00 08.           "  PT    ,Parity type" "EVEN,ODD" 
  bitfld.word  0x00 07.           "  TIE      ,Transmitter interrupt enable" "0,1" 
  TEXTLINE "            "
  bitfld.word  0x00 06.           "  TCIE     ,Transmission complete interrupt enable" "0,1" 
  bitfld.word  0x00 05.           "  RIE      ,Receiver full interrupt enable" "0,1" 
  bitfld.word  0x00 04.           "  ILIE     ,Idle line interrupt enable" "0,1" 
  bitfld.word  0x00 03.           "  TE       ,Transmitter enable" "0,1" 
  TEXTLINE "            "
  bitfld.word  0x00 02.           "  RE       ,Receiver enable" "0,1" 
  bitfld.word  0x00 01.           "  RWU      ,Receiver wakeup" "0,1" 
  bitfld.word  0x00 00.           "  SBK      ,Send break" "0,1" 
TEXTLINE ""

group.word (0xFFFB8000+0x04)++0x01
  line.word    0x00 "CR2,Module Configuration Register 2"
  bitfld.word  0x00 15.             "MDIS     ,Module disable" "0,1" 
  bitfld.word  0x00 14.           "  FBR      ,Fast bit error detection" "0,1"
  bitfld.word  0x00 13.           "  BSTP     ,Bit error/physical bus error stop" "0,1" 
  bitfld.word  0x00 12.           "  IEBERR   ,Enable bit error interrupt" "0,1" 
  TEXTLINE "            "
  bitfld.word  0x00 11.           "  RXDMA    ,Activate RX DMA channel" "0,1" 
  bitfld.word  0x00 10.           "  TXDMA    ,Activate TX DMA channel" "0,1" 
  bitfld.word  0x00 09.           "  BRCL ,Break Character Length" "10/11,13/14" 
  bitfld.word  0x00 08.           "  TXDIR ,TXD pin output driver control" " dis,ena"
  TEXTLINE "            "
  bitfld.word  0x00 07.           "  BESM  ,Bit error sample mode - bit 13" " RC9,RC13"
  bitfld.word  0x00 06.           "  BESTP    ,Transmit Stop on Bit Error" "0,1"
  bitfld.word  0x00 05.           "  RXPOL  ,RXD Pin polarity" "nrm,inv"
  bitfld.word  0x00 04.           "  PMSK     ,Parity Bit Masking" "0,1"
  TEXTLINE "            "
  bitfld.word  0x00 03.           "  ORIE     ,Overrun error interrupt enable" "0,1"
  bitfld.word  0x00 02.           "  NFIE     ,Noise flag interrupt enable" "0,1"
  bitfld.word  0x00 01.           "  FEIE     ,Frame error interrupt enable" "0,1"
  bitfld.word  0x00 00.           "  PFIE     ,Parity flag interrupt enable" "0,1"
TEXTLINE ""

group.word (0xFFFB8000+0x06)++0x01
  line.word    0x00 "SDR,SCI Data Register"
  bitfld.word  0x00 15.             "RN       ,Received Most Significant Bit" "0,1" 
  bitfld.word  0x00 14.           "  TN       ,Transmit Most Significant Bit" "0,1" 
  bitfld.word  0x00 13.           "  ERR      ,Receive Error Bit" "0,1" 
  hexmask.word 0x00 00.--11. 1.   "  D     ,RX/TX Data"
TEXTLINE ""
  
group.word (0xFFFB8000+0x08)++0x01
  line.word    0x00 "IFSR1,Interrupt Flag and Status Register 1"
  eventfld.word  0x00 15.           "TDRE     ,Transmit data register empty flag" "0,1" 
  eventfld.word  0x00 14.         "  TC       ,Transmit complete flag" "0,1" 
  eventfld.word  0x00 13.         "  RDRF     ,Receive data register full flag" "0,1" 
  eventfld.word  0x00 12.         "  IDLE     ,Idle line flag" "0,1" 
  TEXTLINE "            "
  eventfld.word  0x00 11.         "  OR       ,Overrun flag" "0,1" 
  eventfld.word  0x00 10.         "  NF       ,Noise flag" "0,1" 
  eventfld.word  0x00 09.         "  FE       ,Framing error flag" "0,1" 
  eventfld.word  0x00 08.         "  PF       ,Parity error flag" "0,1" 
  TEXTLINE "            "
  eventfld.word  0x00 04.         "  BERR     ,Bit error" "0,1" 
  bitfld.word  0x00 01.           "  TACT     ,Transmitter active flag" "0,1" 
  bitfld.word  0x00 00.           "  RACT     ,Receiver active flag" "0,1" 
TEXTLINE ""
  
group.word (0xFFFB8000+0x0a)++0x01
  line.word    0x00 "IFSR2,Interrupt Flag and Status Register 2"
  eventfld.word  0x00 15.           "RXRDY    ,Receive data ready" "0,1" 
  eventfld.word  0x00 14.         "  TXRDY    ,Transmit data ready" "0,1" 
  eventfld.word  0x00 13.         "  LWAKE    ,Received LIN wakeup signal" "0,1" 
  eventfld.word  0x00 12.         "  STO      ,Slave time out" "0,1" 
  TEXTLINE "            "
  eventfld.word  0x00 11.         "  PBERR    ,Physical bus error" "0,1" 
  eventfld.word  0x00 10.         "  CERR     ,CRC error" "0,1" 
  eventfld.word  0x00 09.         "  CKERR    ,Checksum error" "0,1" 
  eventfld.word  0x00 08.         "  FRC      ,Frame complete" "0,1" 
  TEXTLINE "            "
  eventfld.word  0x00 01.         "  UREQ     ,Unrequested Data Received Interrupt Flag" "0,1" 
  eventfld.word  0x00 00.         "  OVFL     ,LRR overflow" "0,1" 
TEXTLINE ""

group.word (0xFFFB8000+0x0C)++0x01
  line.word    0x00 "LCR1,LIN Control Register 1"
  bitfld.word  0x00 15.             "LRES     ,LIN resynchronize" "0,1" 
  bitfld.word  0x00 14.           "  WU       ,LIN bus wakeup." "0,1" 
  bitfld.word  0x00 12.--13.      "  WUD     ,Wakeup delimiter time" " 4, 8,32,64" 
  bitfld.word  0x00 11.           "  LDBG     ,LIN debug mode" "0,1" 
  TEXTLINE "            "
  bitfld.word  0x00 10.           "  DSF      ,Double stop flags" "0,1" 
  bitfld.word  0x00 09.           "  PRTY     ,Activating parity generation" "0,1" 
  bitfld.word  0x00 08.           "  LIN      ,LIN mode. Switch device into LIN mode" "0,1" 
  bitfld.word  0x00 07.           "  RXIE     ,LIN RXREG ready interrupt enable." "0,1" 
  TEXTLINE "            "
  bitfld.word  0x00 06.           "  TXIE     ,LIN TXREG ready interrupt enable." "0,1" 
  bitfld.word  0x00 05.           "  WUIE     ,RX wakeup interrupt enable." "0,1" 
  bitfld.word  0x00 04.           "  STIE     ,Slave timeout error interrupt enable." "0,1" 
  bitfld.word  0x00 03.           "  PBIE     ,Physical bus error interrupt enable." "0,1" 
  TEXTLINE "            "
  bitfld.word  0x00 02.           "  CIE      ,CRC error interrupt enable." "0,1" 
  bitfld.word  0x00 01.           "  CKIE     ,Checksum error interrupt enable." "0,1" 
  bitfld.word  0x00 00.           "  FCIE     ,Frame complete interrupt enable." "0,1" 
TEXTLINE ""
  
group.word (0xFFFB8000+0x0e)++0x01
  line.word    0x00 "LCR2,LIN Control Register 2"
  bitfld.word  0x00 09.             "UQIE     ,Unrequested Data Received Interrupt Enable" "0,1" 
  bitfld.word  0x00 08.           "  OFIE     ,Overflow Interrupt Enable" "0,1" 

group.byte (0xFFFB8000+0x10)++0x00
  line.byte    0x00 "LTR,LIN Transmit Register"

group.byte (0xFFFB8000+0x14)++0x00
  line.byte    0x00 "LRR,LIN Receive Register"

group.word (0xFFFB8000+0x18)++0x01
  line.word    0x00 "LPR,LIN CRC Polynomial Register"

TEXTLINE ""

group.word (0xFFFB8000+0x1a)++0x01
  line.word    0x00 "CR3,Control Register 3"
  bitfld.word  0x00 12.             "SYNM     ,Synchronization Mode" "0,1" 
  TEXTLINE "            "
  bitfld.word  0x00 11.           "  EROE     ,ERR flag overrun enable" "0,1" 
  bitfld.word  0x00 10.           "  ERFE     ,ERR flag frame error enable" "0,1" 
  bitfld.word  0x00 09.           "  ERPE     ,ERR flag parity error enable" "0,1" 
  TEXTLINE "            "
  bitfld.word  0x00 08.           "  M2       ,Frame Format Mode 2" "0,1" 

tree.end

 endif
else
tree "ESCI A"

group.long 0xFFFB0000++0x03
  line.long    0x00 "CR1,Configuration Register 1"
  hexmask.word 0x00 00.--12. 1.     "SBR  ,SCI baud rate"
  bitfld.long  0x00 15.           "  LOOPS   ,Loop select" "0,1" 
  bitfld.long  0x00 13.           "  RSRC    ,Receiver source" "0,1" 
  bitfld.long  0x00 12.           "  M   ,Data format mode" "1-8-1,1-9-1" 
  bitfld.long  0x00 11.           "  WAKE  ,Wakeup condition" "ILW,AMW" 
  bitfld.long  0x00 10.           "  ILT  ,Idle line type" "STRT,STOP" 
  TEXTLINE "                "
  bitfld.long  0x00 09.           "  PE      ,Parity enable" "0,1" 
  bitfld.long  0x00 08.           "  PT   ,Parity type" "EVEN,ODD" 
  bitfld.long  0x00 07.           "  TIE     ,Transmitter interrupt enable" "0,1" 
  bitfld.long  0x00 06.           "  TCIE    ,Transmission complete interrupt enable" "0,1" 
  bitfld.long  0x00 05.           "  RIE     ,Receiver full interrupt enable" "0,1" 
  bitfld.long  0x00 04.           "  ILIE    ,Idle line interrupt enable" "0,1" 
  TEXTLINE "                "
  bitfld.long  0x00 03.           "  TE      ,Transmitter enable" "0,1" 
  bitfld.long  0x00 02.           "  RE      ,Receiver enable" "0,1" 
  bitfld.long  0x00 01.           "  RWU     ,Receiver wakeup" "0,1" 
  bitfld.long  0x00 00.           "  SBK     ,Send break" "0,1" 
TEXTLINE ""

group.word (0xFFFB0000+0x04)++0x01
  line.word    0x00 "CR2,Module Configuration Register 2"
  bitfld.word  0x00 15.           "    MDIS    ,Module disable" "0,1" 
  bitfld.word  0x00 14.           "  FBR     ,Fast bit error detection" "0,1"
  bitfld.word  0x00 13.           "  BSTP    ,Bit error/physical bus error stop" "0,1" 
  bitfld.word  0x00 12.           "  IEBERR  ,Enable bit error interrupt" "0,1" 
  bitfld.word  0x00 11.           "  RXDMA   ,Activate RX DMA channel" "0,1" 
  bitfld.word  0x00 10.           "  TXDMA   ,Activate TX DMA channel" "0,1" 
  TEXTLINE "                "
  bitfld.word  0x00 09.           "  BRK ,Break transmit character length" "10/11,13/14" 
  bitfld.word  0x00 07.           "  BESM ,Bit error sample mode - bit 13" " RC9,RC13"
  bitfld.word  0x00 06.           "  SBSTP   ,SCI bit error stop" "0,1"
  bitfld.word  0x00 03.           "  ORIE    ,Overrun error interrupt enable" "0,1"
  bitfld.word  0x00 02.           "  NFIE    ,Noise flag interrupt enable" "0,1"
  bitfld.word  0x00 01.           "  FEIE    ,Frame error interrupt enable" "0,1"
  TEXTLINE "                "
  bitfld.word  0x00 00.           "  PFIE    ,Parity flag interrupt enable" "0,1"
TEXTLINE ""

group.word (0xFFFB0000+0x06)++0x01
  line.word    0x00 "DR,Data Register 1"
  bitfld.word  0x00 15.           "    R8      ,Received bit 8" "0,1" 
  bitfld.word  0x00 14.           "  T8      ,Transmit bit 8" "0,1" 
  hexmask.byte 0x01 00.--07. 1.   "  D      ,RX/TX Data"
TEXTLINE ""
  
group.long (0xFFFB0000+0x08)++0x03
  line.long    0x00 "SR,Status Register"
  eventfld.long  0x00 31.           "TDRE    ,Transmit data register empty flag" "0,1" 
  eventfld.long  0x00 30.           "  TC      ,Transmit complete flag" "0,1" 
  eventfld.long  0x00 29.           "  RDRF    ,Receive data register full flag" "0,1" 
  eventfld.long  0x00 28.           "  IDLE    ,Idle line flag" "0,1" 
  eventfld.long  0x00 27.           "  OR      ,Overrun flag" "0,1" 
  eventfld.long  0x00 26.           "  NF      ,Noise flag" "0,1" 
  TEXTLINE "                "
  eventfld.long  0x00 25.           "  FE      ,Framing error flag" "0,1" 
  eventfld.long  0x00 24.           "  PF      ,Parity error flag" "0,1" 
  eventfld.long  0x00 20.           "  BERR    ,Bit error" "0,1" 
  eventfld.long  0x00 16.           "  RAF     ,Receiver active flag" "0,1" 
  eventfld.long  0x00 15.           "  RXRDY   ,Receive data ready" "0,1" 
  eventfld.long  0x00 14.           "  TXRDY   ,Transmit data ready" "0,1" 
  TEXTLINE "                "
  eventfld.long  0x00 13.           "  LWAKE   ,Received LIN wakeup signal" "0,1" 
  eventfld.long  0x00 12.           "  STO     ,Slave time out" "0,1" 
  eventfld.long  0x00 11.           "  PBERR   ,Physical bus error" "0,1" 
  eventfld.long  0x00 10.           "  CERR    ,CRC error" "0,1" 
  eventfld.long  0x00 09.           "  CKERR   ,Checksum error" "0,1" 
  eventfld.long  0x00 08.           "  FRC     ,Frame complete" "0,1" 
  TEXTLINE "                "
  eventfld.long  0x00 00.           "  OVFL    ,LRR overflow" "0,1" 
TEXTLINE ""

  
group.long (0xFFFB0000+0x0C)++0x03
  line.long    0x00 "LCR,LIN Control Register"
  bitfld.long  0x00 31.           "LRES    ,LIN resynchronize" "0,1" 
  bitfld.long  0x00 30.           "  WU      ,LIN bus wakeup." "0,1" 
  bitfld.long  0x00 28.--29.      "  WUD    ,Wakeup delimiter time" " 4, 8,32,64" 
  bitfld.long  0x00 27.           "  LDBG    ,LIN debug mode" "0,1" 
  bitfld.long  0x00 26.           "  DSF     ,Double stop flags" "0,1" 
  bitfld.long  0x00 25.           "  PRTY    ,Activating parity generation" "0,1" 
  TEXTLINE "                "
  bitfld.long  0x00 24.           "  LIN     ,LIN mode. Switch device into LIN mode" "0,1" 
  bitfld.long  0x00 23.           "  RXIE    ,LIN RXREG ready interrupt enable." "0,1" 
  bitfld.long  0x00 22.           "  TXIE    ,LIN TXREG ready interrupt enable." "0,1" 
  bitfld.long  0x00 21.           "  WUIE    ,RX wakeup interrupt enable." "0,1" 
  bitfld.long  0x00 20.           "  STIE    ,Slave timeout error interrupt enable." "0,1" 
  bitfld.long  0x00 19.           "  PBIE    ,Physical bus error interrupt enable." "0,1" 
  TEXTLINE "                "
  bitfld.long  0x00 18.           "  CIE     ,CRC error interrupt enable." "0,1" 
  bitfld.long  0x00 17.           "  CKIE    ,Checksum error interrupt enable." "0,1" 
  bitfld.long  0x00 16.           "  FCIE    ,Frame complete interrupt enable." "0,1" 
  bitfld.long  0x00 08.           "  OFIE    ,Overflow interrupt enable." "0,1" 
TEXTLINE ""

group.long (0xFFFB0000+0x10)++0x03
  line.long    0x00 "LTR,LIN Transmit Register"

group.long (0xFFFB0000+0x14)++0x03
  line.long    0x00 "LRR,LIN Receive Register"

group.long (0xFFFB0000+0x18)++0x03
  line.long    0x00 "LPR,LIN CRC Polynomial Register"


tree.end

 sif (cpu()=="MPC5534")||(cpu()=="MPC5553")||(cpu()=="MPC5554")||(cpu()=="MPC5561")||(cpu()=="MPC5565")||(cpu()=="MPC5566")||(cpu()=="MPC5567")
tree "ESCI B"

group.long 0xFFFB4000++0x03
  line.long    0x00 "CR1,Configuration Register 1"
  hexmask.word 0x00 00.--12. 1.     "SBR  ,SCI baud rate"
  bitfld.long  0x00 15.           "  LOOPS   ,Loop select" "0,1" 
  bitfld.long  0x00 13.           "  RSRC    ,Receiver source" "0,1" 
  bitfld.long  0x00 12.           "  M   ,Data format mode" "1-8-1,1-9-1" 
  bitfld.long  0x00 11.           "  WAKE  ,Wakeup condition" "ILW,AMW" 
  bitfld.long  0x00 10.           "  ILT  ,Idle line type" "STRT,STOP" 
  TEXTLINE "                "
  bitfld.long  0x00 09.           "  PE      ,Parity enable" "0,1" 
  bitfld.long  0x00 08.           "  PT   ,Parity type" "EVEN,ODD" 
  bitfld.long  0x00 07.           "  TIE     ,Transmitter interrupt enable" "0,1" 
  bitfld.long  0x00 06.           "  TCIE    ,Transmission complete interrupt enable" "0,1" 
  bitfld.long  0x00 05.           "  RIE     ,Receiver full interrupt enable" "0,1" 
  bitfld.long  0x00 04.           "  ILIE    ,Idle line interrupt enable" "0,1" 
  TEXTLINE "                "
  bitfld.long  0x00 03.           "  TE      ,Transmitter enable" "0,1" 
  bitfld.long  0x00 02.           "  RE      ,Receiver enable" "0,1" 
  bitfld.long  0x00 01.           "  RWU     ,Receiver wakeup" "0,1" 
  bitfld.long  0x00 00.           "  SBK     ,Send break" "0,1" 
TEXTLINE ""

group.word (0xFFFB4000+0x04)++0x01
  line.word    0x00 "CR2,Module Configuration Register 2"
  bitfld.word  0x00 15.           "    MDIS    ,Module disable" "0,1" 
  bitfld.word  0x00 14.           "  FBR     ,Fast bit error detection" "0,1"
  bitfld.word  0x00 13.           "  BSTP    ,Bit error/physical bus error stop" "0,1" 
  bitfld.word  0x00 12.           "  IEBERR  ,Enable bit error interrupt" "0,1" 
  bitfld.word  0x00 11.           "  RXDMA   ,Activate RX DMA channel" "0,1" 
  bitfld.word  0x00 10.           "  TXDMA   ,Activate TX DMA channel" "0,1" 
  TEXTLINE "                "
  bitfld.word  0x00 09.           "  BRK ,Break transmit character length" "10/11,13/14" 
  bitfld.word  0x00 07.           "  BESM ,Bit error sample mode - bit 13" " RC9,RC13"
  bitfld.word  0x00 06.           "  SBSTP   ,SCI bit error stop" "0,1"
  bitfld.word  0x00 03.           "  ORIE    ,Overrun error interrupt enable" "0,1"
  bitfld.word  0x00 02.           "  NFIE    ,Noise flag interrupt enable" "0,1"
  bitfld.word  0x00 01.           "  FEIE    ,Frame error interrupt enable" "0,1"
  TEXTLINE "                "
  bitfld.word  0x00 00.           "  PFIE    ,Parity flag interrupt enable" "0,1"
TEXTLINE ""

group.word (0xFFFB4000+0x06)++0x01
  line.word    0x00 "DR,Data Register 1"
  bitfld.word  0x00 15.           "    R8      ,Received bit 8" "0,1" 
  bitfld.word  0x00 14.           "  T8      ,Transmit bit 8" "0,1" 
  hexmask.byte 0x01 00.--07. 1.   "  D      ,RX/TX Data"
TEXTLINE ""
  
group.long (0xFFFB4000+0x08)++0x03
  line.long    0x00 "SR,Status Register"
  eventfld.long  0x00 31.           "TDRE    ,Transmit data register empty flag" "0,1" 
  eventfld.long  0x00 30.           "  TC      ,Transmit complete flag" "0,1" 
  eventfld.long  0x00 29.           "  RDRF    ,Receive data register full flag" "0,1" 
  eventfld.long  0x00 28.           "  IDLE    ,Idle line flag" "0,1" 
  eventfld.long  0x00 27.           "  OR      ,Overrun flag" "0,1" 
  eventfld.long  0x00 26.           "  NF      ,Noise flag" "0,1" 
  TEXTLINE "                "
  eventfld.long  0x00 25.           "  FE      ,Framing error flag" "0,1" 
  eventfld.long  0x00 24.           "  PF      ,Parity error flag" "0,1" 
  eventfld.long  0x00 20.           "  BERR    ,Bit error" "0,1" 
  eventfld.long  0x00 16.           "  RAF     ,Receiver active flag" "0,1" 
  eventfld.long  0x00 15.           "  RXRDY   ,Receive data ready" "0,1" 
  eventfld.long  0x00 14.           "  TXRDY   ,Transmit data ready" "0,1" 
  TEXTLINE "                "
  eventfld.long  0x00 13.           "  LWAKE   ,Received LIN wakeup signal" "0,1" 
  eventfld.long  0x00 12.           "  STO     ,Slave time out" "0,1" 
  eventfld.long  0x00 11.           "  PBERR   ,Physical bus error" "0,1" 
  eventfld.long  0x00 10.           "  CERR    ,CRC error" "0,1" 
  eventfld.long  0x00 09.           "  CKERR   ,Checksum error" "0,1" 
  eventfld.long  0x00 08.           "  FRC     ,Frame complete" "0,1" 
  TEXTLINE "                "
  eventfld.long  0x00 00.           "  OVFL    ,LRR overflow" "0,1" 
TEXTLINE ""

  
group.long (0xFFFB4000+0x0C)++0x03
  line.long    0x00 "LCR,LIN Control Register"
  bitfld.long  0x00 31.           "LRES    ,LIN resynchronize" "0,1" 
  bitfld.long  0x00 30.           "  WU      ,LIN bus wakeup." "0,1" 
  bitfld.long  0x00 28.--29.      "  WUD    ,Wakeup delimiter time" " 4, 8,32,64" 
  bitfld.long  0x00 27.           "  LDBG    ,LIN debug mode" "0,1" 
  bitfld.long  0x00 26.           "  DSF     ,Double stop flags" "0,1" 
  bitfld.long  0x00 25.           "  PRTY    ,Activating parity generation" "0,1" 
  TEXTLINE "                "
  bitfld.long  0x00 24.           "  LIN     ,LIN mode. Switch device into LIN mode" "0,1" 
  bitfld.long  0x00 23.           "  RXIE    ,LIN RXREG ready interrupt enable." "0,1" 
  bitfld.long  0x00 22.           "  TXIE    ,LIN TXREG ready interrupt enable." "0,1" 
  bitfld.long  0x00 21.           "  WUIE    ,RX wakeup interrupt enable." "0,1" 
  bitfld.long  0x00 20.           "  STIE    ,Slave timeout error interrupt enable." "0,1" 
  bitfld.long  0x00 19.           "  PBIE    ,Physical bus error interrupt enable." "0,1" 
  TEXTLINE "                "
  bitfld.long  0x00 18.           "  CIE     ,CRC error interrupt enable." "0,1" 
  bitfld.long  0x00 17.           "  CKIE    ,Checksum error interrupt enable." "0,1" 
  bitfld.long  0x00 16.           "  FCIE    ,Frame complete interrupt enable." "0,1" 
  bitfld.long  0x00 08.           "  OFIE    ,Overflow interrupt enable." "0,1" 
TEXTLINE ""

group.long (0xFFFB4000+0x10)++0x03
  line.long    0x00 "LTR,LIN Transmit Register"

group.long (0xFFFB4000+0x14)++0x03
  line.long    0x00 "LRR,LIN Receive Register"

group.long (0xFFFB4000+0x18)++0x03
  line.long    0x00 "LPR,LIN CRC Polynomial Register"


tree.end

 endif
 sif (cpu()=="MPC5561")
tree "ESCI C"

group.long 0xFFFB8000++0x03
  line.long    0x00 "CR1,Configuration Register 1"
  hexmask.word 0x00 00.--12. 1.     "SBR  ,SCI baud rate"
  bitfld.long  0x00 15.           "  LOOPS   ,Loop select" "0,1" 
  bitfld.long  0x00 13.           "  RSRC    ,Receiver source" "0,1" 
  bitfld.long  0x00 12.           "  M   ,Data format mode" "1-8-1,1-9-1" 
  bitfld.long  0x00 11.           "  WAKE  ,Wakeup condition" "ILW,AMW" 
  bitfld.long  0x00 10.           "  ILT  ,Idle line type" "STRT,STOP" 
  TEXTLINE "                "
  bitfld.long  0x00 09.           "  PE      ,Parity enable" "0,1" 
  bitfld.long  0x00 08.           "  PT   ,Parity type" "EVEN,ODD" 
  bitfld.long  0x00 07.           "  TIE     ,Transmitter interrupt enable" "0,1" 
  bitfld.long  0x00 06.           "  TCIE    ,Transmission complete interrupt enable" "0,1" 
  bitfld.long  0x00 05.           "  RIE     ,Receiver full interrupt enable" "0,1" 
  bitfld.long  0x00 04.           "  ILIE    ,Idle line interrupt enable" "0,1" 
  TEXTLINE "                "
  bitfld.long  0x00 03.           "  TE      ,Transmitter enable" "0,1" 
  bitfld.long  0x00 02.           "  RE      ,Receiver enable" "0,1" 
  bitfld.long  0x00 01.           "  RWU     ,Receiver wakeup" "0,1" 
  bitfld.long  0x00 00.           "  SBK     ,Send break" "0,1" 
TEXTLINE ""

group.word (0xFFFB8000+0x04)++0x01
  line.word    0x00 "CR2,Module Configuration Register 2"
  bitfld.word  0x00 15.           "    MDIS    ,Module disable" "0,1" 
  bitfld.word  0x00 14.           "  FBR     ,Fast bit error detection" "0,1"
  bitfld.word  0x00 13.           "  BSTP    ,Bit error/physical bus error stop" "0,1" 
  bitfld.word  0x00 12.           "  IEBERR  ,Enable bit error interrupt" "0,1" 
  bitfld.word  0x00 11.           "  RXDMA   ,Activate RX DMA channel" "0,1" 
  bitfld.word  0x00 10.           "  TXDMA   ,Activate TX DMA channel" "0,1" 
  TEXTLINE "                "
  bitfld.word  0x00 09.           "  BRK ,Break transmit character length" "10/11,13/14" 
  bitfld.word  0x00 07.           "  BESM ,Bit error sample mode - bit 13" " RC9,RC13"
  bitfld.word  0x00 06.           "  SBSTP   ,SCI bit error stop" "0,1"
  bitfld.word  0x00 03.           "  ORIE    ,Overrun error interrupt enable" "0,1"
  bitfld.word  0x00 02.           "  NFIE    ,Noise flag interrupt enable" "0,1"
  bitfld.word  0x00 01.           "  FEIE    ,Frame error interrupt enable" "0,1"
  TEXTLINE "                "
  bitfld.word  0x00 00.           "  PFIE    ,Parity flag interrupt enable" "0,1"
TEXTLINE ""

group.word (0xFFFB8000+0x06)++0x01
  line.word    0x00 "DR,Data Register 1"
  bitfld.word  0x00 15.           "    R8      ,Received bit 8" "0,1" 
  bitfld.word  0x00 14.           "  T8      ,Transmit bit 8" "0,1" 
  hexmask.byte 0x01 00.--07. 1.   "  D      ,RX/TX Data"
TEXTLINE ""
  
group.long (0xFFFB8000+0x08)++0x03
  line.long    0x00 "SR,Status Register"
  eventfld.long  0x00 31.           "TDRE    ,Transmit data register empty flag" "0,1" 
  eventfld.long  0x00 30.           "  TC      ,Transmit complete flag" "0,1" 
  eventfld.long  0x00 29.           "  RDRF    ,Receive data register full flag" "0,1" 
  eventfld.long  0x00 28.           "  IDLE    ,Idle line flag" "0,1" 
  eventfld.long  0x00 27.           "  OR      ,Overrun flag" "0,1" 
  eventfld.long  0x00 26.           "  NF      ,Noise flag" "0,1" 
  TEXTLINE "                "
  eventfld.long  0x00 25.           "  FE      ,Framing error flag" "0,1" 
  eventfld.long  0x00 24.           "  PF      ,Parity error flag" "0,1" 
  eventfld.long  0x00 20.           "  BERR    ,Bit error" "0,1" 
  eventfld.long  0x00 16.           "  RAF     ,Receiver active flag" "0,1" 
  eventfld.long  0x00 15.           "  RXRDY   ,Receive data ready" "0,1" 
  eventfld.long  0x00 14.           "  TXRDY   ,Transmit data ready" "0,1" 
  TEXTLINE "                "
  eventfld.long  0x00 13.           "  LWAKE   ,Received LIN wakeup signal" "0,1" 
  eventfld.long  0x00 12.           "  STO     ,Slave time out" "0,1" 
  eventfld.long  0x00 11.           "  PBERR   ,Physical bus error" "0,1" 
  eventfld.long  0x00 10.           "  CERR    ,CRC error" "0,1" 
  eventfld.long  0x00 09.           "  CKERR   ,Checksum error" "0,1" 
  eventfld.long  0x00 08.           "  FRC     ,Frame complete" "0,1" 
  TEXTLINE "                "
  eventfld.long  0x00 00.           "  OVFL    ,LRR overflow" "0,1" 
TEXTLINE ""

  
group.long (0xFFFB8000+0x0C)++0x03
  line.long    0x00 "LCR,LIN Control Register"
  bitfld.long  0x00 31.           "LRES    ,LIN resynchronize" "0,1" 
  bitfld.long  0x00 30.           "  WU      ,LIN bus wakeup." "0,1" 
  bitfld.long  0x00 28.--29.      "  WUD    ,Wakeup delimiter time" " 4, 8,32,64" 
  bitfld.long  0x00 27.           "  LDBG    ,LIN debug mode" "0,1" 
  bitfld.long  0x00 26.           "  DSF     ,Double stop flags" "0,1" 
  bitfld.long  0x00 25.           "  PRTY    ,Activating parity generation" "0,1" 
  TEXTLINE "                "
  bitfld.long  0x00 24.           "  LIN     ,LIN mode. Switch device into LIN mode" "0,1" 
  bitfld.long  0x00 23.           "  RXIE    ,LIN RXREG ready interrupt enable." "0,1" 
  bitfld.long  0x00 22.           "  TXIE    ,LIN TXREG ready interrupt enable." "0,1" 
  bitfld.long  0x00 21.           "  WUIE    ,RX wakeup interrupt enable." "0,1" 
  bitfld.long  0x00 20.           "  STIE    ,Slave timeout error interrupt enable." "0,1" 
  bitfld.long  0x00 19.           "  PBIE    ,Physical bus error interrupt enable." "0,1" 
  TEXTLINE "                "
  bitfld.long  0x00 18.           "  CIE     ,CRC error interrupt enable." "0,1" 
  bitfld.long  0x00 17.           "  CKIE    ,Checksum error interrupt enable." "0,1" 
  bitfld.long  0x00 16.           "  FCIE    ,Frame complete interrupt enable." "0,1" 
  bitfld.long  0x00 08.           "  OFIE    ,Overflow interrupt enable." "0,1" 
TEXTLINE ""

group.long (0xFFFB8000+0x10)++0x03
  line.long    0x00 "LTR,LIN Transmit Register"

group.long (0xFFFB8000+0x14)++0x03
  line.long    0x00 "LRR,LIN Receive Register"

group.long (0xFFFB8000+0x18)++0x03
  line.long    0x00 "LPR,LIN CRC Polynomial Register"


tree.end

 endif
 sif (cpu()=="MPC5561")
tree "ESCI D"

group.long 0xFFFBC000++0x03
  line.long    0x00 "CR1,Configuration Register 1"
  hexmask.word 0x00 00.--12. 1.     "SBR  ,SCI baud rate"
  bitfld.long  0x00 15.           "  LOOPS   ,Loop select" "0,1" 
  bitfld.long  0x00 13.           "  RSRC    ,Receiver source" "0,1" 
  bitfld.long  0x00 12.           "  M   ,Data format mode" "1-8-1,1-9-1" 
  bitfld.long  0x00 11.           "  WAKE  ,Wakeup condition" "ILW,AMW" 
  bitfld.long  0x00 10.           "  ILT  ,Idle line type" "STRT,STOP" 
  TEXTLINE "                "
  bitfld.long  0x00 09.           "  PE      ,Parity enable" "0,1" 
  bitfld.long  0x00 08.           "  PT   ,Parity type" "EVEN,ODD" 
  bitfld.long  0x00 07.           "  TIE     ,Transmitter interrupt enable" "0,1" 
  bitfld.long  0x00 06.           "  TCIE    ,Transmission complete interrupt enable" "0,1" 
  bitfld.long  0x00 05.           "  RIE     ,Receiver full interrupt enable" "0,1" 
  bitfld.long  0x00 04.           "  ILIE    ,Idle line interrupt enable" "0,1" 
  TEXTLINE "                "
  bitfld.long  0x00 03.           "  TE      ,Transmitter enable" "0,1" 
  bitfld.long  0x00 02.           "  RE      ,Receiver enable" "0,1" 
  bitfld.long  0x00 01.           "  RWU     ,Receiver wakeup" "0,1" 
  bitfld.long  0x00 00.           "  SBK     ,Send break" "0,1" 
TEXTLINE ""

group.word (0xFFFBC000+0x04)++0x01
  line.word    0x00 "CR2,Module Configuration Register 2"
  bitfld.word  0x00 15.           "    MDIS    ,Module disable" "0,1" 
  bitfld.word  0x00 14.           "  FBR     ,Fast bit error detection" "0,1"
  bitfld.word  0x00 13.           "  BSTP    ,Bit error/physical bus error stop" "0,1" 
  bitfld.word  0x00 12.           "  IEBERR  ,Enable bit error interrupt" "0,1" 
  bitfld.word  0x00 11.           "  RXDMA   ,Activate RX DMA channel" "0,1" 
  bitfld.word  0x00 10.           "  TXDMA   ,Activate TX DMA channel" "0,1" 
  TEXTLINE "                "
  bitfld.word  0x00 09.           "  BRK ,Break transmit character length" "10/11,13/14" 
  bitfld.word  0x00 07.           "  BESM ,Bit error sample mode - bit 13" " RC9,RC13"
  bitfld.word  0x00 06.           "  SBSTP   ,SCI bit error stop" "0,1"
  bitfld.word  0x00 03.           "  ORIE    ,Overrun error interrupt enable" "0,1"
  bitfld.word  0x00 02.           "  NFIE    ,Noise flag interrupt enable" "0,1"
  bitfld.word  0x00 01.           "  FEIE    ,Frame error interrupt enable" "0,1"
  TEXTLINE "                "
  bitfld.word  0x00 00.           "  PFIE    ,Parity flag interrupt enable" "0,1"
TEXTLINE ""

group.word (0xFFFBC000+0x06)++0x01
  line.word    0x00 "DR,Data Register 1"
  bitfld.word  0x00 15.           "    R8      ,Received bit 8" "0,1" 
  bitfld.word  0x00 14.           "  T8      ,Transmit bit 8" "0,1" 
  hexmask.byte 0x01 00.--07. 1.   "  D      ,RX/TX Data"
TEXTLINE ""
  
group.long (0xFFFBC000+0x08)++0x03
  line.long    0x00 "SR,Status Register"
  eventfld.long  0x00 31.           "TDRE    ,Transmit data register empty flag" "0,1" 
  eventfld.long  0x00 30.           "  TC      ,Transmit complete flag" "0,1" 
  eventfld.long  0x00 29.           "  RDRF    ,Receive data register full flag" "0,1" 
  eventfld.long  0x00 28.           "  IDLE    ,Idle line flag" "0,1" 
  eventfld.long  0x00 27.           "  OR      ,Overrun flag" "0,1" 
  eventfld.long  0x00 26.           "  NF      ,Noise flag" "0,1" 
  TEXTLINE "                "
  eventfld.long  0x00 25.           "  FE      ,Framing error flag" "0,1" 
  eventfld.long  0x00 24.           "  PF      ,Parity error flag" "0,1" 
  eventfld.long  0x00 20.           "  BERR    ,Bit error" "0,1" 
  eventfld.long  0x00 16.           "  RAF     ,Receiver active flag" "0,1" 
  eventfld.long  0x00 15.           "  RXRDY   ,Receive data ready" "0,1" 
  eventfld.long  0x00 14.           "  TXRDY   ,Transmit data ready" "0,1" 
  TEXTLINE "                "
  eventfld.long  0x00 13.           "  LWAKE   ,Received LIN wakeup signal" "0,1" 
  eventfld.long  0x00 12.           "  STO     ,Slave time out" "0,1" 
  eventfld.long  0x00 11.           "  PBERR   ,Physical bus error" "0,1" 
  eventfld.long  0x00 10.           "  CERR    ,CRC error" "0,1" 
  eventfld.long  0x00 09.           "  CKERR   ,Checksum error" "0,1" 
  eventfld.long  0x00 08.           "  FRC     ,Frame complete" "0,1" 
  TEXTLINE "                "
  eventfld.long  0x00 00.           "  OVFL    ,LRR overflow" "0,1" 
TEXTLINE ""

  
group.long (0xFFFBC000+0x0C)++0x03
  line.long    0x00 "LCR,LIN Control Register"
  bitfld.long  0x00 31.           "LRES    ,LIN resynchronize" "0,1" 
  bitfld.long  0x00 30.           "  WU      ,LIN bus wakeup." "0,1" 
  bitfld.long  0x00 28.--29.      "  WUD    ,Wakeup delimiter time" " 4, 8,32,64" 
  bitfld.long  0x00 27.           "  LDBG    ,LIN debug mode" "0,1" 
  bitfld.long  0x00 26.           "  DSF     ,Double stop flags" "0,1" 
  bitfld.long  0x00 25.           "  PRTY    ,Activating parity generation" "0,1" 
  TEXTLINE "                "
  bitfld.long  0x00 24.           "  LIN     ,LIN mode. Switch device into LIN mode" "0,1" 
  bitfld.long  0x00 23.           "  RXIE    ,LIN RXREG ready interrupt enable." "0,1" 
  bitfld.long  0x00 22.           "  TXIE    ,LIN TXREG ready interrupt enable." "0,1" 
  bitfld.long  0x00 21.           "  WUIE    ,RX wakeup interrupt enable." "0,1" 
  bitfld.long  0x00 20.           "  STIE    ,Slave timeout error interrupt enable." "0,1" 
  bitfld.long  0x00 19.           "  PBIE    ,Physical bus error interrupt enable." "0,1" 
  TEXTLINE "                "
  bitfld.long  0x00 18.           "  CIE     ,CRC error interrupt enable." "0,1" 
  bitfld.long  0x00 17.           "  CKIE    ,Checksum error interrupt enable." "0,1" 
  bitfld.long  0x00 16.           "  FCIE    ,Frame complete interrupt enable." "0,1" 
  bitfld.long  0x00 08.           "  OFIE    ,Overflow interrupt enable." "0,1" 
TEXTLINE ""

group.long (0xFFFBC000+0x10)++0x03
  line.long    0x00 "LTR,LIN Transmit Register"

group.long (0xFFFBC000+0x14)++0x03
  line.long    0x00 "LRR,LIN Receive Register"

group.long (0xFFFBC000+0x18)++0x03
  line.long    0x00 "LPR,LIN CRC Polynomial Register"


tree.end

 endif
endif

tree.end

tree "FlexCAN2 Controller Area Network"

tree "FlexCAN A"

group.long 0xFFFC0000++0x03
  line.long    0x00 "MCR,Module Configuration Register"
  bitfld.long  0x00 31.                  "MDIS     ,Module disable" "0,1"
  bitfld.long  0x00 30.                  "  FRZ ,Freeze enable" "0,1"
  bitfld.long  0x00 28.                  "      HALT    ,Halt FlexCAN" "0,1"
  bitfld.long  0x00 27.                  "    NOTRDY ,FlexCAN2 not ready" "0,1"
  bitfld.long  0x00 25.                  "  SOFTRST ,Soft reset" "0,1"
  bitfld.long  0x00 24.                  "  FRZACK ,Freeze mode acknowledge" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 21.                  "  WRNEN    ,Warning interrupt enable" "0,1"
  bitfld.long  0x00 20.                  "  MDISACK ,Low power mode acknowledge" "0,1"
  bitfld.long  0x00 17.                  "  SRXDIS  ,This bit defines whether FlexCAN is allowed to receive frames transmitted by itself" "0,1"
  bitfld.long  0x00 16.                  "    MBFEN  ,Message buffer filter enable" "0,1"
  hexmask.byte 0x03 00.--06. 1.          "  MAXMB  ,Maximum number of message buffers"
TEXTLINE ""
 

group.long (0xFFFC0000+0x04)++0x03
  line.long    0x00 "CR,Control Register"
  hexmask.byte 0x00 00.--07. 1.          "PRESDIV ,Prescaler division factor"
  bitfld.long  0x00 22.--23.             "  RJW ,Resync jump width" "0,1,2,3"
  bitfld.long  0x00 19.--21.             "      PSEG1   ,Phase segment 1" "0,1,2,3,4,5,6,7"
  bitfld.long  0x00 16.--18.             "    PSEG2  ,Phase segment 2" "0,1,2,3,4,5,6,7"
  bitfld.long  0x00 15.                  "  BOFFMSK ,Bus off mask" "0,1"
  bitfld.long  0x00 14.                  "  ERRMSK ,Error mask" "0,1"
  bitfld.long  0x00 13.                  "  CLK_SRC ,CAN engine clock source" "osc_clk,bus_clk"
TEXTLINE "                "
  bitfld.long  0x00 12.                  "  LPB      ,Loop back" "0,1"
  bitfld.long  0x00 07.                  "  SMP ,Sampling mode" "one,three"
  bitfld.long  0x00 06.                  "  BOFFREC ,Bus off recovery mode" "ena,dis"
  bitfld.long  0x00 05.                  "  TSYN   ,Timer sync mode" "0,1"
  bitfld.long  0x00 04.                  "  LBUF    ,Lowest buffer transmitted first" "0,1"
  bitfld.long  0x00 03.                  "  LOM    ,Listen-only mode" "0,1"
  bitfld.long  0x00 00.--02.             "  PROPSEG ,Propagation segment" "0,1,2,3,4,5,6,7"
TEXTLINE ""

group.long (0xFFFC0000+0x08)++0x03
  line.long    0x00 "TIMER,Free Running Timer"
TEXTLINE ""

group.long (0xFFFC0000+0x10)++0x03
  line.long    0x00 "RXGMASK,RX Global Mask"
  bitfld.long  0x00 28.              "MI28       ,ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
  
  TEXTLINE "                "

  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"

TEXTLINE ""

group.long (0xFFFC0000+0x14)++0x03
  line.long    0x00 "RX14MASK,RX 14 Global Mask"
  bitfld.long  0x00 28.              "MI28       ,ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
  
  TEXTLINE "                "

  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""

group.long (0xFFFC0000+0x18)++0x03
  line.long    0x00 "RX15MASK,RX 15 Global Mask"
  bitfld.long  0x00 28.              "MI28       ,ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
  
  TEXTLINE "                "

  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""

group.long (0xFFFC0000+0x1C)++0x03
  line.long    0x00 "ECR,Error Counter Register"
  hexmask.byte 0x02 00.--07. 1.          "RXECTR ,Receive Error Counter"
  hexmask.byte 0x03 00.--07. 1.          "  TXECTR ,Transmit Error Counter"
TEXTLINE ""

group.long (0xFFFC0000+0x20)++0x03
  line.long    0x00 "ESR,Error and Status Register"
  bitfld.long  0x00 15.                  "BIT1ERR ,Bit 1 error" "0,1"
  bitfld.long  0x00 14.                  "  BIT0ERR ,Bit 0 error" "0,1"
  bitfld.long  0x00 13.                  "  ACKERR ,Acknowledge error." "0,1"
  bitfld.long  0x00 12.                  "   CRCERR   ,Cyclic redundancy code error" "0,1"
  bitfld.long  0x00 11.                  "  FRMERR ,Form error" "0,1"
  bitfld.long  0x00 10.                  "  STFERR ,Stuffing error" "0,1"
  bitfld.long  0x00 09.                  "  TXWRN  ,TX error counter" "0,1"
  TEXTLINE "                "
  bitfld.long  0x00 08.                  "  RXWRN   ,RX error counter" "0,1"
  bitfld.long  0x00 07.                  "  IDLE    ,CAN bus IDLE state" "0,1"
  bitfld.long  0x00 06.                  "  TXRX   ,Current FlexCAN2 status" "RX,TX"
  bitfld.long  0x00 04.--05.             "  FLTCONF  ,Fault confinement state" "err act,err pass,bus off,bus off"
  eventfld.long  0x00 02.                  "  BOFFINT   ,Bus off interrupt" "0,1"
  eventfld.long  0x00 01.                  "  ERRINT ,Error interrupt" "0,1"
TEXTLINE ""


group.long (0xFFFC0000+0x24)++0x03
  line.long    0x00 "IMRH,Interrupt masks high register"
  bitfld.long  0x00 31.              "BUF63-60 ,Message Buffer 63 mask" "0,1"
  bitfld.long  0x00 30.              ",Message Buffer 62 mask" "0,1"
  bitfld.long  0x00 29.              ",Message Buffer 61 mask" "0,1"
  bitfld.long  0x00 28.              ",Message Buffer 60 mask" "0,1"

  bitfld.long  0x00 27.              "  BUF59-56 ,Message Buffer 59 mask" "0,1"
  bitfld.long  0x00 26.              ",Message Buffer 58 mask" "0,1"
  bitfld.long  0x00 25.              ",Message Buffer 57 mask" "0,1"
  bitfld.long  0x00 24.              ",Message Buffer 56 mask" "0,1"

  bitfld.long  0x00 23.              "  BUF55-52 ,Message Buffer 55 mask" "0,1"
  bitfld.long  0x00 22.              ",Message Buffer 54 mask" "0,1"
  bitfld.long  0x00 21.              ",Message Buffer 53 mask" "0,1"
  bitfld.long  0x00 20.              ",Message Buffer 52 mask" "0,1"

  bitfld.long  0x00 19.              "  BUF51-48 ,Message Buffer 51 mask" "0,1"
  bitfld.long  0x00 18.              ",Message Buffer 50 mask" "0,1"
  bitfld.long  0x00 17.              ",Message Buffer 49 mask" "0,1"
  bitfld.long  0x00 16.              ",Message Buffer 48 mask" "0,1"
  
  TEXTLINE "                "

  bitfld.long  0x00 15.              "  BUF47-44 ,Message Buffer 47 mask" "0,1"
  bitfld.long  0x00 14.              ",Message Buffer 46 mask" "0,1"
  bitfld.long  0x00 13.              ",Message Buffer 45 mask" "0,1"
  bitfld.long  0x00 12.              ",Message Buffer 44 mask" "0,1"
  
  bitfld.long  0x00 11.              "  BUF43-40 ,Message Buffer 43 mask" "0,1"
  bitfld.long  0x00 10.              ",Message Buffer 42 mask" "0,1"
  bitfld.long  0x00 09.              ",Message Buffer 41 mask" "0,1"
  bitfld.long  0x00 08.              ",Message Buffer 40 mask" "0,1"
  
  bitfld.long  0x00 07.              "  BUF39-36 ,Message Buffer 39 mask" "0,1"
  bitfld.long  0x00 06.              ",Message Buffer 38 mask" "0,1"
  bitfld.long  0x00 05.              ",Message Buffer 37 mask" "0,1"
  bitfld.long  0x00 04.              ",Message Buffer 36 mask" "0,1"

  bitfld.long  0x00 03.              "  BUF35-32 ,Message Buffer 35 mask" "0,1"
  bitfld.long  0x00 02.              ",Message Buffer 34 mask" "0,1"
  bitfld.long  0x00 01.              ",Message Buffer 33 mask" "0,1"
  bitfld.long  0x00 00.              ",Message Buffer 32 mask" "0,1"
  
TEXTLINE ""

group.long (0xFFFC0000+0x28)++0x03
  line.long    0x00 "IMRL,Interrupt masks low register"
  bitfld.long  0x00 31.              "BUF31-28 ,Message Buffer 31 mask" "0,1"
  bitfld.long  0x00 30.              ",Message Buffer 30 mask" "0,1"
  bitfld.long  0x00 29.              ",Message Buffer 29 mask" "0,1"
  bitfld.long  0x00 28.              ",Message Buffer 28 mask" "0,1"

  bitfld.long  0x00 27.              "  BUF27-24 ,Message Buffer 27 mask" "0,1"
  bitfld.long  0x00 26.              ",Message Buffer 26 mask" "0,1"
  bitfld.long  0x00 25.              ",Message Buffer 25 mask" "0,1"
  bitfld.long  0x00 24.              ",Message Buffer 24 mask" "0,1"

  bitfld.long  0x00 23.              "  BUF23-20 ,Message Buffer 23 mask" "0,1"
  bitfld.long  0x00 22.              ",Message Buffer 22 mask" "0,1"
  bitfld.long  0x00 21.              ",Message Buffer 21 mask" "0,1"
  bitfld.long  0x00 20.              ",Message Buffer 20 mask" "0,1"

  bitfld.long  0x00 19.              "  BUF19-16 ,Message Buffer 19 mask" "0,1"
  bitfld.long  0x00 18.              ",Message Buffer 18 mask" "0,1"
  bitfld.long  0x00 17.              ",Message Buffer 17 mask" "0,1"
  bitfld.long  0x00 16.              ",Message Buffer 16 mask" "0,1"
  
  TEXTLINE "                "

  bitfld.long  0x00 15.              "  BUF15-12 ,Message Buffer 15 mask" "0,1"
  bitfld.long  0x00 14.              ",Message Buffer 14 mask" "0,1"
  bitfld.long  0x00 13.              ",Message Buffer 13 mask" "0,1"
  bitfld.long  0x00 12.              ",Message Buffer 12 mask" "0,1"
  
  bitfld.long  0x00 11.              "  BUF11-08 ,Message Buffer 11 mask" "0,1"
  bitfld.long  0x00 10.              ",Message Buffer 10 mask" "0,1"
  bitfld.long  0x00 09.              ",Message Buffer 09 mask" "0,1"
  bitfld.long  0x00 08.              ",Message Buffer 08 mask" "0,1"
  
  bitfld.long  0x00 07.              "  BUF07-04 ,Message Buffer 07 mask" "0,1"
  bitfld.long  0x00 06.              ",Message Buffer 06 mask" "0,1"
  bitfld.long  0x00 05.              ",Message Buffer 05 mask" "0,1"
  bitfld.long  0x00 04.              ",Message Buffer 04 mask" "0,1"

  bitfld.long  0x00 03.              "  BUF03-00 ,Message Buffer 03 mask" "0,1"
  bitfld.long  0x00 02.              ",Message Buffer 02 mask" "0,1"
  bitfld.long  0x00 01.              ",Message Buffer 01 mask" "0,1"
  bitfld.long  0x00 00.              ",Message Buffer 00 mask" "0,1"
  
TEXTLINE ""


group.long (0xFFFC0000+0x2C)++0x03
  line.long    0x00 "IFRH,Interrupt flags high register"
  eventfld.long  0x00 31.              "BUF63-60 ,Message Buffer 63 flag" "0,1"
  eventfld.long  0x00 30.              ",Message Buffer 62 flag" "0,1"
  eventfld.long  0x00 29.              ",Message Buffer 61 flag" "0,1"
  eventfld.long  0x00 28.              ",Message Buffer 60 flag" "0,1"

  eventfld.long  0x00 27.              "  BUF59-56 ,Message Buffer 59 flag" "0,1"
  eventfld.long  0x00 26.              ",Message Buffer 58 flag" "0,1"
  eventfld.long  0x00 25.              ",Message Buffer 57 flag" "0,1"
  eventfld.long  0x00 24.              ",Message Buffer 56 flag" "0,1"

  eventfld.long  0x00 23.              "  BUF55-52 ,Message Buffer 55 flag" "0,1"
  eventfld.long  0x00 22.              ",Message Buffer 54 flag" "0,1"
  eventfld.long  0x00 21.              ",Message Buffer 53 flag" "0,1"
  eventfld.long  0x00 20.              ",Message Buffer 52 flag" "0,1"

  eventfld.long  0x00 19.              "  BUF51-48 ,Message Buffer 51 flag" "0,1"
  eventfld.long  0x00 18.              ",Message Buffer 50 flag" "0,1"
  eventfld.long  0x00 17.              ",Message Buffer 49 flag" "0,1"
  eventfld.long  0x00 16.              ",Message Buffer 48 flag" "0,1"
  
  TEXTLINE "                "

  eventfld.long  0x00 15.              "  BUF47-44 ,Message Buffer 47 flag" "0,1"
  eventfld.long  0x00 14.              ",Message Buffer 46 flag" "0,1"
  eventfld.long  0x00 13.              ",Message Buffer 45 flag" "0,1"
  eventfld.long  0x00 12.              ",Message Buffer 44 flag" "0,1"
  
  eventfld.long  0x00 11.              "  BUF43-40 ,Message Buffer 43 flag" "0,1"
  eventfld.long  0x00 10.              ",Message Buffer 42 flag" "0,1"
  eventfld.long  0x00 09.              ",Message Buffer 41 flag" "0,1"
  eventfld.long  0x00 08.              ",Message Buffer 40 flag" "0,1"
  
  eventfld.long  0x00 07.              "  BUF39-36 ,Message Buffer 39 flag" "0,1"
  eventfld.long  0x00 06.              ",Message Buffer 38 flag" "0,1"
  eventfld.long  0x00 05.              ",Message Buffer 37 flag" "0,1"
  eventfld.long  0x00 04.              ",Message Buffer 36 flag" "0,1"

  eventfld.long  0x00 03.              "  BUF35-32 ,Message Buffer 35 flag" "0,1"
  eventfld.long  0x00 02.              ",Message Buffer 34 flag" "0,1"
  eventfld.long  0x00 01.              ",Message Buffer 33 flag" "0,1"
  eventfld.long  0x00 00.              ",Message Buffer 32 flag" "0,1"
  
TEXTLINE ""

group.long (0xFFFC0000+0x30)++0x03
  line.long    0x00 "IFRL,Interrupt flags low register"
  eventfld.long  0x00 31.              "BUF31-28 ,Message Buffer 31 flag" "0,1"
  eventfld.long  0x00 30.              ",Message Buffer 30 flag" "0,1"
  eventfld.long  0x00 29.              ",Message Buffer 29 flag" "0,1"
  eventfld.long  0x00 28.              ",Message Buffer 28 flag" "0,1"

  eventfld.long  0x00 27.              "  BUF27-24 ,Message Buffer 27 flag" "0,1"
  eventfld.long  0x00 26.              ",Message Buffer 26 flag" "0,1"
  eventfld.long  0x00 25.              ",Message Buffer 25 flag" "0,1"
  eventfld.long  0x00 24.              ",Message Buffer 24 flag" "0,1"

  eventfld.long  0x00 23.              "  BUF23-20 ,Message Buffer 23 flag" "0,1"
  eventfld.long  0x00 22.              ",Message Buffer 22 flag" "0,1"
  eventfld.long  0x00 21.              ",Message Buffer 21 flag" "0,1"
  eventfld.long  0x00 20.              ",Message Buffer 20 flag" "0,1"

  eventfld.long  0x00 19.              "  BUF19-16 ,Message Buffer 19 flag" "0,1"
  eventfld.long  0x00 18.              ",Message Buffer 18 flag" "0,1"
  eventfld.long  0x00 17.              ",Message Buffer 17 flag" "0,1"
  eventfld.long  0x00 16.              ",Message Buffer 16 flag" "0,1"
  
  TEXTLINE "                "

  eventfld.long  0x00 15.              "  BUF15-12 ,Message Buffer 15 flag" "0,1"
  eventfld.long  0x00 14.              ",Message Buffer 14 flag" "0,1"
  eventfld.long  0x00 13.              ",Message Buffer 13 flag" "0,1"
  eventfld.long  0x00 12.              ",Message Buffer 12 flag" "0,1"
  
  eventfld.long  0x00 11.              "  BUF11-08 ,Message Buffer 11 flag" "0,1"
  eventfld.long  0x00 10.              ",Message Buffer 10 flag" "0,1"
  eventfld.long  0x00 09.              ",Message Buffer 09 flag" "0,1"
  eventfld.long  0x00 08.              ",Message Buffer 08 flag" "0,1"
  
  eventfld.long  0x00 07.              "  BUF07-04 ,Message Buffer 07 flag" "0,1"
  eventfld.long  0x00 06.              ",Message Buffer 06 flag" "0,1"
  eventfld.long  0x00 05.              ",Message Buffer 05 flag" "0,1"
  eventfld.long  0x00 04.              ",Message Buffer 04 flag" "0,1"

  eventfld.long  0x00 03.              "  BUF03-00 ,Message Buffer 03 flag" "0,1"
  eventfld.long  0x00 02.              ",Message Buffer 02 flag" "0,1"
  eventfld.long  0x00 01.              ",Message Buffer 01 flag" "0,1"
  eventfld.long  0x00 00.              ",Message Buffer 00 flag" "0,1"
  
TEXTLINE ""


tree "Rx Individual Mask Registers"
group.long (0xFFFC0000+0x0880)++0x03
  line.long    0x00 "RXIMR00,Rx Individual Mask Register 00"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC0000+0x0884)++0x03
  line.long    0x00 "RXIMR01,Rx Individual Mask Register 01"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC0000+0x0888)++0x03
  line.long    0x00 "RXIMR02,Rx Individual Mask Register 02"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC0000+0x088c)++0x03
  line.long    0x00 "RXIMR03,Rx Individual Mask Register 03"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC0000+0x0890)++0x03
  line.long    0x00 "RXIMR04,Rx Individual Mask Register 04"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC0000+0x0894)++0x03
  line.long    0x00 "RXIMR05,Rx Individual Mask Register 05"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC0000+0x0898)++0x03
  line.long    0x00 "RXIMR06,Rx Individual Mask Register 06"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC0000+0x089c)++0x03
  line.long    0x00 "RXIMR07,Rx Individual Mask Register 07"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC0000+0x08a0)++0x03
  line.long    0x00 "RXIMR08,Rx Individual Mask Register 08"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC0000+0x08a4)++0x03
  line.long    0x00 "RXIMR09,Rx Individual Mask Register 09"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC0000+0x08a8)++0x03
  line.long    0x00 "RXIMR10,Rx Individual Mask Register 10"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC0000+0x08ac)++0x03
  line.long    0x00 "RXIMR11,Rx Individual Mask Register 11"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC0000+0x08b0)++0x03
  line.long    0x00 "RXIMR12,Rx Individual Mask Register 12"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC0000+0x08b4)++0x03
  line.long    0x00 "RXIMR13,Rx Individual Mask Register 13"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC0000+0x08b8)++0x03
  line.long    0x00 "RXIMR14,Rx Individual Mask Register 14"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC0000+0x08bc)++0x03
  line.long    0x00 "RXIMR15,Rx Individual Mask Register 15"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC0000+0x08c0)++0x03
  line.long    0x00 "RXIMR16,Rx Individual Mask Register 16"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC0000+0x08c4)++0x03
  line.long    0x00 "RXIMR17,Rx Individual Mask Register 17"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC0000+0x08c8)++0x03
  line.long    0x00 "RXIMR18,Rx Individual Mask Register 18"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC0000+0x08cc)++0x03
  line.long    0x00 "RXIMR19,Rx Individual Mask Register 19"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC0000+0x08d0)++0x03
  line.long    0x00 "RXIMR20,Rx Individual Mask Register 20"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC0000+0x08d4)++0x03
  line.long    0x00 "RXIMR21,Rx Individual Mask Register 21"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC0000+0x08d8)++0x03
  line.long    0x00 "RXIMR22,Rx Individual Mask Register 22"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC0000+0x08dc)++0x03
  line.long    0x00 "RXIMR23,Rx Individual Mask Register 23"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC0000+0x08e0)++0x03
  line.long    0x00 "RXIMR24,Rx Individual Mask Register 24"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC0000+0x08e4)++0x03
  line.long    0x00 "RXIMR25,Rx Individual Mask Register 25"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC0000+0x08e8)++0x03
  line.long    0x00 "RXIMR26,Rx Individual Mask Register 26"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC0000+0x08ec)++0x03
  line.long    0x00 "RXIMR27,Rx Individual Mask Register 27"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC0000+0x08f0)++0x03
  line.long    0x00 "RXIMR28,Rx Individual Mask Register 28"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC0000+0x08f4)++0x03
  line.long    0x00 "RXIMR29,Rx Individual Mask Register 29"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC0000+0x08f8)++0x03
  line.long    0x00 "RXIMR30,Rx Individual Mask Register 30"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC0000+0x08fc)++0x03
  line.long    0x00 "RXIMR31,Rx Individual Mask Register 31"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC0000+0x0900)++0x03
  line.long    0x00 "RXIMR32,Rx Individual Mask Register 32"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC0000+0x0904)++0x03
  line.long    0x00 "RXIMR33,Rx Individual Mask Register 33"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC0000+0x0908)++0x03
  line.long    0x00 "RXIMR34,Rx Individual Mask Register 34"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC0000+0x090c)++0x03
  line.long    0x00 "RXIMR35,Rx Individual Mask Register 35"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC0000+0x0910)++0x03
  line.long    0x00 "RXIMR36,Rx Individual Mask Register 36"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC0000+0x0914)++0x03
  line.long    0x00 "RXIMR37,Rx Individual Mask Register 37"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC0000+0x0918)++0x03
  line.long    0x00 "RXIMR38,Rx Individual Mask Register 38"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC0000+0x091c)++0x03
  line.long    0x00 "RXIMR39,Rx Individual Mask Register 39"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC0000+0x0920)++0x03
  line.long    0x00 "RXIMR30,Rx Individual Mask Register 30"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC0000+0x0924)++0x03
  line.long    0x00 "RXIMR41,Rx Individual Mask Register 41"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC0000+0x0928)++0x03
  line.long    0x00 "RXIMR42,Rx Individual Mask Register 42"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC0000+0x092c)++0x03
  line.long    0x00 "RXIMR43,Rx Individual Mask Register 43"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC0000+0x0930)++0x03
  line.long    0x00 "RXIMR44,Rx Individual Mask Register 44"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC0000+0x0934)++0x03
  line.long    0x00 "RXIMR45,Rx Individual Mask Register 45"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC0000+0x0938)++0x03
  line.long    0x00 "RXIMR46,Rx Individual Mask Register 46"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC0000+0x093c)++0x03
  line.long    0x00 "RXIMR47,Rx Individual Mask Register 47"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC0000+0x0940)++0x03
  line.long    0x00 "RXIMR48,Rx Individual Mask Register 48"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC0000+0x0944)++0x03
  line.long    0x00 "RXIMR49,Rx Individual Mask Register 49"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC0000+0x0948)++0x03
  line.long    0x00 "RXIMR50,Rx Individual Mask Register 50"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC0000+0x094c)++0x03
  line.long    0x00 "RXIMR51,Rx Individual Mask Register 51"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC0000+0x0950)++0x03
  line.long    0x00 "RXIMR52,Rx Individual Mask Register 52"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC0000+0x0954)++0x03
  line.long    0x00 "RXIMR53,Rx Individual Mask Register 53"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC0000+0x0958)++0x03
  line.long    0x00 "RXIMR54,Rx Individual Mask Register 54"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC0000+0x095c)++0x03
  line.long    0x00 "RXIMR55,Rx Individual Mask Register 55"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC0000+0x0960)++0x03
  line.long    0x00 "RXIMR56,Rx Individual Mask Register 56"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC0000+0x0964)++0x03
  line.long    0x00 "RXIMR57,Rx Individual Mask Register 57"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC0000+0x0968)++0x03
  line.long    0x00 "RXIMR58,Rx Individual Mask Register 58"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC0000+0x096c)++0x03
  line.long    0x00 "RXIMR59,Rx Individual Mask Register 59"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC0000+0x0970)++0x03
  line.long    0x00 "RXIMR60,Rx Individual Mask Register 60"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC0000+0x0974)++0x03
  line.long    0x00 "RXIMR61,Rx Individual Mask Register 61"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC0000+0x0978)++0x03
  line.long    0x00 "RXIMR62,Rx Individual Mask Register 62"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC0000+0x097c)++0x03
  line.long    0x00 "RXIMR63,Rx Individual Mask Register 63"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
tree.end 

tree "Message Buffers"


group.long (0xFFFC0000+128.)++0x03
  line.long    0x00 "MB0,Message Buffer 0"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC0000+128.)&0x00200000)==0x00200000
group.long ((0xFFFC0000+128.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 0"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC0000+128.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 0"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC0000+128.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 0"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 0"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC0000+144.)++0x03
  line.long    0x00 "MB1,Message Buffer 1"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC0000+144.)&0x00200000)==0x00200000
group.long ((0xFFFC0000+144.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 1"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC0000+144.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 1"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC0000+144.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 1"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 1"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC0000+160.)++0x03
  line.long    0x00 "MB2,Message Buffer 2"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC0000+160.)&0x00200000)==0x00200000
group.long ((0xFFFC0000+160.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 2"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC0000+160.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 2"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC0000+160.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 2"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 2"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC0000+176.)++0x03
  line.long    0x00 "MB3,Message Buffer 3"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC0000+176.)&0x00200000)==0x00200000
group.long ((0xFFFC0000+176.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 3"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC0000+176.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 3"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC0000+176.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 3"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 3"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC0000+192.)++0x03
  line.long    0x00 "MB4,Message Buffer 4"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC0000+192.)&0x00200000)==0x00200000
group.long ((0xFFFC0000+192.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 4"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC0000+192.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 4"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC0000+192.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 4"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 4"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC0000+208.)++0x03
  line.long    0x00 "MB5,Message Buffer 5"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC0000+208.)&0x00200000)==0x00200000
group.long ((0xFFFC0000+208.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 5"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC0000+208.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 5"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC0000+208.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 5"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 5"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC0000+224.)++0x03
  line.long    0x00 "MB6,Message Buffer 6"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC0000+224.)&0x00200000)==0x00200000
group.long ((0xFFFC0000+224.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 6"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC0000+224.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 6"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC0000+224.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 6"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 6"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC0000+240.)++0x03
  line.long    0x00 "MB7,Message Buffer 7"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC0000+240.)&0x00200000)==0x00200000
group.long ((0xFFFC0000+240.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 7"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC0000+240.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 7"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC0000+240.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 7"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 7"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC0000+256.)++0x03
  line.long    0x00 "MB8,Message Buffer 8"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC0000+256.)&0x00200000)==0x00200000
group.long ((0xFFFC0000+256.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 8"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC0000+256.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 8"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC0000+256.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 8"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 8"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC0000+272.)++0x03
  line.long    0x00 "MB9,Message Buffer 9"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC0000+272.)&0x00200000)==0x00200000
group.long ((0xFFFC0000+272.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 9"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC0000+272.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 9"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC0000+272.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 9"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 9"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC0000+288.)++0x03
  line.long    0x00 "MB10,Message Buffer 10"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC0000+288.)&0x00200000)==0x00200000
group.long ((0xFFFC0000+288.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 10"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC0000+288.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 10"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC0000+288.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 10"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 10"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC0000+304.)++0x03
  line.long    0x00 "MB11,Message Buffer 11"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC0000+304.)&0x00200000)==0x00200000
group.long ((0xFFFC0000+304.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 11"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC0000+304.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 11"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC0000+304.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 11"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 11"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC0000+320.)++0x03
  line.long    0x00 "MB12,Message Buffer 12"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC0000+320.)&0x00200000)==0x00200000
group.long ((0xFFFC0000+320.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 12"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC0000+320.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 12"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC0000+320.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 12"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 12"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC0000+336.)++0x03
  line.long    0x00 "MB13,Message Buffer 13"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC0000+336.)&0x00200000)==0x00200000
group.long ((0xFFFC0000+336.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 13"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC0000+336.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 13"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC0000+336.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 13"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 13"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC0000+352.)++0x03
  line.long    0x00 "MB14,Message Buffer 14"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC0000+352.)&0x00200000)==0x00200000
group.long ((0xFFFC0000+352.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 14"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC0000+352.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 14"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC0000+352.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 14"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 14"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC0000+368.)++0x03
  line.long    0x00 "MB15,Message Buffer 15"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC0000+368.)&0x00200000)==0x00200000
group.long ((0xFFFC0000+368.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 15"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC0000+368.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 15"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC0000+368.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 15"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 15"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC0000+384.)++0x03
  line.long    0x00 "MB16,Message Buffer 16"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC0000+384.)&0x00200000)==0x00200000
group.long ((0xFFFC0000+384.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 16"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC0000+384.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 16"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC0000+384.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 16"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 16"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC0000+400.)++0x03
  line.long    0x00 "MB17,Message Buffer 17"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC0000+400.)&0x00200000)==0x00200000
group.long ((0xFFFC0000+400.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 17"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC0000+400.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 17"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC0000+400.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 17"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 17"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC0000+416.)++0x03
  line.long    0x00 "MB18,Message Buffer 18"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC0000+416.)&0x00200000)==0x00200000
group.long ((0xFFFC0000+416.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 18"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC0000+416.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 18"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC0000+416.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 18"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 18"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC0000+432.)++0x03
  line.long    0x00 "MB19,Message Buffer 19"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC0000+432.)&0x00200000)==0x00200000
group.long ((0xFFFC0000+432.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 19"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC0000+432.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 19"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC0000+432.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 19"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 19"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC0000+448.)++0x03
  line.long    0x00 "MB20,Message Buffer 20"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC0000+448.)&0x00200000)==0x00200000
group.long ((0xFFFC0000+448.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 20"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC0000+448.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 20"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC0000+448.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 20"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 20"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC0000+464.)++0x03
  line.long    0x00 "MB21,Message Buffer 21"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC0000+464.)&0x00200000)==0x00200000
group.long ((0xFFFC0000+464.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 21"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC0000+464.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 21"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC0000+464.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 21"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 21"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC0000+480.)++0x03
  line.long    0x00 "MB22,Message Buffer 22"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC0000+480.)&0x00200000)==0x00200000
group.long ((0xFFFC0000+480.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 22"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC0000+480.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 22"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC0000+480.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 22"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 22"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC0000+496.)++0x03
  line.long    0x00 "MB23,Message Buffer 23"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC0000+496.)&0x00200000)==0x00200000
group.long ((0xFFFC0000+496.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 23"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC0000+496.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 23"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC0000+496.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 23"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 23"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC0000+512.)++0x03
  line.long    0x00 "MB24,Message Buffer 24"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC0000+512.)&0x00200000)==0x00200000
group.long ((0xFFFC0000+512.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 24"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC0000+512.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 24"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC0000+512.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 24"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 24"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC0000+528.)++0x03
  line.long    0x00 "MB25,Message Buffer 25"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC0000+528.)&0x00200000)==0x00200000
group.long ((0xFFFC0000+528.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 25"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC0000+528.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 25"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC0000+528.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 25"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 25"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC0000+544.)++0x03
  line.long    0x00 "MB26,Message Buffer 26"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC0000+544.)&0x00200000)==0x00200000
group.long ((0xFFFC0000+544.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 26"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC0000+544.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 26"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC0000+544.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 26"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 26"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC0000+560.)++0x03
  line.long    0x00 "MB27,Message Buffer 27"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC0000+560.)&0x00200000)==0x00200000
group.long ((0xFFFC0000+560.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 27"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC0000+560.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 27"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC0000+560.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 27"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 27"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC0000+576.)++0x03
  line.long    0x00 "MB28,Message Buffer 28"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC0000+576.)&0x00200000)==0x00200000
group.long ((0xFFFC0000+576.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 28"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC0000+576.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 28"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC0000+576.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 28"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 28"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC0000+592.)++0x03
  line.long    0x00 "MB29,Message Buffer 29"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC0000+592.)&0x00200000)==0x00200000
group.long ((0xFFFC0000+592.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 29"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC0000+592.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 29"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC0000+592.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 29"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 29"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC0000+608.)++0x03
  line.long    0x00 "MB30,Message Buffer 30"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC0000+608.)&0x00200000)==0x00200000
group.long ((0xFFFC0000+608.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 30"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC0000+608.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 30"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC0000+608.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 30"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 30"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC0000+624.)++0x03
  line.long    0x00 "MB31,Message Buffer 31"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC0000+624.)&0x00200000)==0x00200000
group.long ((0xFFFC0000+624.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 31"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC0000+624.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 31"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC0000+624.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 31"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 31"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC0000+640.)++0x03
  line.long    0x00 "MB32,Message Buffer 32"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC0000+640.)&0x00200000)==0x00200000
group.long ((0xFFFC0000+640.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 32"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC0000+640.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 32"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC0000+640.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 32"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 32"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC0000+656.)++0x03
  line.long    0x00 "MB33,Message Buffer 33"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC0000+656.)&0x00200000)==0x00200000
group.long ((0xFFFC0000+656.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 33"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC0000+656.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 33"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC0000+656.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 33"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 33"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC0000+672.)++0x03
  line.long    0x00 "MB34,Message Buffer 34"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC0000+672.)&0x00200000)==0x00200000
group.long ((0xFFFC0000+672.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 34"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC0000+672.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 34"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC0000+672.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 34"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 34"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC0000+688.)++0x03
  line.long    0x00 "MB35,Message Buffer 35"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC0000+688.)&0x00200000)==0x00200000
group.long ((0xFFFC0000+688.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 35"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC0000+688.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 35"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC0000+688.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 35"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 35"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC0000+704.)++0x03
  line.long    0x00 "MB36,Message Buffer 36"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC0000+704.)&0x00200000)==0x00200000
group.long ((0xFFFC0000+704.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 36"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC0000+704.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 36"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC0000+704.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 36"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 36"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC0000+720.)++0x03
  line.long    0x00 "MB37,Message Buffer 37"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC0000+720.)&0x00200000)==0x00200000
group.long ((0xFFFC0000+720.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 37"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC0000+720.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 37"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC0000+720.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 37"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 37"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC0000+736.)++0x03
  line.long    0x00 "MB38,Message Buffer 38"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC0000+736.)&0x00200000)==0x00200000
group.long ((0xFFFC0000+736.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 38"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC0000+736.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 38"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC0000+736.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 38"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 38"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC0000+752.)++0x03
  line.long    0x00 "MB39,Message Buffer 39"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC0000+752.)&0x00200000)==0x00200000
group.long ((0xFFFC0000+752.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 39"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC0000+752.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 39"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC0000+752.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 39"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 39"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC0000+768.)++0x03
  line.long    0x00 "MB40,Message Buffer 40"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC0000+768.)&0x00200000)==0x00200000
group.long ((0xFFFC0000+768.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 40"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC0000+768.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 40"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC0000+768.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 40"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 40"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC0000+784.)++0x03
  line.long    0x00 "MB41,Message Buffer 41"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC0000+784.)&0x00200000)==0x00200000
group.long ((0xFFFC0000+784.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 41"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC0000+784.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 41"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC0000+784.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 41"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 41"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC0000+800.)++0x03
  line.long    0x00 "MB42,Message Buffer 42"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC0000+800.)&0x00200000)==0x00200000
group.long ((0xFFFC0000+800.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 42"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC0000+800.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 42"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC0000+800.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 42"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 42"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC0000+816.)++0x03
  line.long    0x00 "MB43,Message Buffer 43"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC0000+816.)&0x00200000)==0x00200000
group.long ((0xFFFC0000+816.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 43"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC0000+816.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 43"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC0000+816.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 43"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 43"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC0000+832.)++0x03
  line.long    0x00 "MB44,Message Buffer 44"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC0000+832.)&0x00200000)==0x00200000
group.long ((0xFFFC0000+832.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 44"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC0000+832.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 44"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC0000+832.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 44"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 44"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC0000+848.)++0x03
  line.long    0x00 "MB45,Message Buffer 45"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC0000+848.)&0x00200000)==0x00200000
group.long ((0xFFFC0000+848.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 45"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC0000+848.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 45"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC0000+848.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 45"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 45"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC0000+864.)++0x03
  line.long    0x00 "MB46,Message Buffer 46"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC0000+864.)&0x00200000)==0x00200000
group.long ((0xFFFC0000+864.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 46"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC0000+864.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 46"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC0000+864.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 46"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 46"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC0000+880.)++0x03
  line.long    0x00 "MB47,Message Buffer 47"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC0000+880.)&0x00200000)==0x00200000
group.long ((0xFFFC0000+880.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 47"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC0000+880.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 47"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC0000+880.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 47"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 47"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC0000+896.)++0x03
  line.long    0x00 "MB48,Message Buffer 48"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC0000+896.)&0x00200000)==0x00200000
group.long ((0xFFFC0000+896.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 48"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC0000+896.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 48"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC0000+896.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 48"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 48"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC0000+912.)++0x03
  line.long    0x00 "MB49,Message Buffer 49"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC0000+912.)&0x00200000)==0x00200000
group.long ((0xFFFC0000+912.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 49"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC0000+912.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 49"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC0000+912.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 49"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 49"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC0000+928.)++0x03
  line.long    0x00 "MB50,Message Buffer 50"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC0000+928.)&0x00200000)==0x00200000
group.long ((0xFFFC0000+928.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 50"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC0000+928.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 50"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC0000+928.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 50"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 50"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC0000+944.)++0x03
  line.long    0x00 "MB51,Message Buffer 51"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC0000+944.)&0x00200000)==0x00200000
group.long ((0xFFFC0000+944.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 51"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC0000+944.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 51"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC0000+944.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 51"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 51"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC0000+960.)++0x03
  line.long    0x00 "MB52,Message Buffer 52"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC0000+960.)&0x00200000)==0x00200000
group.long ((0xFFFC0000+960.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 52"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC0000+960.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 52"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC0000+960.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 52"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 52"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC0000+976.)++0x03
  line.long    0x00 "MB53,Message Buffer 53"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC0000+976.)&0x00200000)==0x00200000
group.long ((0xFFFC0000+976.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 53"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC0000+976.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 53"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC0000+976.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 53"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 53"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC0000+992.)++0x03
  line.long    0x00 "MB54,Message Buffer 54"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC0000+992.)&0x00200000)==0x00200000
group.long ((0xFFFC0000+992.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 54"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC0000+992.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 54"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC0000+992.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 54"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 54"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC0000+1008.)++0x03
  line.long    0x00 "MB55,Message Buffer 55"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC0000+1008.)&0x00200000)==0x00200000
group.long ((0xFFFC0000+1008.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 55"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC0000+1008.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 55"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC0000+1008.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 55"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 55"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC0000+1024.)++0x03
  line.long    0x00 "MB56,Message Buffer 56"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC0000+1024.)&0x00200000)==0x00200000
group.long ((0xFFFC0000+1024.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 56"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC0000+1024.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 56"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC0000+1024.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 56"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 56"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC0000+1040.)++0x03
  line.long    0x00 "MB57,Message Buffer 57"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC0000+1040.)&0x00200000)==0x00200000
group.long ((0xFFFC0000+1040.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 57"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC0000+1040.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 57"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC0000+1040.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 57"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 57"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC0000+1056.)++0x03
  line.long    0x00 "MB58,Message Buffer 58"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC0000+1056.)&0x00200000)==0x00200000
group.long ((0xFFFC0000+1056.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 58"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC0000+1056.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 58"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC0000+1056.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 58"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 58"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC0000+1072.)++0x03
  line.long    0x00 "MB59,Message Buffer 59"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC0000+1072.)&0x00200000)==0x00200000
group.long ((0xFFFC0000+1072.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 59"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC0000+1072.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 59"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC0000+1072.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 59"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 59"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC0000+1088.)++0x03
  line.long    0x00 "MB60,Message Buffer 60"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC0000+1088.)&0x00200000)==0x00200000
group.long ((0xFFFC0000+1088.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 60"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC0000+1088.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 60"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC0000+1088.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 60"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 60"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC0000+1104.)++0x03
  line.long    0x00 "MB61,Message Buffer 61"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC0000+1104.)&0x00200000)==0x00200000
group.long ((0xFFFC0000+1104.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 61"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC0000+1104.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 61"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC0000+1104.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 61"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 61"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC0000+1120.)++0x03
  line.long    0x00 "MB62,Message Buffer 62"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC0000+1120.)&0x00200000)==0x00200000
group.long ((0xFFFC0000+1120.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 62"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC0000+1120.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 62"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC0000+1120.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 62"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 62"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC0000+1136.)++0x03
  line.long    0x00 "MB63,Message Buffer 63"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC0000+1136.)&0x00200000)==0x00200000
group.long ((0xFFFC0000+1136.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 63"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC0000+1136.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 63"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC0000+1136.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 63"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 63"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""
tree.end


tree.end


sif (cpu()=="MPC5554")||(cpu()=="MPC5565")||(cpu()=="MPC5566")||(cpu()=="MPC5567")||(CPUIS("MPC5674*"))

tree "FlexCAN B"

group.long 0xFFFC4000++0x03
  line.long    0x00 "MCR,Module Configuration Register"
  bitfld.long  0x00 31.                  "MDIS     ,Module disable" "0,1"
  bitfld.long  0x00 30.                  "  FRZ ,Freeze enable" "0,1"
  bitfld.long  0x00 28.                  "      HALT    ,Halt FlexCAN" "0,1"
  bitfld.long  0x00 27.                  "    NOTRDY ,FlexCAN2 not ready" "0,1"
  bitfld.long  0x00 25.                  "  SOFTRST ,Soft reset" "0,1"
  bitfld.long  0x00 24.                  "  FRZACK ,Freeze mode acknowledge" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 21.                  "  WRNEN    ,Warning interrupt enable" "0,1"
  bitfld.long  0x00 20.                  "  MDISACK ,Low power mode acknowledge" "0,1"
  bitfld.long  0x00 17.                  "  SRXDIS  ,This bit defines whether FlexCAN is allowed to receive frames transmitted by itself" "0,1"
  bitfld.long  0x00 16.                  "    MBFEN  ,Message buffer filter enable" "0,1"
  hexmask.byte 0x03 00.--06. 1.          "  MAXMB  ,Maximum number of message buffers"
TEXTLINE ""
 

group.long (0xFFFC4000+0x04)++0x03
  line.long    0x00 "CR,Control Register"
  hexmask.byte 0x00 00.--07. 1.          "PRESDIV ,Prescaler division factor"
  bitfld.long  0x00 22.--23.             "  RJW ,Resync jump width" "0,1,2,3"
  bitfld.long  0x00 19.--21.             "      PSEG1   ,Phase segment 1" "0,1,2,3,4,5,6,7"
  bitfld.long  0x00 16.--18.             "    PSEG2  ,Phase segment 2" "0,1,2,3,4,5,6,7"
  bitfld.long  0x00 15.                  "  BOFFMSK ,Bus off mask" "0,1"
  bitfld.long  0x00 14.                  "  ERRMSK ,Error mask" "0,1"
  bitfld.long  0x00 13.                  "  CLK_SRC ,CAN engine clock source" "osc_clk,bus_clk"
TEXTLINE "                "
  bitfld.long  0x00 12.                  "  LPB      ,Loop back" "0,1"
  bitfld.long  0x00 07.                  "  SMP ,Sampling mode" "one,three"
  bitfld.long  0x00 06.                  "  BOFFREC ,Bus off recovery mode" "ena,dis"
  bitfld.long  0x00 05.                  "  TSYN   ,Timer sync mode" "0,1"
  bitfld.long  0x00 04.                  "  LBUF    ,Lowest buffer transmitted first" "0,1"
  bitfld.long  0x00 03.                  "  LOM    ,Listen-only mode" "0,1"
  bitfld.long  0x00 00.--02.             "  PROPSEG ,Propagation segment" "0,1,2,3,4,5,6,7"
TEXTLINE ""

group.long (0xFFFC4000+0x08)++0x03
  line.long    0x00 "TIMER,Free Running Timer"
TEXTLINE ""

group.long (0xFFFC4000+0x10)++0x03
  line.long    0x00 "RXGMASK,RX Global Mask"
  bitfld.long  0x00 28.              "MI28       ,ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
  
  TEXTLINE "                "

  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"

TEXTLINE ""

group.long (0xFFFC4000+0x14)++0x03
  line.long    0x00 "RX14MASK,RX 14 Global Mask"
  bitfld.long  0x00 28.              "MI28       ,ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
  
  TEXTLINE "                "

  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""

group.long (0xFFFC4000+0x18)++0x03
  line.long    0x00 "RX15MASK,RX 15 Global Mask"
  bitfld.long  0x00 28.              "MI28       ,ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
  
  TEXTLINE "                "

  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""

group.long (0xFFFC4000+0x1C)++0x03
  line.long    0x00 "ECR,Error Counter Register"
  hexmask.byte 0x02 00.--07. 1.          "RXECTR ,Receive Error Counter"
  hexmask.byte 0x03 00.--07. 1.          "  TXECTR ,Transmit Error Counter"
TEXTLINE ""

group.long (0xFFFC4000+0x20)++0x03
  line.long    0x00 "ESR,Error and Status Register"
  bitfld.long  0x00 15.                  "BIT1ERR ,Bit 1 error" "0,1"
  bitfld.long  0x00 14.                  "  BIT0ERR ,Bit 0 error" "0,1"
  bitfld.long  0x00 13.                  "  ACKERR ,Acknowledge error." "0,1"
  bitfld.long  0x00 12.                  "   CRCERR   ,Cyclic redundancy code error" "0,1"
  bitfld.long  0x00 11.                  "  FRMERR ,Form error" "0,1"
  bitfld.long  0x00 10.                  "  STFERR ,Stuffing error" "0,1"
  bitfld.long  0x00 09.                  "  TXWRN  ,TX error counter" "0,1"
  TEXTLINE "                "
  bitfld.long  0x00 08.                  "  RXWRN   ,RX error counter" "0,1"
  bitfld.long  0x00 07.                  "  IDLE    ,CAN bus IDLE state" "0,1"
  bitfld.long  0x00 06.                  "  TXRX   ,Current FlexCAN2 status" "RX,TX"
  bitfld.long  0x00 04.--05.             "  FLTCONF  ,Fault confinement state" "err act,err pass,bus off,bus off"
  eventfld.long  0x00 02.                  "  BOFFINT   ,Bus off interrupt" "0,1"
  eventfld.long  0x00 01.                  "  ERRINT ,Error interrupt" "0,1"
TEXTLINE ""


group.long (0xFFFC4000+0x24)++0x03
  line.long    0x00 "IMRH,Interrupt masks high register"
  bitfld.long  0x00 31.              "BUF63-60 ,Message Buffer 63 mask" "0,1"
  bitfld.long  0x00 30.              ",Message Buffer 62 mask" "0,1"
  bitfld.long  0x00 29.              ",Message Buffer 61 mask" "0,1"
  bitfld.long  0x00 28.              ",Message Buffer 60 mask" "0,1"

  bitfld.long  0x00 27.              "  BUF59-56 ,Message Buffer 59 mask" "0,1"
  bitfld.long  0x00 26.              ",Message Buffer 58 mask" "0,1"
  bitfld.long  0x00 25.              ",Message Buffer 57 mask" "0,1"
  bitfld.long  0x00 24.              ",Message Buffer 56 mask" "0,1"

  bitfld.long  0x00 23.              "  BUF55-52 ,Message Buffer 55 mask" "0,1"
  bitfld.long  0x00 22.              ",Message Buffer 54 mask" "0,1"
  bitfld.long  0x00 21.              ",Message Buffer 53 mask" "0,1"
  bitfld.long  0x00 20.              ",Message Buffer 52 mask" "0,1"

  bitfld.long  0x00 19.              "  BUF51-48 ,Message Buffer 51 mask" "0,1"
  bitfld.long  0x00 18.              ",Message Buffer 50 mask" "0,1"
  bitfld.long  0x00 17.              ",Message Buffer 49 mask" "0,1"
  bitfld.long  0x00 16.              ",Message Buffer 48 mask" "0,1"
  
  TEXTLINE "                "

  bitfld.long  0x00 15.              "  BUF47-44 ,Message Buffer 47 mask" "0,1"
  bitfld.long  0x00 14.              ",Message Buffer 46 mask" "0,1"
  bitfld.long  0x00 13.              ",Message Buffer 45 mask" "0,1"
  bitfld.long  0x00 12.              ",Message Buffer 44 mask" "0,1"
  
  bitfld.long  0x00 11.              "  BUF43-40 ,Message Buffer 43 mask" "0,1"
  bitfld.long  0x00 10.              ",Message Buffer 42 mask" "0,1"
  bitfld.long  0x00 09.              ",Message Buffer 41 mask" "0,1"
  bitfld.long  0x00 08.              ",Message Buffer 40 mask" "0,1"
  
  bitfld.long  0x00 07.              "  BUF39-36 ,Message Buffer 39 mask" "0,1"
  bitfld.long  0x00 06.              ",Message Buffer 38 mask" "0,1"
  bitfld.long  0x00 05.              ",Message Buffer 37 mask" "0,1"
  bitfld.long  0x00 04.              ",Message Buffer 36 mask" "0,1"

  bitfld.long  0x00 03.              "  BUF35-32 ,Message Buffer 35 mask" "0,1"
  bitfld.long  0x00 02.              ",Message Buffer 34 mask" "0,1"
  bitfld.long  0x00 01.              ",Message Buffer 33 mask" "0,1"
  bitfld.long  0x00 00.              ",Message Buffer 32 mask" "0,1"
  
TEXTLINE ""

group.long (0xFFFC4000+0x28)++0x03
  line.long    0x00 "IMRL,Interrupt masks low register"
  bitfld.long  0x00 31.              "BUF31-28 ,Message Buffer 31 mask" "0,1"
  bitfld.long  0x00 30.              ",Message Buffer 30 mask" "0,1"
  bitfld.long  0x00 29.              ",Message Buffer 29 mask" "0,1"
  bitfld.long  0x00 28.              ",Message Buffer 28 mask" "0,1"

  bitfld.long  0x00 27.              "  BUF27-24 ,Message Buffer 27 mask" "0,1"
  bitfld.long  0x00 26.              ",Message Buffer 26 mask" "0,1"
  bitfld.long  0x00 25.              ",Message Buffer 25 mask" "0,1"
  bitfld.long  0x00 24.              ",Message Buffer 24 mask" "0,1"

  bitfld.long  0x00 23.              "  BUF23-20 ,Message Buffer 23 mask" "0,1"
  bitfld.long  0x00 22.              ",Message Buffer 22 mask" "0,1"
  bitfld.long  0x00 21.              ",Message Buffer 21 mask" "0,1"
  bitfld.long  0x00 20.              ",Message Buffer 20 mask" "0,1"

  bitfld.long  0x00 19.              "  BUF19-16 ,Message Buffer 19 mask" "0,1"
  bitfld.long  0x00 18.              ",Message Buffer 18 mask" "0,1"
  bitfld.long  0x00 17.              ",Message Buffer 17 mask" "0,1"
  bitfld.long  0x00 16.              ",Message Buffer 16 mask" "0,1"
  
  TEXTLINE "                "

  bitfld.long  0x00 15.              "  BUF15-12 ,Message Buffer 15 mask" "0,1"
  bitfld.long  0x00 14.              ",Message Buffer 14 mask" "0,1"
  bitfld.long  0x00 13.              ",Message Buffer 13 mask" "0,1"
  bitfld.long  0x00 12.              ",Message Buffer 12 mask" "0,1"
  
  bitfld.long  0x00 11.              "  BUF11-08 ,Message Buffer 11 mask" "0,1"
  bitfld.long  0x00 10.              ",Message Buffer 10 mask" "0,1"
  bitfld.long  0x00 09.              ",Message Buffer 09 mask" "0,1"
  bitfld.long  0x00 08.              ",Message Buffer 08 mask" "0,1"
  
  bitfld.long  0x00 07.              "  BUF07-04 ,Message Buffer 07 mask" "0,1"
  bitfld.long  0x00 06.              ",Message Buffer 06 mask" "0,1"
  bitfld.long  0x00 05.              ",Message Buffer 05 mask" "0,1"
  bitfld.long  0x00 04.              ",Message Buffer 04 mask" "0,1"

  bitfld.long  0x00 03.              "  BUF03-00 ,Message Buffer 03 mask" "0,1"
  bitfld.long  0x00 02.              ",Message Buffer 02 mask" "0,1"
  bitfld.long  0x00 01.              ",Message Buffer 01 mask" "0,1"
  bitfld.long  0x00 00.              ",Message Buffer 00 mask" "0,1"
  
TEXTLINE ""


group.long (0xFFFC4000+0x2C)++0x03
  line.long    0x00 "IFRH,Interrupt flags high register"
  eventfld.long  0x00 31.              "BUF63-60 ,Message Buffer 63 flag" "0,1"
  eventfld.long  0x00 30.              ",Message Buffer 62 flag" "0,1"
  eventfld.long  0x00 29.              ",Message Buffer 61 flag" "0,1"
  eventfld.long  0x00 28.              ",Message Buffer 60 flag" "0,1"

  eventfld.long  0x00 27.              "  BUF59-56 ,Message Buffer 59 flag" "0,1"
  eventfld.long  0x00 26.              ",Message Buffer 58 flag" "0,1"
  eventfld.long  0x00 25.              ",Message Buffer 57 flag" "0,1"
  eventfld.long  0x00 24.              ",Message Buffer 56 flag" "0,1"

  eventfld.long  0x00 23.              "  BUF55-52 ,Message Buffer 55 flag" "0,1"
  eventfld.long  0x00 22.              ",Message Buffer 54 flag" "0,1"
  eventfld.long  0x00 21.              ",Message Buffer 53 flag" "0,1"
  eventfld.long  0x00 20.              ",Message Buffer 52 flag" "0,1"

  eventfld.long  0x00 19.              "  BUF51-48 ,Message Buffer 51 flag" "0,1"
  eventfld.long  0x00 18.              ",Message Buffer 50 flag" "0,1"
  eventfld.long  0x00 17.              ",Message Buffer 49 flag" "0,1"
  eventfld.long  0x00 16.              ",Message Buffer 48 flag" "0,1"
  
  TEXTLINE "                "

  eventfld.long  0x00 15.              "  BUF47-44 ,Message Buffer 47 flag" "0,1"
  eventfld.long  0x00 14.              ",Message Buffer 46 flag" "0,1"
  eventfld.long  0x00 13.              ",Message Buffer 45 flag" "0,1"
  eventfld.long  0x00 12.              ",Message Buffer 44 flag" "0,1"
  
  eventfld.long  0x00 11.              "  BUF43-40 ,Message Buffer 43 flag" "0,1"
  eventfld.long  0x00 10.              ",Message Buffer 42 flag" "0,1"
  eventfld.long  0x00 09.              ",Message Buffer 41 flag" "0,1"
  eventfld.long  0x00 08.              ",Message Buffer 40 flag" "0,1"
  
  eventfld.long  0x00 07.              "  BUF39-36 ,Message Buffer 39 flag" "0,1"
  eventfld.long  0x00 06.              ",Message Buffer 38 flag" "0,1"
  eventfld.long  0x00 05.              ",Message Buffer 37 flag" "0,1"
  eventfld.long  0x00 04.              ",Message Buffer 36 flag" "0,1"

  eventfld.long  0x00 03.              "  BUF35-32 ,Message Buffer 35 flag" "0,1"
  eventfld.long  0x00 02.              ",Message Buffer 34 flag" "0,1"
  eventfld.long  0x00 01.              ",Message Buffer 33 flag" "0,1"
  eventfld.long  0x00 00.              ",Message Buffer 32 flag" "0,1"
  
TEXTLINE ""

group.long (0xFFFC4000+0x30)++0x03
  line.long    0x00 "IFRL,Interrupt flags low register"
  eventfld.long  0x00 31.              "BUF31-28 ,Message Buffer 31 flag" "0,1"
  eventfld.long  0x00 30.              ",Message Buffer 30 flag" "0,1"
  eventfld.long  0x00 29.              ",Message Buffer 29 flag" "0,1"
  eventfld.long  0x00 28.              ",Message Buffer 28 flag" "0,1"

  eventfld.long  0x00 27.              "  BUF27-24 ,Message Buffer 27 flag" "0,1"
  eventfld.long  0x00 26.              ",Message Buffer 26 flag" "0,1"
  eventfld.long  0x00 25.              ",Message Buffer 25 flag" "0,1"
  eventfld.long  0x00 24.              ",Message Buffer 24 flag" "0,1"

  eventfld.long  0x00 23.              "  BUF23-20 ,Message Buffer 23 flag" "0,1"
  eventfld.long  0x00 22.              ",Message Buffer 22 flag" "0,1"
  eventfld.long  0x00 21.              ",Message Buffer 21 flag" "0,1"
  eventfld.long  0x00 20.              ",Message Buffer 20 flag" "0,1"

  eventfld.long  0x00 19.              "  BUF19-16 ,Message Buffer 19 flag" "0,1"
  eventfld.long  0x00 18.              ",Message Buffer 18 flag" "0,1"
  eventfld.long  0x00 17.              ",Message Buffer 17 flag" "0,1"
  eventfld.long  0x00 16.              ",Message Buffer 16 flag" "0,1"
  
  TEXTLINE "                "

  eventfld.long  0x00 15.              "  BUF15-12 ,Message Buffer 15 flag" "0,1"
  eventfld.long  0x00 14.              ",Message Buffer 14 flag" "0,1"
  eventfld.long  0x00 13.              ",Message Buffer 13 flag" "0,1"
  eventfld.long  0x00 12.              ",Message Buffer 12 flag" "0,1"
  
  eventfld.long  0x00 11.              "  BUF11-08 ,Message Buffer 11 flag" "0,1"
  eventfld.long  0x00 10.              ",Message Buffer 10 flag" "0,1"
  eventfld.long  0x00 09.              ",Message Buffer 09 flag" "0,1"
  eventfld.long  0x00 08.              ",Message Buffer 08 flag" "0,1"
  
  eventfld.long  0x00 07.              "  BUF07-04 ,Message Buffer 07 flag" "0,1"
  eventfld.long  0x00 06.              ",Message Buffer 06 flag" "0,1"
  eventfld.long  0x00 05.              ",Message Buffer 05 flag" "0,1"
  eventfld.long  0x00 04.              ",Message Buffer 04 flag" "0,1"

  eventfld.long  0x00 03.              "  BUF03-00 ,Message Buffer 03 flag" "0,1"
  eventfld.long  0x00 02.              ",Message Buffer 02 flag" "0,1"
  eventfld.long  0x00 01.              ",Message Buffer 01 flag" "0,1"
  eventfld.long  0x00 00.              ",Message Buffer 00 flag" "0,1"
  
TEXTLINE ""


tree "Rx Individual Mask Registers"
group.long (0xFFFC4000+0x0880)++0x03
  line.long    0x00 "RXIMR00,Rx Individual Mask Register 00"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC4000+0x0884)++0x03
  line.long    0x00 "RXIMR01,Rx Individual Mask Register 01"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC4000+0x0888)++0x03
  line.long    0x00 "RXIMR02,Rx Individual Mask Register 02"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC4000+0x088c)++0x03
  line.long    0x00 "RXIMR03,Rx Individual Mask Register 03"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC4000+0x0890)++0x03
  line.long    0x00 "RXIMR04,Rx Individual Mask Register 04"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC4000+0x0894)++0x03
  line.long    0x00 "RXIMR05,Rx Individual Mask Register 05"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC4000+0x0898)++0x03
  line.long    0x00 "RXIMR06,Rx Individual Mask Register 06"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC4000+0x089c)++0x03
  line.long    0x00 "RXIMR07,Rx Individual Mask Register 07"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC4000+0x08a0)++0x03
  line.long    0x00 "RXIMR08,Rx Individual Mask Register 08"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC4000+0x08a4)++0x03
  line.long    0x00 "RXIMR09,Rx Individual Mask Register 09"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC4000+0x08a8)++0x03
  line.long    0x00 "RXIMR10,Rx Individual Mask Register 10"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC4000+0x08ac)++0x03
  line.long    0x00 "RXIMR11,Rx Individual Mask Register 11"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC4000+0x08b0)++0x03
  line.long    0x00 "RXIMR12,Rx Individual Mask Register 12"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC4000+0x08b4)++0x03
  line.long    0x00 "RXIMR13,Rx Individual Mask Register 13"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC4000+0x08b8)++0x03
  line.long    0x00 "RXIMR14,Rx Individual Mask Register 14"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC4000+0x08bc)++0x03
  line.long    0x00 "RXIMR15,Rx Individual Mask Register 15"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC4000+0x08c0)++0x03
  line.long    0x00 "RXIMR16,Rx Individual Mask Register 16"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC4000+0x08c4)++0x03
  line.long    0x00 "RXIMR17,Rx Individual Mask Register 17"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC4000+0x08c8)++0x03
  line.long    0x00 "RXIMR18,Rx Individual Mask Register 18"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC4000+0x08cc)++0x03
  line.long    0x00 "RXIMR19,Rx Individual Mask Register 19"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC4000+0x08d0)++0x03
  line.long    0x00 "RXIMR20,Rx Individual Mask Register 20"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC4000+0x08d4)++0x03
  line.long    0x00 "RXIMR21,Rx Individual Mask Register 21"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC4000+0x08d8)++0x03
  line.long    0x00 "RXIMR22,Rx Individual Mask Register 22"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC4000+0x08dc)++0x03
  line.long    0x00 "RXIMR23,Rx Individual Mask Register 23"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC4000+0x08e0)++0x03
  line.long    0x00 "RXIMR24,Rx Individual Mask Register 24"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC4000+0x08e4)++0x03
  line.long    0x00 "RXIMR25,Rx Individual Mask Register 25"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC4000+0x08e8)++0x03
  line.long    0x00 "RXIMR26,Rx Individual Mask Register 26"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC4000+0x08ec)++0x03
  line.long    0x00 "RXIMR27,Rx Individual Mask Register 27"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC4000+0x08f0)++0x03
  line.long    0x00 "RXIMR28,Rx Individual Mask Register 28"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC4000+0x08f4)++0x03
  line.long    0x00 "RXIMR29,Rx Individual Mask Register 29"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC4000+0x08f8)++0x03
  line.long    0x00 "RXIMR30,Rx Individual Mask Register 30"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC4000+0x08fc)++0x03
  line.long    0x00 "RXIMR31,Rx Individual Mask Register 31"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC4000+0x0900)++0x03
  line.long    0x00 "RXIMR32,Rx Individual Mask Register 32"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC4000+0x0904)++0x03
  line.long    0x00 "RXIMR33,Rx Individual Mask Register 33"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC4000+0x0908)++0x03
  line.long    0x00 "RXIMR34,Rx Individual Mask Register 34"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC4000+0x090c)++0x03
  line.long    0x00 "RXIMR35,Rx Individual Mask Register 35"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC4000+0x0910)++0x03
  line.long    0x00 "RXIMR36,Rx Individual Mask Register 36"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC4000+0x0914)++0x03
  line.long    0x00 "RXIMR37,Rx Individual Mask Register 37"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC4000+0x0918)++0x03
  line.long    0x00 "RXIMR38,Rx Individual Mask Register 38"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC4000+0x091c)++0x03
  line.long    0x00 "RXIMR39,Rx Individual Mask Register 39"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC4000+0x0920)++0x03
  line.long    0x00 "RXIMR30,Rx Individual Mask Register 30"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC4000+0x0924)++0x03
  line.long    0x00 "RXIMR41,Rx Individual Mask Register 41"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC4000+0x0928)++0x03
  line.long    0x00 "RXIMR42,Rx Individual Mask Register 42"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC4000+0x092c)++0x03
  line.long    0x00 "RXIMR43,Rx Individual Mask Register 43"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC4000+0x0930)++0x03
  line.long    0x00 "RXIMR44,Rx Individual Mask Register 44"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC4000+0x0934)++0x03
  line.long    0x00 "RXIMR45,Rx Individual Mask Register 45"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC4000+0x0938)++0x03
  line.long    0x00 "RXIMR46,Rx Individual Mask Register 46"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC4000+0x093c)++0x03
  line.long    0x00 "RXIMR47,Rx Individual Mask Register 47"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC4000+0x0940)++0x03
  line.long    0x00 "RXIMR48,Rx Individual Mask Register 48"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC4000+0x0944)++0x03
  line.long    0x00 "RXIMR49,Rx Individual Mask Register 49"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC4000+0x0948)++0x03
  line.long    0x00 "RXIMR50,Rx Individual Mask Register 50"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC4000+0x094c)++0x03
  line.long    0x00 "RXIMR51,Rx Individual Mask Register 51"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC4000+0x0950)++0x03
  line.long    0x00 "RXIMR52,Rx Individual Mask Register 52"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC4000+0x0954)++0x03
  line.long    0x00 "RXIMR53,Rx Individual Mask Register 53"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC4000+0x0958)++0x03
  line.long    0x00 "RXIMR54,Rx Individual Mask Register 54"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC4000+0x095c)++0x03
  line.long    0x00 "RXIMR55,Rx Individual Mask Register 55"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC4000+0x0960)++0x03
  line.long    0x00 "RXIMR56,Rx Individual Mask Register 56"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC4000+0x0964)++0x03
  line.long    0x00 "RXIMR57,Rx Individual Mask Register 57"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC4000+0x0968)++0x03
  line.long    0x00 "RXIMR58,Rx Individual Mask Register 58"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC4000+0x096c)++0x03
  line.long    0x00 "RXIMR59,Rx Individual Mask Register 59"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC4000+0x0970)++0x03
  line.long    0x00 "RXIMR60,Rx Individual Mask Register 60"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC4000+0x0974)++0x03
  line.long    0x00 "RXIMR61,Rx Individual Mask Register 61"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC4000+0x0978)++0x03
  line.long    0x00 "RXIMR62,Rx Individual Mask Register 62"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC4000+0x097c)++0x03
  line.long    0x00 "RXIMR63,Rx Individual Mask Register 63"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
tree.end 

tree "Message Buffers"


group.long (0xFFFC4000+128.)++0x03
  line.long    0x00 "MB0,Message Buffer 0"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC4000+128.)&0x00200000)==0x00200000
group.long ((0xFFFC4000+128.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 0"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC4000+128.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 0"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC4000+128.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 0"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 0"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC4000+144.)++0x03
  line.long    0x00 "MB1,Message Buffer 1"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC4000+144.)&0x00200000)==0x00200000
group.long ((0xFFFC4000+144.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 1"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC4000+144.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 1"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC4000+144.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 1"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 1"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC4000+160.)++0x03
  line.long    0x00 "MB2,Message Buffer 2"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC4000+160.)&0x00200000)==0x00200000
group.long ((0xFFFC4000+160.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 2"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC4000+160.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 2"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC4000+160.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 2"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 2"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC4000+176.)++0x03
  line.long    0x00 "MB3,Message Buffer 3"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC4000+176.)&0x00200000)==0x00200000
group.long ((0xFFFC4000+176.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 3"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC4000+176.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 3"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC4000+176.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 3"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 3"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC4000+192.)++0x03
  line.long    0x00 "MB4,Message Buffer 4"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC4000+192.)&0x00200000)==0x00200000
group.long ((0xFFFC4000+192.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 4"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC4000+192.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 4"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC4000+192.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 4"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 4"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC4000+208.)++0x03
  line.long    0x00 "MB5,Message Buffer 5"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC4000+208.)&0x00200000)==0x00200000
group.long ((0xFFFC4000+208.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 5"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC4000+208.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 5"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC4000+208.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 5"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 5"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC4000+224.)++0x03
  line.long    0x00 "MB6,Message Buffer 6"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC4000+224.)&0x00200000)==0x00200000
group.long ((0xFFFC4000+224.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 6"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC4000+224.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 6"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC4000+224.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 6"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 6"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC4000+240.)++0x03
  line.long    0x00 "MB7,Message Buffer 7"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC4000+240.)&0x00200000)==0x00200000
group.long ((0xFFFC4000+240.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 7"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC4000+240.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 7"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC4000+240.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 7"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 7"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC4000+256.)++0x03
  line.long    0x00 "MB8,Message Buffer 8"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC4000+256.)&0x00200000)==0x00200000
group.long ((0xFFFC4000+256.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 8"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC4000+256.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 8"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC4000+256.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 8"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 8"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC4000+272.)++0x03
  line.long    0x00 "MB9,Message Buffer 9"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC4000+272.)&0x00200000)==0x00200000
group.long ((0xFFFC4000+272.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 9"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC4000+272.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 9"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC4000+272.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 9"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 9"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC4000+288.)++0x03
  line.long    0x00 "MB10,Message Buffer 10"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC4000+288.)&0x00200000)==0x00200000
group.long ((0xFFFC4000+288.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 10"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC4000+288.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 10"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC4000+288.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 10"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 10"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC4000+304.)++0x03
  line.long    0x00 "MB11,Message Buffer 11"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC4000+304.)&0x00200000)==0x00200000
group.long ((0xFFFC4000+304.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 11"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC4000+304.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 11"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC4000+304.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 11"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 11"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC4000+320.)++0x03
  line.long    0x00 "MB12,Message Buffer 12"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC4000+320.)&0x00200000)==0x00200000
group.long ((0xFFFC4000+320.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 12"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC4000+320.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 12"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC4000+320.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 12"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 12"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC4000+336.)++0x03
  line.long    0x00 "MB13,Message Buffer 13"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC4000+336.)&0x00200000)==0x00200000
group.long ((0xFFFC4000+336.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 13"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC4000+336.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 13"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC4000+336.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 13"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 13"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC4000+352.)++0x03
  line.long    0x00 "MB14,Message Buffer 14"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC4000+352.)&0x00200000)==0x00200000
group.long ((0xFFFC4000+352.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 14"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC4000+352.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 14"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC4000+352.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 14"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 14"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC4000+368.)++0x03
  line.long    0x00 "MB15,Message Buffer 15"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC4000+368.)&0x00200000)==0x00200000
group.long ((0xFFFC4000+368.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 15"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC4000+368.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 15"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC4000+368.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 15"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 15"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC4000+384.)++0x03
  line.long    0x00 "MB16,Message Buffer 16"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC4000+384.)&0x00200000)==0x00200000
group.long ((0xFFFC4000+384.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 16"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC4000+384.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 16"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC4000+384.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 16"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 16"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC4000+400.)++0x03
  line.long    0x00 "MB17,Message Buffer 17"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC4000+400.)&0x00200000)==0x00200000
group.long ((0xFFFC4000+400.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 17"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC4000+400.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 17"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC4000+400.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 17"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 17"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC4000+416.)++0x03
  line.long    0x00 "MB18,Message Buffer 18"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC4000+416.)&0x00200000)==0x00200000
group.long ((0xFFFC4000+416.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 18"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC4000+416.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 18"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC4000+416.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 18"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 18"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC4000+432.)++0x03
  line.long    0x00 "MB19,Message Buffer 19"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC4000+432.)&0x00200000)==0x00200000
group.long ((0xFFFC4000+432.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 19"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC4000+432.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 19"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC4000+432.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 19"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 19"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC4000+448.)++0x03
  line.long    0x00 "MB20,Message Buffer 20"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC4000+448.)&0x00200000)==0x00200000
group.long ((0xFFFC4000+448.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 20"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC4000+448.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 20"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC4000+448.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 20"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 20"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC4000+464.)++0x03
  line.long    0x00 "MB21,Message Buffer 21"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC4000+464.)&0x00200000)==0x00200000
group.long ((0xFFFC4000+464.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 21"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC4000+464.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 21"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC4000+464.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 21"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 21"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC4000+480.)++0x03
  line.long    0x00 "MB22,Message Buffer 22"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC4000+480.)&0x00200000)==0x00200000
group.long ((0xFFFC4000+480.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 22"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC4000+480.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 22"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC4000+480.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 22"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 22"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC4000+496.)++0x03
  line.long    0x00 "MB23,Message Buffer 23"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC4000+496.)&0x00200000)==0x00200000
group.long ((0xFFFC4000+496.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 23"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC4000+496.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 23"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC4000+496.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 23"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 23"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC4000+512.)++0x03
  line.long    0x00 "MB24,Message Buffer 24"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC4000+512.)&0x00200000)==0x00200000
group.long ((0xFFFC4000+512.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 24"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC4000+512.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 24"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC4000+512.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 24"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 24"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC4000+528.)++0x03
  line.long    0x00 "MB25,Message Buffer 25"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC4000+528.)&0x00200000)==0x00200000
group.long ((0xFFFC4000+528.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 25"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC4000+528.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 25"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC4000+528.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 25"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 25"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC4000+544.)++0x03
  line.long    0x00 "MB26,Message Buffer 26"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC4000+544.)&0x00200000)==0x00200000
group.long ((0xFFFC4000+544.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 26"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC4000+544.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 26"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC4000+544.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 26"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 26"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC4000+560.)++0x03
  line.long    0x00 "MB27,Message Buffer 27"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC4000+560.)&0x00200000)==0x00200000
group.long ((0xFFFC4000+560.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 27"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC4000+560.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 27"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC4000+560.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 27"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 27"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC4000+576.)++0x03
  line.long    0x00 "MB28,Message Buffer 28"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC4000+576.)&0x00200000)==0x00200000
group.long ((0xFFFC4000+576.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 28"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC4000+576.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 28"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC4000+576.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 28"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 28"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC4000+592.)++0x03
  line.long    0x00 "MB29,Message Buffer 29"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC4000+592.)&0x00200000)==0x00200000
group.long ((0xFFFC4000+592.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 29"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC4000+592.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 29"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC4000+592.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 29"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 29"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC4000+608.)++0x03
  line.long    0x00 "MB30,Message Buffer 30"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC4000+608.)&0x00200000)==0x00200000
group.long ((0xFFFC4000+608.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 30"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC4000+608.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 30"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC4000+608.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 30"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 30"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC4000+624.)++0x03
  line.long    0x00 "MB31,Message Buffer 31"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC4000+624.)&0x00200000)==0x00200000
group.long ((0xFFFC4000+624.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 31"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC4000+624.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 31"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC4000+624.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 31"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 31"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC4000+640.)++0x03
  line.long    0x00 "MB32,Message Buffer 32"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC4000+640.)&0x00200000)==0x00200000
group.long ((0xFFFC4000+640.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 32"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC4000+640.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 32"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC4000+640.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 32"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 32"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC4000+656.)++0x03
  line.long    0x00 "MB33,Message Buffer 33"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC4000+656.)&0x00200000)==0x00200000
group.long ((0xFFFC4000+656.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 33"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC4000+656.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 33"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC4000+656.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 33"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 33"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC4000+672.)++0x03
  line.long    0x00 "MB34,Message Buffer 34"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC4000+672.)&0x00200000)==0x00200000
group.long ((0xFFFC4000+672.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 34"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC4000+672.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 34"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC4000+672.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 34"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 34"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC4000+688.)++0x03
  line.long    0x00 "MB35,Message Buffer 35"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC4000+688.)&0x00200000)==0x00200000
group.long ((0xFFFC4000+688.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 35"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC4000+688.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 35"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC4000+688.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 35"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 35"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC4000+704.)++0x03
  line.long    0x00 "MB36,Message Buffer 36"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC4000+704.)&0x00200000)==0x00200000
group.long ((0xFFFC4000+704.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 36"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC4000+704.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 36"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC4000+704.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 36"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 36"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC4000+720.)++0x03
  line.long    0x00 "MB37,Message Buffer 37"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC4000+720.)&0x00200000)==0x00200000
group.long ((0xFFFC4000+720.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 37"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC4000+720.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 37"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC4000+720.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 37"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 37"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC4000+736.)++0x03
  line.long    0x00 "MB38,Message Buffer 38"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC4000+736.)&0x00200000)==0x00200000
group.long ((0xFFFC4000+736.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 38"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC4000+736.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 38"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC4000+736.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 38"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 38"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC4000+752.)++0x03
  line.long    0x00 "MB39,Message Buffer 39"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC4000+752.)&0x00200000)==0x00200000
group.long ((0xFFFC4000+752.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 39"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC4000+752.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 39"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC4000+752.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 39"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 39"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC4000+768.)++0x03
  line.long    0x00 "MB40,Message Buffer 40"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC4000+768.)&0x00200000)==0x00200000
group.long ((0xFFFC4000+768.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 40"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC4000+768.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 40"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC4000+768.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 40"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 40"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC4000+784.)++0x03
  line.long    0x00 "MB41,Message Buffer 41"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC4000+784.)&0x00200000)==0x00200000
group.long ((0xFFFC4000+784.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 41"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC4000+784.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 41"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC4000+784.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 41"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 41"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC4000+800.)++0x03
  line.long    0x00 "MB42,Message Buffer 42"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC4000+800.)&0x00200000)==0x00200000
group.long ((0xFFFC4000+800.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 42"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC4000+800.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 42"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC4000+800.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 42"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 42"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC4000+816.)++0x03
  line.long    0x00 "MB43,Message Buffer 43"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC4000+816.)&0x00200000)==0x00200000
group.long ((0xFFFC4000+816.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 43"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC4000+816.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 43"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC4000+816.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 43"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 43"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC4000+832.)++0x03
  line.long    0x00 "MB44,Message Buffer 44"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC4000+832.)&0x00200000)==0x00200000
group.long ((0xFFFC4000+832.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 44"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC4000+832.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 44"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC4000+832.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 44"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 44"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC4000+848.)++0x03
  line.long    0x00 "MB45,Message Buffer 45"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC4000+848.)&0x00200000)==0x00200000
group.long ((0xFFFC4000+848.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 45"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC4000+848.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 45"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC4000+848.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 45"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 45"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC4000+864.)++0x03
  line.long    0x00 "MB46,Message Buffer 46"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC4000+864.)&0x00200000)==0x00200000
group.long ((0xFFFC4000+864.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 46"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC4000+864.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 46"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC4000+864.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 46"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 46"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC4000+880.)++0x03
  line.long    0x00 "MB47,Message Buffer 47"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC4000+880.)&0x00200000)==0x00200000
group.long ((0xFFFC4000+880.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 47"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC4000+880.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 47"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC4000+880.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 47"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 47"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC4000+896.)++0x03
  line.long    0x00 "MB48,Message Buffer 48"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC4000+896.)&0x00200000)==0x00200000
group.long ((0xFFFC4000+896.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 48"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC4000+896.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 48"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC4000+896.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 48"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 48"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC4000+912.)++0x03
  line.long    0x00 "MB49,Message Buffer 49"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC4000+912.)&0x00200000)==0x00200000
group.long ((0xFFFC4000+912.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 49"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC4000+912.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 49"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC4000+912.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 49"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 49"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC4000+928.)++0x03
  line.long    0x00 "MB50,Message Buffer 50"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC4000+928.)&0x00200000)==0x00200000
group.long ((0xFFFC4000+928.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 50"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC4000+928.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 50"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC4000+928.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 50"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 50"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC4000+944.)++0x03
  line.long    0x00 "MB51,Message Buffer 51"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC4000+944.)&0x00200000)==0x00200000
group.long ((0xFFFC4000+944.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 51"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC4000+944.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 51"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC4000+944.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 51"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 51"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC4000+960.)++0x03
  line.long    0x00 "MB52,Message Buffer 52"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC4000+960.)&0x00200000)==0x00200000
group.long ((0xFFFC4000+960.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 52"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC4000+960.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 52"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC4000+960.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 52"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 52"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC4000+976.)++0x03
  line.long    0x00 "MB53,Message Buffer 53"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC4000+976.)&0x00200000)==0x00200000
group.long ((0xFFFC4000+976.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 53"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC4000+976.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 53"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC4000+976.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 53"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 53"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC4000+992.)++0x03
  line.long    0x00 "MB54,Message Buffer 54"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC4000+992.)&0x00200000)==0x00200000
group.long ((0xFFFC4000+992.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 54"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC4000+992.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 54"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC4000+992.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 54"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 54"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC4000+1008.)++0x03
  line.long    0x00 "MB55,Message Buffer 55"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC4000+1008.)&0x00200000)==0x00200000
group.long ((0xFFFC4000+1008.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 55"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC4000+1008.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 55"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC4000+1008.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 55"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 55"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC4000+1024.)++0x03
  line.long    0x00 "MB56,Message Buffer 56"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC4000+1024.)&0x00200000)==0x00200000
group.long ((0xFFFC4000+1024.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 56"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC4000+1024.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 56"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC4000+1024.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 56"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 56"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC4000+1040.)++0x03
  line.long    0x00 "MB57,Message Buffer 57"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC4000+1040.)&0x00200000)==0x00200000
group.long ((0xFFFC4000+1040.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 57"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC4000+1040.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 57"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC4000+1040.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 57"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 57"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC4000+1056.)++0x03
  line.long    0x00 "MB58,Message Buffer 58"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC4000+1056.)&0x00200000)==0x00200000
group.long ((0xFFFC4000+1056.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 58"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC4000+1056.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 58"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC4000+1056.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 58"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 58"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC4000+1072.)++0x03
  line.long    0x00 "MB59,Message Buffer 59"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC4000+1072.)&0x00200000)==0x00200000
group.long ((0xFFFC4000+1072.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 59"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC4000+1072.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 59"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC4000+1072.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 59"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 59"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC4000+1088.)++0x03
  line.long    0x00 "MB60,Message Buffer 60"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC4000+1088.)&0x00200000)==0x00200000
group.long ((0xFFFC4000+1088.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 60"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC4000+1088.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 60"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC4000+1088.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 60"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 60"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC4000+1104.)++0x03
  line.long    0x00 "MB61,Message Buffer 61"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC4000+1104.)&0x00200000)==0x00200000
group.long ((0xFFFC4000+1104.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 61"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC4000+1104.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 61"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC4000+1104.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 61"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 61"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC4000+1120.)++0x03
  line.long    0x00 "MB62,Message Buffer 62"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC4000+1120.)&0x00200000)==0x00200000
group.long ((0xFFFC4000+1120.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 62"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC4000+1120.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 62"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC4000+1120.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 62"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 62"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC4000+1136.)++0x03
  line.long    0x00 "MB63,Message Buffer 63"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC4000+1136.)&0x00200000)==0x00200000
group.long ((0xFFFC4000+1136.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 63"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC4000+1136.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 63"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC4000+1136.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 63"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 63"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""
tree.end


tree.end

endif

sif (cpu()=="MPC5633M")||(cpu()=="MPC5634M")||(cpu()=="SPC563M60")||(cpu()=="SPC563M64")

tree "FlexCAN C"

group.long 0xFFFC8000++0x03
  line.long    0x00 "MCR,Module Configuration Register"
  bitfld.long  0x00 31.                  "MDIS     ,Module disable" "0,1"
  bitfld.long  0x00 30.                  "  FRZ ,Freeze enable" "0,1"
  bitfld.long  0x00 28.                  "      HALT    ,Halt FlexCAN" "0,1"
  bitfld.long  0x00 27.                  "    NOTRDY ,FlexCAN2 not ready" "0,1"
  bitfld.long  0x00 25.                  "  SOFTRST ,Soft reset" "0,1"
  bitfld.long  0x00 24.                  "  FRZACK ,Freeze mode acknowledge" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 21.                  "  WRNEN    ,Warning interrupt enable" "0,1"
  bitfld.long  0x00 20.                  "  MDISACK ,Low power mode acknowledge" "0,1"
  bitfld.long  0x00 17.                  "  SRXDIS  ,This bit defines whether FlexCAN is allowed to receive frames transmitted by itself" "0,1"
  bitfld.long  0x00 16.                  "    MBFEN  ,Message buffer filter enable" "0,1"
  hexmask.byte 0x03 00.--06. 1.          "  MAXMB  ,Maximum number of message buffers"
TEXTLINE ""
 

group.long (0xFFFC8000+0x04)++0x03
  line.long    0x00 "CR,Control Register"
  hexmask.byte 0x00 00.--07. 1.          "PRESDIV ,Prescaler division factor"
  bitfld.long  0x00 22.--23.             "  RJW ,Resync jump width" "0,1,2,3"
  bitfld.long  0x00 19.--21.             "      PSEG1   ,Phase segment 1" "0,1,2,3,4,5,6,7"
  bitfld.long  0x00 16.--18.             "    PSEG2  ,Phase segment 2" "0,1,2,3,4,5,6,7"
  bitfld.long  0x00 15.                  "  BOFFMSK ,Bus off mask" "0,1"
  bitfld.long  0x00 14.                  "  ERRMSK ,Error mask" "0,1"
  bitfld.long  0x00 13.                  "  CLK_SRC ,CAN engine clock source" "osc_clk,bus_clk"
TEXTLINE "                "
  bitfld.long  0x00 12.                  "  LPB      ,Loop back" "0,1"
  bitfld.long  0x00 07.                  "  SMP ,Sampling mode" "one,three"
  bitfld.long  0x00 06.                  "  BOFFREC ,Bus off recovery mode" "ena,dis"
  bitfld.long  0x00 05.                  "  TSYN   ,Timer sync mode" "0,1"
  bitfld.long  0x00 04.                  "  LBUF    ,Lowest buffer transmitted first" "0,1"
  bitfld.long  0x00 03.                  "  LOM    ,Listen-only mode" "0,1"
  bitfld.long  0x00 00.--02.             "  PROPSEG ,Propagation segment" "0,1,2,3,4,5,6,7"
TEXTLINE ""

group.long (0xFFFC8000+0x08)++0x03
  line.long    0x00 "TIMER,Free Running Timer"
TEXTLINE ""

group.long (0xFFFC8000+0x10)++0x03
  line.long    0x00 "RXGMASK,RX Global Mask"
  bitfld.long  0x00 28.              "MI28       ,ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
  
  TEXTLINE "                "

  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"

TEXTLINE ""

group.long (0xFFFC8000+0x14)++0x03
  line.long    0x00 "RX14MASK,RX 14 Global Mask"
  bitfld.long  0x00 28.              "MI28       ,ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
  
  TEXTLINE "                "

  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""

group.long (0xFFFC8000+0x18)++0x03
  line.long    0x00 "RX15MASK,RX 15 Global Mask"
  bitfld.long  0x00 28.              "MI28       ,ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
  
  TEXTLINE "                "

  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""

group.long (0xFFFC8000+0x1C)++0x03
  line.long    0x00 "ECR,Error Counter Register"
  hexmask.byte 0x02 00.--07. 1.          "RXECTR ,Receive Error Counter"
  hexmask.byte 0x03 00.--07. 1.          "  TXECTR ,Transmit Error Counter"
TEXTLINE ""

group.long (0xFFFC8000+0x20)++0x03
  line.long    0x00 "ESR,Error and Status Register"
  bitfld.long  0x00 15.                  "BIT1ERR ,Bit 1 error" "0,1"
  bitfld.long  0x00 14.                  "  BIT0ERR ,Bit 0 error" "0,1"
  bitfld.long  0x00 13.                  "  ACKERR ,Acknowledge error." "0,1"
  bitfld.long  0x00 12.                  "   CRCERR   ,Cyclic redundancy code error" "0,1"
  bitfld.long  0x00 11.                  "  FRMERR ,Form error" "0,1"
  bitfld.long  0x00 10.                  "  STFERR ,Stuffing error" "0,1"
  bitfld.long  0x00 09.                  "  TXWRN  ,TX error counter" "0,1"
  TEXTLINE "                "
  bitfld.long  0x00 08.                  "  RXWRN   ,RX error counter" "0,1"
  bitfld.long  0x00 07.                  "  IDLE    ,CAN bus IDLE state" "0,1"
  bitfld.long  0x00 06.                  "  TXRX   ,Current FlexCAN2 status" "RX,TX"
  bitfld.long  0x00 04.--05.             "  FLTCONF  ,Fault confinement state" "err act,err pass,bus off,bus off"
  eventfld.long  0x00 02.                  "  BOFFINT   ,Bus off interrupt" "0,1"
  eventfld.long  0x00 01.                  "  ERRINT ,Error interrupt" "0,1"
TEXTLINE ""


group.long (0xFFFC8000+0x24)++0x03
  line.long    0x00 "IMRH,Interrupt masks high register"
  bitfld.long  0x00 31.              "BUF63-60 ,Message Buffer 63 mask" "0,1"
  bitfld.long  0x00 30.              ",Message Buffer 62 mask" "0,1"
  bitfld.long  0x00 29.              ",Message Buffer 61 mask" "0,1"
  bitfld.long  0x00 28.              ",Message Buffer 60 mask" "0,1"

  bitfld.long  0x00 27.              "  BUF59-56 ,Message Buffer 59 mask" "0,1"
  bitfld.long  0x00 26.              ",Message Buffer 58 mask" "0,1"
  bitfld.long  0x00 25.              ",Message Buffer 57 mask" "0,1"
  bitfld.long  0x00 24.              ",Message Buffer 56 mask" "0,1"

  bitfld.long  0x00 23.              "  BUF55-52 ,Message Buffer 55 mask" "0,1"
  bitfld.long  0x00 22.              ",Message Buffer 54 mask" "0,1"
  bitfld.long  0x00 21.              ",Message Buffer 53 mask" "0,1"
  bitfld.long  0x00 20.              ",Message Buffer 52 mask" "0,1"

  bitfld.long  0x00 19.              "  BUF51-48 ,Message Buffer 51 mask" "0,1"
  bitfld.long  0x00 18.              ",Message Buffer 50 mask" "0,1"
  bitfld.long  0x00 17.              ",Message Buffer 49 mask" "0,1"
  bitfld.long  0x00 16.              ",Message Buffer 48 mask" "0,1"
  
  TEXTLINE "                "

  bitfld.long  0x00 15.              "  BUF47-44 ,Message Buffer 47 mask" "0,1"
  bitfld.long  0x00 14.              ",Message Buffer 46 mask" "0,1"
  bitfld.long  0x00 13.              ",Message Buffer 45 mask" "0,1"
  bitfld.long  0x00 12.              ",Message Buffer 44 mask" "0,1"
  
  bitfld.long  0x00 11.              "  BUF43-40 ,Message Buffer 43 mask" "0,1"
  bitfld.long  0x00 10.              ",Message Buffer 42 mask" "0,1"
  bitfld.long  0x00 09.              ",Message Buffer 41 mask" "0,1"
  bitfld.long  0x00 08.              ",Message Buffer 40 mask" "0,1"
  
  bitfld.long  0x00 07.              "  BUF39-36 ,Message Buffer 39 mask" "0,1"
  bitfld.long  0x00 06.              ",Message Buffer 38 mask" "0,1"
  bitfld.long  0x00 05.              ",Message Buffer 37 mask" "0,1"
  bitfld.long  0x00 04.              ",Message Buffer 36 mask" "0,1"

  bitfld.long  0x00 03.              "  BUF35-32 ,Message Buffer 35 mask" "0,1"
  bitfld.long  0x00 02.              ",Message Buffer 34 mask" "0,1"
  bitfld.long  0x00 01.              ",Message Buffer 33 mask" "0,1"
  bitfld.long  0x00 00.              ",Message Buffer 32 mask" "0,1"
  
TEXTLINE ""

group.long (0xFFFC8000+0x28)++0x03
  line.long    0x00 "IMRL,Interrupt masks low register"
  bitfld.long  0x00 31.              "BUF31-28 ,Message Buffer 31 mask" "0,1"
  bitfld.long  0x00 30.              ",Message Buffer 30 mask" "0,1"
  bitfld.long  0x00 29.              ",Message Buffer 29 mask" "0,1"
  bitfld.long  0x00 28.              ",Message Buffer 28 mask" "0,1"

  bitfld.long  0x00 27.              "  BUF27-24 ,Message Buffer 27 mask" "0,1"
  bitfld.long  0x00 26.              ",Message Buffer 26 mask" "0,1"
  bitfld.long  0x00 25.              ",Message Buffer 25 mask" "0,1"
  bitfld.long  0x00 24.              ",Message Buffer 24 mask" "0,1"

  bitfld.long  0x00 23.              "  BUF23-20 ,Message Buffer 23 mask" "0,1"
  bitfld.long  0x00 22.              ",Message Buffer 22 mask" "0,1"
  bitfld.long  0x00 21.              ",Message Buffer 21 mask" "0,1"
  bitfld.long  0x00 20.              ",Message Buffer 20 mask" "0,1"

  bitfld.long  0x00 19.              "  BUF19-16 ,Message Buffer 19 mask" "0,1"
  bitfld.long  0x00 18.              ",Message Buffer 18 mask" "0,1"
  bitfld.long  0x00 17.              ",Message Buffer 17 mask" "0,1"
  bitfld.long  0x00 16.              ",Message Buffer 16 mask" "0,1"
  
  TEXTLINE "                "

  bitfld.long  0x00 15.              "  BUF15-12 ,Message Buffer 15 mask" "0,1"
  bitfld.long  0x00 14.              ",Message Buffer 14 mask" "0,1"
  bitfld.long  0x00 13.              ",Message Buffer 13 mask" "0,1"
  bitfld.long  0x00 12.              ",Message Buffer 12 mask" "0,1"
  
  bitfld.long  0x00 11.              "  BUF11-08 ,Message Buffer 11 mask" "0,1"
  bitfld.long  0x00 10.              ",Message Buffer 10 mask" "0,1"
  bitfld.long  0x00 09.              ",Message Buffer 09 mask" "0,1"
  bitfld.long  0x00 08.              ",Message Buffer 08 mask" "0,1"
  
  bitfld.long  0x00 07.              "  BUF07-04 ,Message Buffer 07 mask" "0,1"
  bitfld.long  0x00 06.              ",Message Buffer 06 mask" "0,1"
  bitfld.long  0x00 05.              ",Message Buffer 05 mask" "0,1"
  bitfld.long  0x00 04.              ",Message Buffer 04 mask" "0,1"

  bitfld.long  0x00 03.              "  BUF03-00 ,Message Buffer 03 mask" "0,1"
  bitfld.long  0x00 02.              ",Message Buffer 02 mask" "0,1"
  bitfld.long  0x00 01.              ",Message Buffer 01 mask" "0,1"
  bitfld.long  0x00 00.              ",Message Buffer 00 mask" "0,1"
  
TEXTLINE ""


group.long (0xFFFC8000+0x2C)++0x03
  line.long    0x00 "IFRH,Interrupt flags high register"
  eventfld.long  0x00 31.              "BUF63-60 ,Message Buffer 63 flag" "0,1"
  eventfld.long  0x00 30.              ",Message Buffer 62 flag" "0,1"
  eventfld.long  0x00 29.              ",Message Buffer 61 flag" "0,1"
  eventfld.long  0x00 28.              ",Message Buffer 60 flag" "0,1"

  eventfld.long  0x00 27.              "  BUF59-56 ,Message Buffer 59 flag" "0,1"
  eventfld.long  0x00 26.              ",Message Buffer 58 flag" "0,1"
  eventfld.long  0x00 25.              ",Message Buffer 57 flag" "0,1"
  eventfld.long  0x00 24.              ",Message Buffer 56 flag" "0,1"

  eventfld.long  0x00 23.              "  BUF55-52 ,Message Buffer 55 flag" "0,1"
  eventfld.long  0x00 22.              ",Message Buffer 54 flag" "0,1"
  eventfld.long  0x00 21.              ",Message Buffer 53 flag" "0,1"
  eventfld.long  0x00 20.              ",Message Buffer 52 flag" "0,1"

  eventfld.long  0x00 19.              "  BUF51-48 ,Message Buffer 51 flag" "0,1"
  eventfld.long  0x00 18.              ",Message Buffer 50 flag" "0,1"
  eventfld.long  0x00 17.              ",Message Buffer 49 flag" "0,1"
  eventfld.long  0x00 16.              ",Message Buffer 48 flag" "0,1"
  
  TEXTLINE "                "

  eventfld.long  0x00 15.              "  BUF47-44 ,Message Buffer 47 flag" "0,1"
  eventfld.long  0x00 14.              ",Message Buffer 46 flag" "0,1"
  eventfld.long  0x00 13.              ",Message Buffer 45 flag" "0,1"
  eventfld.long  0x00 12.              ",Message Buffer 44 flag" "0,1"
  
  eventfld.long  0x00 11.              "  BUF43-40 ,Message Buffer 43 flag" "0,1"
  eventfld.long  0x00 10.              ",Message Buffer 42 flag" "0,1"
  eventfld.long  0x00 09.              ",Message Buffer 41 flag" "0,1"
  eventfld.long  0x00 08.              ",Message Buffer 40 flag" "0,1"
  
  eventfld.long  0x00 07.              "  BUF39-36 ,Message Buffer 39 flag" "0,1"
  eventfld.long  0x00 06.              ",Message Buffer 38 flag" "0,1"
  eventfld.long  0x00 05.              ",Message Buffer 37 flag" "0,1"
  eventfld.long  0x00 04.              ",Message Buffer 36 flag" "0,1"

  eventfld.long  0x00 03.              "  BUF35-32 ,Message Buffer 35 flag" "0,1"
  eventfld.long  0x00 02.              ",Message Buffer 34 flag" "0,1"
  eventfld.long  0x00 01.              ",Message Buffer 33 flag" "0,1"
  eventfld.long  0x00 00.              ",Message Buffer 32 flag" "0,1"
  
TEXTLINE ""

group.long (0xFFFC8000+0x30)++0x03
  line.long    0x00 "IFRL,Interrupt flags low register"
  eventfld.long  0x00 31.              "BUF31-28 ,Message Buffer 31 flag" "0,1"
  eventfld.long  0x00 30.              ",Message Buffer 30 flag" "0,1"
  eventfld.long  0x00 29.              ",Message Buffer 29 flag" "0,1"
  eventfld.long  0x00 28.              ",Message Buffer 28 flag" "0,1"

  eventfld.long  0x00 27.              "  BUF27-24 ,Message Buffer 27 flag" "0,1"
  eventfld.long  0x00 26.              ",Message Buffer 26 flag" "0,1"
  eventfld.long  0x00 25.              ",Message Buffer 25 flag" "0,1"
  eventfld.long  0x00 24.              ",Message Buffer 24 flag" "0,1"

  eventfld.long  0x00 23.              "  BUF23-20 ,Message Buffer 23 flag" "0,1"
  eventfld.long  0x00 22.              ",Message Buffer 22 flag" "0,1"
  eventfld.long  0x00 21.              ",Message Buffer 21 flag" "0,1"
  eventfld.long  0x00 20.              ",Message Buffer 20 flag" "0,1"

  eventfld.long  0x00 19.              "  BUF19-16 ,Message Buffer 19 flag" "0,1"
  eventfld.long  0x00 18.              ",Message Buffer 18 flag" "0,1"
  eventfld.long  0x00 17.              ",Message Buffer 17 flag" "0,1"
  eventfld.long  0x00 16.              ",Message Buffer 16 flag" "0,1"
  
  TEXTLINE "                "

  eventfld.long  0x00 15.              "  BUF15-12 ,Message Buffer 15 flag" "0,1"
  eventfld.long  0x00 14.              ",Message Buffer 14 flag" "0,1"
  eventfld.long  0x00 13.              ",Message Buffer 13 flag" "0,1"
  eventfld.long  0x00 12.              ",Message Buffer 12 flag" "0,1"
  
  eventfld.long  0x00 11.              "  BUF11-08 ,Message Buffer 11 flag" "0,1"
  eventfld.long  0x00 10.              ",Message Buffer 10 flag" "0,1"
  eventfld.long  0x00 09.              ",Message Buffer 09 flag" "0,1"
  eventfld.long  0x00 08.              ",Message Buffer 08 flag" "0,1"
  
  eventfld.long  0x00 07.              "  BUF07-04 ,Message Buffer 07 flag" "0,1"
  eventfld.long  0x00 06.              ",Message Buffer 06 flag" "0,1"
  eventfld.long  0x00 05.              ",Message Buffer 05 flag" "0,1"
  eventfld.long  0x00 04.              ",Message Buffer 04 flag" "0,1"

  eventfld.long  0x00 03.              "  BUF03-00 ,Message Buffer 03 flag" "0,1"
  eventfld.long  0x00 02.              ",Message Buffer 02 flag" "0,1"
  eventfld.long  0x00 01.              ",Message Buffer 01 flag" "0,1"
  eventfld.long  0x00 00.              ",Message Buffer 00 flag" "0,1"
  
TEXTLINE ""

tree "Rx Individual Mask Registers"
group.long (0xFFFC8000+0x0880)++0x03
  line.long    0x00 "RXIMR00,Rx Individual Mask Register 00"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC8000+0x0884)++0x03
  line.long    0x00 "RXIMR01,Rx Individual Mask Register 01"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC8000+0x0888)++0x03
  line.long    0x00 "RXIMR02,Rx Individual Mask Register 02"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC8000+0x088c)++0x03
  line.long    0x00 "RXIMR03,Rx Individual Mask Register 03"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC8000+0x0890)++0x03
  line.long    0x00 "RXIMR04,Rx Individual Mask Register 04"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC8000+0x0894)++0x03
  line.long    0x00 "RXIMR05,Rx Individual Mask Register 05"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC8000+0x0898)++0x03
  line.long    0x00 "RXIMR06,Rx Individual Mask Register 06"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC8000+0x089c)++0x03
  line.long    0x00 "RXIMR07,Rx Individual Mask Register 07"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC8000+0x08a0)++0x03
  line.long    0x00 "RXIMR08,Rx Individual Mask Register 08"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC8000+0x08a4)++0x03
  line.long    0x00 "RXIMR09,Rx Individual Mask Register 09"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC8000+0x08a8)++0x03
  line.long    0x00 "RXIMR10,Rx Individual Mask Register 10"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC8000+0x08ac)++0x03
  line.long    0x00 "RXIMR11,Rx Individual Mask Register 11"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC8000+0x08b0)++0x03
  line.long    0x00 "RXIMR12,Rx Individual Mask Register 12"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC8000+0x08b4)++0x03
  line.long    0x00 "RXIMR13,Rx Individual Mask Register 13"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC8000+0x08b8)++0x03
  line.long    0x00 "RXIMR14,Rx Individual Mask Register 14"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC8000+0x08bc)++0x03
  line.long    0x00 "RXIMR15,Rx Individual Mask Register 15"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC8000+0x08c0)++0x03
  line.long    0x00 "RXIMR16,Rx Individual Mask Register 16"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC8000+0x08c4)++0x03
  line.long    0x00 "RXIMR17,Rx Individual Mask Register 17"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC8000+0x08c8)++0x03
  line.long    0x00 "RXIMR18,Rx Individual Mask Register 18"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC8000+0x08cc)++0x03
  line.long    0x00 "RXIMR19,Rx Individual Mask Register 19"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC8000+0x08d0)++0x03
  line.long    0x00 "RXIMR20,Rx Individual Mask Register 20"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC8000+0x08d4)++0x03
  line.long    0x00 "RXIMR21,Rx Individual Mask Register 21"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC8000+0x08d8)++0x03
  line.long    0x00 "RXIMR22,Rx Individual Mask Register 22"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC8000+0x08dc)++0x03
  line.long    0x00 "RXIMR23,Rx Individual Mask Register 23"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC8000+0x08e0)++0x03
  line.long    0x00 "RXIMR24,Rx Individual Mask Register 24"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC8000+0x08e4)++0x03
  line.long    0x00 "RXIMR25,Rx Individual Mask Register 25"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC8000+0x08e8)++0x03
  line.long    0x00 "RXIMR26,Rx Individual Mask Register 26"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC8000+0x08ec)++0x03
  line.long    0x00 "RXIMR27,Rx Individual Mask Register 27"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC8000+0x08f0)++0x03
  line.long    0x00 "RXIMR28,Rx Individual Mask Register 28"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC8000+0x08f4)++0x03
  line.long    0x00 "RXIMR29,Rx Individual Mask Register 29"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC8000+0x08f8)++0x03
  line.long    0x00 "RXIMR30,Rx Individual Mask Register 30"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC8000+0x08fc)++0x03
  line.long    0x00 "RXIMR31,Rx Individual Mask Register 31"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
tree.end

tree "Message Buffers"


group.long (0xFFFC8000+128.)++0x03
  line.long    0x00 "MB0,Message Buffer 0"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC8000+128.)&0x00200000)==0x00200000
group.long ((0xFFFC8000+128.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 0"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC8000+128.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 0"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC8000+128.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 0"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 0"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC8000+144.)++0x03
  line.long    0x00 "MB1,Message Buffer 1"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC8000+144.)&0x00200000)==0x00200000
group.long ((0xFFFC8000+144.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 1"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC8000+144.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 1"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC8000+144.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 1"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 1"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC8000+160.)++0x03
  line.long    0x00 "MB2,Message Buffer 2"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC8000+160.)&0x00200000)==0x00200000
group.long ((0xFFFC8000+160.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 2"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC8000+160.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 2"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC8000+160.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 2"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 2"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC8000+176.)++0x03
  line.long    0x00 "MB3,Message Buffer 3"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC8000+176.)&0x00200000)==0x00200000
group.long ((0xFFFC8000+176.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 3"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC8000+176.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 3"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC8000+176.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 3"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 3"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC8000+192.)++0x03
  line.long    0x00 "MB4,Message Buffer 4"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC8000+192.)&0x00200000)==0x00200000
group.long ((0xFFFC8000+192.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 4"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC8000+192.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 4"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC8000+192.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 4"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 4"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC8000+208.)++0x03
  line.long    0x00 "MB5,Message Buffer 5"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC8000+208.)&0x00200000)==0x00200000
group.long ((0xFFFC8000+208.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 5"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC8000+208.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 5"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC8000+208.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 5"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 5"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC8000+224.)++0x03
  line.long    0x00 "MB6,Message Buffer 6"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC8000+224.)&0x00200000)==0x00200000
group.long ((0xFFFC8000+224.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 6"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC8000+224.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 6"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC8000+224.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 6"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 6"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC8000+240.)++0x03
  line.long    0x00 "MB7,Message Buffer 7"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC8000+240.)&0x00200000)==0x00200000
group.long ((0xFFFC8000+240.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 7"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC8000+240.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 7"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC8000+240.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 7"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 7"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC8000+256.)++0x03
  line.long    0x00 "MB8,Message Buffer 8"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC8000+256.)&0x00200000)==0x00200000
group.long ((0xFFFC8000+256.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 8"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC8000+256.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 8"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC8000+256.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 8"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 8"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC8000+272.)++0x03
  line.long    0x00 "MB9,Message Buffer 9"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC8000+272.)&0x00200000)==0x00200000
group.long ((0xFFFC8000+272.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 9"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC8000+272.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 9"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC8000+272.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 9"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 9"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC8000+288.)++0x03
  line.long    0x00 "MB10,Message Buffer 10"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC8000+288.)&0x00200000)==0x00200000
group.long ((0xFFFC8000+288.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 10"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC8000+288.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 10"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC8000+288.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 10"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 10"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC8000+304.)++0x03
  line.long    0x00 "MB11,Message Buffer 11"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC8000+304.)&0x00200000)==0x00200000
group.long ((0xFFFC8000+304.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 11"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC8000+304.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 11"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC8000+304.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 11"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 11"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC8000+320.)++0x03
  line.long    0x00 "MB12,Message Buffer 12"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC8000+320.)&0x00200000)==0x00200000
group.long ((0xFFFC8000+320.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 12"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC8000+320.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 12"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC8000+320.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 12"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 12"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC8000+336.)++0x03
  line.long    0x00 "MB13,Message Buffer 13"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC8000+336.)&0x00200000)==0x00200000
group.long ((0xFFFC8000+336.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 13"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC8000+336.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 13"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC8000+336.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 13"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 13"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC8000+352.)++0x03
  line.long    0x00 "MB14,Message Buffer 14"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC8000+352.)&0x00200000)==0x00200000
group.long ((0xFFFC8000+352.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 14"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC8000+352.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 14"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC8000+352.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 14"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 14"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC8000+368.)++0x03
  line.long    0x00 "MB15,Message Buffer 15"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC8000+368.)&0x00200000)==0x00200000
group.long ((0xFFFC8000+368.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 15"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC8000+368.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 15"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC8000+368.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 15"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 15"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC8000+384.)++0x03
  line.long    0x00 "MB16,Message Buffer 16"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC8000+384.)&0x00200000)==0x00200000
group.long ((0xFFFC8000+384.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 16"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC8000+384.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 16"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC8000+384.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 16"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 16"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC8000+400.)++0x03
  line.long    0x00 "MB17,Message Buffer 17"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC8000+400.)&0x00200000)==0x00200000
group.long ((0xFFFC8000+400.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 17"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC8000+400.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 17"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC8000+400.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 17"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 17"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC8000+416.)++0x03
  line.long    0x00 "MB18,Message Buffer 18"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC8000+416.)&0x00200000)==0x00200000
group.long ((0xFFFC8000+416.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 18"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC8000+416.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 18"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC8000+416.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 18"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 18"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC8000+432.)++0x03
  line.long    0x00 "MB19,Message Buffer 19"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC8000+432.)&0x00200000)==0x00200000
group.long ((0xFFFC8000+432.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 19"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC8000+432.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 19"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC8000+432.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 19"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 19"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC8000+448.)++0x03
  line.long    0x00 "MB20,Message Buffer 20"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC8000+448.)&0x00200000)==0x00200000
group.long ((0xFFFC8000+448.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 20"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC8000+448.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 20"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC8000+448.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 20"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 20"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC8000+464.)++0x03
  line.long    0x00 "MB21,Message Buffer 21"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC8000+464.)&0x00200000)==0x00200000
group.long ((0xFFFC8000+464.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 21"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC8000+464.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 21"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC8000+464.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 21"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 21"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC8000+480.)++0x03
  line.long    0x00 "MB22,Message Buffer 22"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC8000+480.)&0x00200000)==0x00200000
group.long ((0xFFFC8000+480.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 22"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC8000+480.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 22"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC8000+480.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 22"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 22"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC8000+496.)++0x03
  line.long    0x00 "MB23,Message Buffer 23"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC8000+496.)&0x00200000)==0x00200000
group.long ((0xFFFC8000+496.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 23"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC8000+496.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 23"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC8000+496.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 23"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 23"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC8000+512.)++0x03
  line.long    0x00 "MB24,Message Buffer 24"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC8000+512.)&0x00200000)==0x00200000
group.long ((0xFFFC8000+512.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 24"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC8000+512.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 24"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC8000+512.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 24"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 24"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC8000+528.)++0x03
  line.long    0x00 "MB25,Message Buffer 25"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC8000+528.)&0x00200000)==0x00200000
group.long ((0xFFFC8000+528.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 25"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC8000+528.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 25"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC8000+528.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 25"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 25"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC8000+544.)++0x03
  line.long    0x00 "MB26,Message Buffer 26"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC8000+544.)&0x00200000)==0x00200000
group.long ((0xFFFC8000+544.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 26"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC8000+544.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 26"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC8000+544.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 26"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 26"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC8000+560.)++0x03
  line.long    0x00 "MB27,Message Buffer 27"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC8000+560.)&0x00200000)==0x00200000
group.long ((0xFFFC8000+560.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 27"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC8000+560.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 27"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC8000+560.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 27"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 27"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC8000+576.)++0x03
  line.long    0x00 "MB28,Message Buffer 28"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC8000+576.)&0x00200000)==0x00200000
group.long ((0xFFFC8000+576.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 28"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC8000+576.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 28"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC8000+576.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 28"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 28"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC8000+592.)++0x03
  line.long    0x00 "MB29,Message Buffer 29"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC8000+592.)&0x00200000)==0x00200000
group.long ((0xFFFC8000+592.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 29"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC8000+592.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 29"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC8000+592.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 29"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 29"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC8000+608.)++0x03
  line.long    0x00 "MB30,Message Buffer 30"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC8000+608.)&0x00200000)==0x00200000
group.long ((0xFFFC8000+608.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 30"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC8000+608.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 30"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC8000+608.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 30"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 30"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC8000+624.)++0x03
  line.long    0x00 "MB31,Message Buffer 31"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC8000+624.)&0x00200000)==0x00200000
group.long ((0xFFFC8000+624.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 31"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC8000+624.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 31"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC8000+624.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 31"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 31"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""
tree.end


tree.end

else

tree "FlexCAN C"

group.long 0xFFFC8000++0x03
  line.long    0x00 "MCR,Module Configuration Register"
  bitfld.long  0x00 31.                  "MDIS     ,Module disable" "0,1"
  bitfld.long  0x00 30.                  "  FRZ ,Freeze enable" "0,1"
  bitfld.long  0x00 28.                  "      HALT    ,Halt FlexCAN" "0,1"
  bitfld.long  0x00 27.                  "    NOTRDY ,FlexCAN2 not ready" "0,1"
  bitfld.long  0x00 25.                  "  SOFTRST ,Soft reset" "0,1"
  bitfld.long  0x00 24.                  "  FRZACK ,Freeze mode acknowledge" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 21.                  "  WRNEN    ,Warning interrupt enable" "0,1"
  bitfld.long  0x00 20.                  "  MDISACK ,Low power mode acknowledge" "0,1"
  bitfld.long  0x00 17.                  "  SRXDIS  ,This bit defines whether FlexCAN is allowed to receive frames transmitted by itself" "0,1"
  bitfld.long  0x00 16.                  "    MBFEN  ,Message buffer filter enable" "0,1"
  hexmask.byte 0x03 00.--06. 1.          "  MAXMB  ,Maximum number of message buffers"
TEXTLINE ""
 

group.long (0xFFFC8000+0x04)++0x03
  line.long    0x00 "CR,Control Register"
  hexmask.byte 0x00 00.--07. 1.          "PRESDIV ,Prescaler division factor"
  bitfld.long  0x00 22.--23.             "  RJW ,Resync jump width" "0,1,2,3"
  bitfld.long  0x00 19.--21.             "      PSEG1   ,Phase segment 1" "0,1,2,3,4,5,6,7"
  bitfld.long  0x00 16.--18.             "    PSEG2  ,Phase segment 2" "0,1,2,3,4,5,6,7"
  bitfld.long  0x00 15.                  "  BOFFMSK ,Bus off mask" "0,1"
  bitfld.long  0x00 14.                  "  ERRMSK ,Error mask" "0,1"
  bitfld.long  0x00 13.                  "  CLK_SRC ,CAN engine clock source" "osc_clk,bus_clk"
TEXTLINE "                "
  bitfld.long  0x00 12.                  "  LPB      ,Loop back" "0,1"
  bitfld.long  0x00 07.                  "  SMP ,Sampling mode" "one,three"
  bitfld.long  0x00 06.                  "  BOFFREC ,Bus off recovery mode" "ena,dis"
  bitfld.long  0x00 05.                  "  TSYN   ,Timer sync mode" "0,1"
  bitfld.long  0x00 04.                  "  LBUF    ,Lowest buffer transmitted first" "0,1"
  bitfld.long  0x00 03.                  "  LOM    ,Listen-only mode" "0,1"
  bitfld.long  0x00 00.--02.             "  PROPSEG ,Propagation segment" "0,1,2,3,4,5,6,7"
TEXTLINE ""

group.long (0xFFFC8000+0x08)++0x03
  line.long    0x00 "TIMER,Free Running Timer"
TEXTLINE ""

group.long (0xFFFC8000+0x10)++0x03
  line.long    0x00 "RXGMASK,RX Global Mask"
  bitfld.long  0x00 28.              "MI28       ,ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
  
  TEXTLINE "                "

  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"

TEXTLINE ""

group.long (0xFFFC8000+0x14)++0x03
  line.long    0x00 "RX14MASK,RX 14 Global Mask"
  bitfld.long  0x00 28.              "MI28       ,ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
  
  TEXTLINE "                "

  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""

group.long (0xFFFC8000+0x18)++0x03
  line.long    0x00 "RX15MASK,RX 15 Global Mask"
  bitfld.long  0x00 28.              "MI28       ,ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
  
  TEXTLINE "                "

  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""

group.long (0xFFFC8000+0x1C)++0x03
  line.long    0x00 "ECR,Error Counter Register"
  hexmask.byte 0x02 00.--07. 1.          "RXECTR ,Receive Error Counter"
  hexmask.byte 0x03 00.--07. 1.          "  TXECTR ,Transmit Error Counter"
TEXTLINE ""

group.long (0xFFFC8000+0x20)++0x03
  line.long    0x00 "ESR,Error and Status Register"
  bitfld.long  0x00 15.                  "BIT1ERR ,Bit 1 error" "0,1"
  bitfld.long  0x00 14.                  "  BIT0ERR ,Bit 0 error" "0,1"
  bitfld.long  0x00 13.                  "  ACKERR ,Acknowledge error." "0,1"
  bitfld.long  0x00 12.                  "   CRCERR   ,Cyclic redundancy code error" "0,1"
  bitfld.long  0x00 11.                  "  FRMERR ,Form error" "0,1"
  bitfld.long  0x00 10.                  "  STFERR ,Stuffing error" "0,1"
  bitfld.long  0x00 09.                  "  TXWRN  ,TX error counter" "0,1"
  TEXTLINE "                "
  bitfld.long  0x00 08.                  "  RXWRN   ,RX error counter" "0,1"
  bitfld.long  0x00 07.                  "  IDLE    ,CAN bus IDLE state" "0,1"
  bitfld.long  0x00 06.                  "  TXRX   ,Current FlexCAN2 status" "RX,TX"
  bitfld.long  0x00 04.--05.             "  FLTCONF  ,Fault confinement state" "err act,err pass,bus off,bus off"
  eventfld.long  0x00 02.                  "  BOFFINT   ,Bus off interrupt" "0,1"
  eventfld.long  0x00 01.                  "  ERRINT ,Error interrupt" "0,1"
TEXTLINE ""


group.long (0xFFFC8000+0x24)++0x03
  line.long    0x00 "IMRH,Interrupt masks high register"
  bitfld.long  0x00 31.              "BUF63-60 ,Message Buffer 63 mask" "0,1"
  bitfld.long  0x00 30.              ",Message Buffer 62 mask" "0,1"
  bitfld.long  0x00 29.              ",Message Buffer 61 mask" "0,1"
  bitfld.long  0x00 28.              ",Message Buffer 60 mask" "0,1"

  bitfld.long  0x00 27.              "  BUF59-56 ,Message Buffer 59 mask" "0,1"
  bitfld.long  0x00 26.              ",Message Buffer 58 mask" "0,1"
  bitfld.long  0x00 25.              ",Message Buffer 57 mask" "0,1"
  bitfld.long  0x00 24.              ",Message Buffer 56 mask" "0,1"

  bitfld.long  0x00 23.              "  BUF55-52 ,Message Buffer 55 mask" "0,1"
  bitfld.long  0x00 22.              ",Message Buffer 54 mask" "0,1"
  bitfld.long  0x00 21.              ",Message Buffer 53 mask" "0,1"
  bitfld.long  0x00 20.              ",Message Buffer 52 mask" "0,1"

  bitfld.long  0x00 19.              "  BUF51-48 ,Message Buffer 51 mask" "0,1"
  bitfld.long  0x00 18.              ",Message Buffer 50 mask" "0,1"
  bitfld.long  0x00 17.              ",Message Buffer 49 mask" "0,1"
  bitfld.long  0x00 16.              ",Message Buffer 48 mask" "0,1"
  
  TEXTLINE "                "

  bitfld.long  0x00 15.              "  BUF47-44 ,Message Buffer 47 mask" "0,1"
  bitfld.long  0x00 14.              ",Message Buffer 46 mask" "0,1"
  bitfld.long  0x00 13.              ",Message Buffer 45 mask" "0,1"
  bitfld.long  0x00 12.              ",Message Buffer 44 mask" "0,1"
  
  bitfld.long  0x00 11.              "  BUF43-40 ,Message Buffer 43 mask" "0,1"
  bitfld.long  0x00 10.              ",Message Buffer 42 mask" "0,1"
  bitfld.long  0x00 09.              ",Message Buffer 41 mask" "0,1"
  bitfld.long  0x00 08.              ",Message Buffer 40 mask" "0,1"
  
  bitfld.long  0x00 07.              "  BUF39-36 ,Message Buffer 39 mask" "0,1"
  bitfld.long  0x00 06.              ",Message Buffer 38 mask" "0,1"
  bitfld.long  0x00 05.              ",Message Buffer 37 mask" "0,1"
  bitfld.long  0x00 04.              ",Message Buffer 36 mask" "0,1"

  bitfld.long  0x00 03.              "  BUF35-32 ,Message Buffer 35 mask" "0,1"
  bitfld.long  0x00 02.              ",Message Buffer 34 mask" "0,1"
  bitfld.long  0x00 01.              ",Message Buffer 33 mask" "0,1"
  bitfld.long  0x00 00.              ",Message Buffer 32 mask" "0,1"
  
TEXTLINE ""

group.long (0xFFFC8000+0x28)++0x03
  line.long    0x00 "IMRL,Interrupt masks low register"
  bitfld.long  0x00 31.              "BUF31-28 ,Message Buffer 31 mask" "0,1"
  bitfld.long  0x00 30.              ",Message Buffer 30 mask" "0,1"
  bitfld.long  0x00 29.              ",Message Buffer 29 mask" "0,1"
  bitfld.long  0x00 28.              ",Message Buffer 28 mask" "0,1"

  bitfld.long  0x00 27.              "  BUF27-24 ,Message Buffer 27 mask" "0,1"
  bitfld.long  0x00 26.              ",Message Buffer 26 mask" "0,1"
  bitfld.long  0x00 25.              ",Message Buffer 25 mask" "0,1"
  bitfld.long  0x00 24.              ",Message Buffer 24 mask" "0,1"

  bitfld.long  0x00 23.              "  BUF23-20 ,Message Buffer 23 mask" "0,1"
  bitfld.long  0x00 22.              ",Message Buffer 22 mask" "0,1"
  bitfld.long  0x00 21.              ",Message Buffer 21 mask" "0,1"
  bitfld.long  0x00 20.              ",Message Buffer 20 mask" "0,1"

  bitfld.long  0x00 19.              "  BUF19-16 ,Message Buffer 19 mask" "0,1"
  bitfld.long  0x00 18.              ",Message Buffer 18 mask" "0,1"
  bitfld.long  0x00 17.              ",Message Buffer 17 mask" "0,1"
  bitfld.long  0x00 16.              ",Message Buffer 16 mask" "0,1"
  
  TEXTLINE "                "

  bitfld.long  0x00 15.              "  BUF15-12 ,Message Buffer 15 mask" "0,1"
  bitfld.long  0x00 14.              ",Message Buffer 14 mask" "0,1"
  bitfld.long  0x00 13.              ",Message Buffer 13 mask" "0,1"
  bitfld.long  0x00 12.              ",Message Buffer 12 mask" "0,1"
  
  bitfld.long  0x00 11.              "  BUF11-08 ,Message Buffer 11 mask" "0,1"
  bitfld.long  0x00 10.              ",Message Buffer 10 mask" "0,1"
  bitfld.long  0x00 09.              ",Message Buffer 09 mask" "0,1"
  bitfld.long  0x00 08.              ",Message Buffer 08 mask" "0,1"
  
  bitfld.long  0x00 07.              "  BUF07-04 ,Message Buffer 07 mask" "0,1"
  bitfld.long  0x00 06.              ",Message Buffer 06 mask" "0,1"
  bitfld.long  0x00 05.              ",Message Buffer 05 mask" "0,1"
  bitfld.long  0x00 04.              ",Message Buffer 04 mask" "0,1"

  bitfld.long  0x00 03.              "  BUF03-00 ,Message Buffer 03 mask" "0,1"
  bitfld.long  0x00 02.              ",Message Buffer 02 mask" "0,1"
  bitfld.long  0x00 01.              ",Message Buffer 01 mask" "0,1"
  bitfld.long  0x00 00.              ",Message Buffer 00 mask" "0,1"
  
TEXTLINE ""


group.long (0xFFFC8000+0x2C)++0x03
  line.long    0x00 "IFRH,Interrupt flags high register"
  eventfld.long  0x00 31.              "BUF63-60 ,Message Buffer 63 flag" "0,1"
  eventfld.long  0x00 30.              ",Message Buffer 62 flag" "0,1"
  eventfld.long  0x00 29.              ",Message Buffer 61 flag" "0,1"
  eventfld.long  0x00 28.              ",Message Buffer 60 flag" "0,1"

  eventfld.long  0x00 27.              "  BUF59-56 ,Message Buffer 59 flag" "0,1"
  eventfld.long  0x00 26.              ",Message Buffer 58 flag" "0,1"
  eventfld.long  0x00 25.              ",Message Buffer 57 flag" "0,1"
  eventfld.long  0x00 24.              ",Message Buffer 56 flag" "0,1"

  eventfld.long  0x00 23.              "  BUF55-52 ,Message Buffer 55 flag" "0,1"
  eventfld.long  0x00 22.              ",Message Buffer 54 flag" "0,1"
  eventfld.long  0x00 21.              ",Message Buffer 53 flag" "0,1"
  eventfld.long  0x00 20.              ",Message Buffer 52 flag" "0,1"

  eventfld.long  0x00 19.              "  BUF51-48 ,Message Buffer 51 flag" "0,1"
  eventfld.long  0x00 18.              ",Message Buffer 50 flag" "0,1"
  eventfld.long  0x00 17.              ",Message Buffer 49 flag" "0,1"
  eventfld.long  0x00 16.              ",Message Buffer 48 flag" "0,1"
  
  TEXTLINE "                "

  eventfld.long  0x00 15.              "  BUF47-44 ,Message Buffer 47 flag" "0,1"
  eventfld.long  0x00 14.              ",Message Buffer 46 flag" "0,1"
  eventfld.long  0x00 13.              ",Message Buffer 45 flag" "0,1"
  eventfld.long  0x00 12.              ",Message Buffer 44 flag" "0,1"
  
  eventfld.long  0x00 11.              "  BUF43-40 ,Message Buffer 43 flag" "0,1"
  eventfld.long  0x00 10.              ",Message Buffer 42 flag" "0,1"
  eventfld.long  0x00 09.              ",Message Buffer 41 flag" "0,1"
  eventfld.long  0x00 08.              ",Message Buffer 40 flag" "0,1"
  
  eventfld.long  0x00 07.              "  BUF39-36 ,Message Buffer 39 flag" "0,1"
  eventfld.long  0x00 06.              ",Message Buffer 38 flag" "0,1"
  eventfld.long  0x00 05.              ",Message Buffer 37 flag" "0,1"
  eventfld.long  0x00 04.              ",Message Buffer 36 flag" "0,1"

  eventfld.long  0x00 03.              "  BUF35-32 ,Message Buffer 35 flag" "0,1"
  eventfld.long  0x00 02.              ",Message Buffer 34 flag" "0,1"
  eventfld.long  0x00 01.              ",Message Buffer 33 flag" "0,1"
  eventfld.long  0x00 00.              ",Message Buffer 32 flag" "0,1"
  
TEXTLINE ""

group.long (0xFFFC8000+0x30)++0x03
  line.long    0x00 "IFRL,Interrupt flags low register"
  eventfld.long  0x00 31.              "BUF31-28 ,Message Buffer 31 flag" "0,1"
  eventfld.long  0x00 30.              ",Message Buffer 30 flag" "0,1"
  eventfld.long  0x00 29.              ",Message Buffer 29 flag" "0,1"
  eventfld.long  0x00 28.              ",Message Buffer 28 flag" "0,1"

  eventfld.long  0x00 27.              "  BUF27-24 ,Message Buffer 27 flag" "0,1"
  eventfld.long  0x00 26.              ",Message Buffer 26 flag" "0,1"
  eventfld.long  0x00 25.              ",Message Buffer 25 flag" "0,1"
  eventfld.long  0x00 24.              ",Message Buffer 24 flag" "0,1"

  eventfld.long  0x00 23.              "  BUF23-20 ,Message Buffer 23 flag" "0,1"
  eventfld.long  0x00 22.              ",Message Buffer 22 flag" "0,1"
  eventfld.long  0x00 21.              ",Message Buffer 21 flag" "0,1"
  eventfld.long  0x00 20.              ",Message Buffer 20 flag" "0,1"

  eventfld.long  0x00 19.              "  BUF19-16 ,Message Buffer 19 flag" "0,1"
  eventfld.long  0x00 18.              ",Message Buffer 18 flag" "0,1"
  eventfld.long  0x00 17.              ",Message Buffer 17 flag" "0,1"
  eventfld.long  0x00 16.              ",Message Buffer 16 flag" "0,1"
  
  TEXTLINE "                "

  eventfld.long  0x00 15.              "  BUF15-12 ,Message Buffer 15 flag" "0,1"
  eventfld.long  0x00 14.              ",Message Buffer 14 flag" "0,1"
  eventfld.long  0x00 13.              ",Message Buffer 13 flag" "0,1"
  eventfld.long  0x00 12.              ",Message Buffer 12 flag" "0,1"
  
  eventfld.long  0x00 11.              "  BUF11-08 ,Message Buffer 11 flag" "0,1"
  eventfld.long  0x00 10.              ",Message Buffer 10 flag" "0,1"
  eventfld.long  0x00 09.              ",Message Buffer 09 flag" "0,1"
  eventfld.long  0x00 08.              ",Message Buffer 08 flag" "0,1"
  
  eventfld.long  0x00 07.              "  BUF07-04 ,Message Buffer 07 flag" "0,1"
  eventfld.long  0x00 06.              ",Message Buffer 06 flag" "0,1"
  eventfld.long  0x00 05.              ",Message Buffer 05 flag" "0,1"
  eventfld.long  0x00 04.              ",Message Buffer 04 flag" "0,1"

  eventfld.long  0x00 03.              "  BUF03-00 ,Message Buffer 03 flag" "0,1"
  eventfld.long  0x00 02.              ",Message Buffer 02 flag" "0,1"
  eventfld.long  0x00 01.              ",Message Buffer 01 flag" "0,1"
  eventfld.long  0x00 00.              ",Message Buffer 00 flag" "0,1"
  
TEXTLINE ""


tree "Rx Individual Mask Registers"
group.long (0xFFFC8000+0x0880)++0x03
  line.long    0x00 "RXIMR00,Rx Individual Mask Register 00"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC8000+0x0884)++0x03
  line.long    0x00 "RXIMR01,Rx Individual Mask Register 01"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC8000+0x0888)++0x03
  line.long    0x00 "RXIMR02,Rx Individual Mask Register 02"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC8000+0x088c)++0x03
  line.long    0x00 "RXIMR03,Rx Individual Mask Register 03"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC8000+0x0890)++0x03
  line.long    0x00 "RXIMR04,Rx Individual Mask Register 04"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC8000+0x0894)++0x03
  line.long    0x00 "RXIMR05,Rx Individual Mask Register 05"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC8000+0x0898)++0x03
  line.long    0x00 "RXIMR06,Rx Individual Mask Register 06"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC8000+0x089c)++0x03
  line.long    0x00 "RXIMR07,Rx Individual Mask Register 07"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC8000+0x08a0)++0x03
  line.long    0x00 "RXIMR08,Rx Individual Mask Register 08"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC8000+0x08a4)++0x03
  line.long    0x00 "RXIMR09,Rx Individual Mask Register 09"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC8000+0x08a8)++0x03
  line.long    0x00 "RXIMR10,Rx Individual Mask Register 10"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC8000+0x08ac)++0x03
  line.long    0x00 "RXIMR11,Rx Individual Mask Register 11"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC8000+0x08b0)++0x03
  line.long    0x00 "RXIMR12,Rx Individual Mask Register 12"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC8000+0x08b4)++0x03
  line.long    0x00 "RXIMR13,Rx Individual Mask Register 13"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC8000+0x08b8)++0x03
  line.long    0x00 "RXIMR14,Rx Individual Mask Register 14"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC8000+0x08bc)++0x03
  line.long    0x00 "RXIMR15,Rx Individual Mask Register 15"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC8000+0x08c0)++0x03
  line.long    0x00 "RXIMR16,Rx Individual Mask Register 16"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC8000+0x08c4)++0x03
  line.long    0x00 "RXIMR17,Rx Individual Mask Register 17"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC8000+0x08c8)++0x03
  line.long    0x00 "RXIMR18,Rx Individual Mask Register 18"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC8000+0x08cc)++0x03
  line.long    0x00 "RXIMR19,Rx Individual Mask Register 19"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC8000+0x08d0)++0x03
  line.long    0x00 "RXIMR20,Rx Individual Mask Register 20"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC8000+0x08d4)++0x03
  line.long    0x00 "RXIMR21,Rx Individual Mask Register 21"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC8000+0x08d8)++0x03
  line.long    0x00 "RXIMR22,Rx Individual Mask Register 22"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC8000+0x08dc)++0x03
  line.long    0x00 "RXIMR23,Rx Individual Mask Register 23"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC8000+0x08e0)++0x03
  line.long    0x00 "RXIMR24,Rx Individual Mask Register 24"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC8000+0x08e4)++0x03
  line.long    0x00 "RXIMR25,Rx Individual Mask Register 25"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC8000+0x08e8)++0x03
  line.long    0x00 "RXIMR26,Rx Individual Mask Register 26"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC8000+0x08ec)++0x03
  line.long    0x00 "RXIMR27,Rx Individual Mask Register 27"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC8000+0x08f0)++0x03
  line.long    0x00 "RXIMR28,Rx Individual Mask Register 28"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC8000+0x08f4)++0x03
  line.long    0x00 "RXIMR29,Rx Individual Mask Register 29"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC8000+0x08f8)++0x03
  line.long    0x00 "RXIMR30,Rx Individual Mask Register 30"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC8000+0x08fc)++0x03
  line.long    0x00 "RXIMR31,Rx Individual Mask Register 31"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC8000+0x0900)++0x03
  line.long    0x00 "RXIMR32,Rx Individual Mask Register 32"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC8000+0x0904)++0x03
  line.long    0x00 "RXIMR33,Rx Individual Mask Register 33"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC8000+0x0908)++0x03
  line.long    0x00 "RXIMR34,Rx Individual Mask Register 34"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC8000+0x090c)++0x03
  line.long    0x00 "RXIMR35,Rx Individual Mask Register 35"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC8000+0x0910)++0x03
  line.long    0x00 "RXIMR36,Rx Individual Mask Register 36"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC8000+0x0914)++0x03
  line.long    0x00 "RXIMR37,Rx Individual Mask Register 37"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC8000+0x0918)++0x03
  line.long    0x00 "RXIMR38,Rx Individual Mask Register 38"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC8000+0x091c)++0x03
  line.long    0x00 "RXIMR39,Rx Individual Mask Register 39"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC8000+0x0920)++0x03
  line.long    0x00 "RXIMR30,Rx Individual Mask Register 30"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC8000+0x0924)++0x03
  line.long    0x00 "RXIMR41,Rx Individual Mask Register 41"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC8000+0x0928)++0x03
  line.long    0x00 "RXIMR42,Rx Individual Mask Register 42"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC8000+0x092c)++0x03
  line.long    0x00 "RXIMR43,Rx Individual Mask Register 43"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC8000+0x0930)++0x03
  line.long    0x00 "RXIMR44,Rx Individual Mask Register 44"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC8000+0x0934)++0x03
  line.long    0x00 "RXIMR45,Rx Individual Mask Register 45"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC8000+0x0938)++0x03
  line.long    0x00 "RXIMR46,Rx Individual Mask Register 46"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC8000+0x093c)++0x03
  line.long    0x00 "RXIMR47,Rx Individual Mask Register 47"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC8000+0x0940)++0x03
  line.long    0x00 "RXIMR48,Rx Individual Mask Register 48"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC8000+0x0944)++0x03
  line.long    0x00 "RXIMR49,Rx Individual Mask Register 49"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC8000+0x0948)++0x03
  line.long    0x00 "RXIMR50,Rx Individual Mask Register 50"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC8000+0x094c)++0x03
  line.long    0x00 "RXIMR51,Rx Individual Mask Register 51"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC8000+0x0950)++0x03
  line.long    0x00 "RXIMR52,Rx Individual Mask Register 52"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC8000+0x0954)++0x03
  line.long    0x00 "RXIMR53,Rx Individual Mask Register 53"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC8000+0x0958)++0x03
  line.long    0x00 "RXIMR54,Rx Individual Mask Register 54"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC8000+0x095c)++0x03
  line.long    0x00 "RXIMR55,Rx Individual Mask Register 55"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC8000+0x0960)++0x03
  line.long    0x00 "RXIMR56,Rx Individual Mask Register 56"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC8000+0x0964)++0x03
  line.long    0x00 "RXIMR57,Rx Individual Mask Register 57"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC8000+0x0968)++0x03
  line.long    0x00 "RXIMR58,Rx Individual Mask Register 58"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC8000+0x096c)++0x03
  line.long    0x00 "RXIMR59,Rx Individual Mask Register 59"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC8000+0x0970)++0x03
  line.long    0x00 "RXIMR60,Rx Individual Mask Register 60"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC8000+0x0974)++0x03
  line.long    0x00 "RXIMR61,Rx Individual Mask Register 61"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC8000+0x0978)++0x03
  line.long    0x00 "RXIMR62,Rx Individual Mask Register 62"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
group.long (0xFFFC8000+0x097c)++0x03
  line.long    0x00 "RXIMR63,Rx Individual Mask Register 63"
  bitfld.long  0x00 31.              "MI31-28 ,ID mask bit 31" "0,1"
  bitfld.long  0x00 30.              ",ID mask bit 30" "0,1"
  bitfld.long  0x00 29.              ",ID mask bit 29" "0,1"
  bitfld.long  0x00 28.              ",ID mask bit 28" "0,1"
  
  bitfld.long  0x00 27.              "  MI27-24 ,ID mask bit 27" "0,1"
  bitfld.long  0x00 26.              ",ID mask bit 26" "0,1"
  bitfld.long  0x00 25.              ",ID mask bit 25" "0,1"
  bitfld.long  0x00 24.              ",ID mask bit 24" "0,1"

  bitfld.long  0x00 23.              "  MI23-20 ,ID mask bit 23" "0,1"
  bitfld.long  0x00 22.              ",ID mask bit 22" "0,1"
  bitfld.long  0x00 21.              ",ID mask bit 21" "0,1"
  bitfld.long  0x00 20.              ",ID mask bit 20" "0,1"

  bitfld.long  0x00 19.              "  MI19-16 ,ID mask bit 19" "0,1"
  bitfld.long  0x00 18.              ",ID mask bit 18" "0,1"
  bitfld.long  0x00 17.              ",ID mask bit 17" "0,1"
  bitfld.long  0x00 16.              ",ID mask bit 16" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  MI15-12 ,ID mask bit 15" "0,1"
  bitfld.long  0x00 14.              ",ID mask bit 14" "0,1"
  bitfld.long  0x00 13.              ",ID mask bit 13" "0,1"
  bitfld.long  0x00 12.              ",ID mask bit 12" "0,1"

  bitfld.long  0x00 11.              "  MI11-08 ,ID mask bit 11" "0,1"
  bitfld.long  0x00 10.              ",ID mask bit 10" "0,1"
  bitfld.long  0x00 09.              ",ID mask bit 09" "0,1"
  bitfld.long  0x00 08.              ",ID mask bit 08" "0,1"

  bitfld.long  0x00 07.              "  MI07-04 ,ID mask bit 07" "0,1"
  bitfld.long  0x00 06.              ",ID mask bit 06" "0,1"
  bitfld.long  0x00 05.              ",ID mask bit 05" "0,1"
  bitfld.long  0x00 04.              ",ID mask bit 04" "0,1"
  
  bitfld.long  0x00 03.              "  MI03-00 ,ID mask bit 03" "0,1"
  bitfld.long  0x00 02.              ",ID mask bit 02" "0,1"
  bitfld.long  0x00 01.              ",ID mask bit 01" "0,1"
  bitfld.long  0x00 00.              ",ID mask bit 00" "0,1"
TEXTLINE ""
tree.end 

tree "Message Buffers"


group.long (0xFFFC8000+128.)++0x03
  line.long    0x00 "MB0,Message Buffer 0"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC8000+128.)&0x00200000)==0x00200000
group.long ((0xFFFC8000+128.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 0"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC8000+128.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 0"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC8000+128.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 0"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 0"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC8000+144.)++0x03
  line.long    0x00 "MB1,Message Buffer 1"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC8000+144.)&0x00200000)==0x00200000
group.long ((0xFFFC8000+144.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 1"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC8000+144.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 1"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC8000+144.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 1"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 1"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC8000+160.)++0x03
  line.long    0x00 "MB2,Message Buffer 2"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC8000+160.)&0x00200000)==0x00200000
group.long ((0xFFFC8000+160.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 2"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC8000+160.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 2"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC8000+160.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 2"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 2"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC8000+176.)++0x03
  line.long    0x00 "MB3,Message Buffer 3"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC8000+176.)&0x00200000)==0x00200000
group.long ((0xFFFC8000+176.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 3"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC8000+176.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 3"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC8000+176.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 3"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 3"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC8000+192.)++0x03
  line.long    0x00 "MB4,Message Buffer 4"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC8000+192.)&0x00200000)==0x00200000
group.long ((0xFFFC8000+192.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 4"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC8000+192.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 4"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC8000+192.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 4"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 4"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC8000+208.)++0x03
  line.long    0x00 "MB5,Message Buffer 5"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC8000+208.)&0x00200000)==0x00200000
group.long ((0xFFFC8000+208.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 5"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC8000+208.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 5"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC8000+208.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 5"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 5"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC8000+224.)++0x03
  line.long    0x00 "MB6,Message Buffer 6"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC8000+224.)&0x00200000)==0x00200000
group.long ((0xFFFC8000+224.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 6"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC8000+224.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 6"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC8000+224.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 6"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 6"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC8000+240.)++0x03
  line.long    0x00 "MB7,Message Buffer 7"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC8000+240.)&0x00200000)==0x00200000
group.long ((0xFFFC8000+240.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 7"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC8000+240.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 7"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC8000+240.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 7"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 7"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC8000+256.)++0x03
  line.long    0x00 "MB8,Message Buffer 8"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC8000+256.)&0x00200000)==0x00200000
group.long ((0xFFFC8000+256.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 8"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC8000+256.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 8"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC8000+256.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 8"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 8"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC8000+272.)++0x03
  line.long    0x00 "MB9,Message Buffer 9"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC8000+272.)&0x00200000)==0x00200000
group.long ((0xFFFC8000+272.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 9"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC8000+272.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 9"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC8000+272.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 9"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 9"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC8000+288.)++0x03
  line.long    0x00 "MB10,Message Buffer 10"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC8000+288.)&0x00200000)==0x00200000
group.long ((0xFFFC8000+288.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 10"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC8000+288.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 10"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC8000+288.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 10"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 10"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC8000+304.)++0x03
  line.long    0x00 "MB11,Message Buffer 11"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC8000+304.)&0x00200000)==0x00200000
group.long ((0xFFFC8000+304.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 11"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC8000+304.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 11"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC8000+304.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 11"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 11"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC8000+320.)++0x03
  line.long    0x00 "MB12,Message Buffer 12"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC8000+320.)&0x00200000)==0x00200000
group.long ((0xFFFC8000+320.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 12"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC8000+320.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 12"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC8000+320.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 12"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 12"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC8000+336.)++0x03
  line.long    0x00 "MB13,Message Buffer 13"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC8000+336.)&0x00200000)==0x00200000
group.long ((0xFFFC8000+336.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 13"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC8000+336.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 13"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC8000+336.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 13"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 13"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC8000+352.)++0x03
  line.long    0x00 "MB14,Message Buffer 14"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC8000+352.)&0x00200000)==0x00200000
group.long ((0xFFFC8000+352.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 14"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC8000+352.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 14"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC8000+352.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 14"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 14"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC8000+368.)++0x03
  line.long    0x00 "MB15,Message Buffer 15"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC8000+368.)&0x00200000)==0x00200000
group.long ((0xFFFC8000+368.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 15"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC8000+368.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 15"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC8000+368.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 15"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 15"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC8000+384.)++0x03
  line.long    0x00 "MB16,Message Buffer 16"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC8000+384.)&0x00200000)==0x00200000
group.long ((0xFFFC8000+384.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 16"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC8000+384.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 16"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC8000+384.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 16"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 16"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC8000+400.)++0x03
  line.long    0x00 "MB17,Message Buffer 17"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC8000+400.)&0x00200000)==0x00200000
group.long ((0xFFFC8000+400.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 17"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC8000+400.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 17"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC8000+400.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 17"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 17"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC8000+416.)++0x03
  line.long    0x00 "MB18,Message Buffer 18"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC8000+416.)&0x00200000)==0x00200000
group.long ((0xFFFC8000+416.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 18"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC8000+416.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 18"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC8000+416.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 18"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 18"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC8000+432.)++0x03
  line.long    0x00 "MB19,Message Buffer 19"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC8000+432.)&0x00200000)==0x00200000
group.long ((0xFFFC8000+432.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 19"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC8000+432.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 19"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC8000+432.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 19"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 19"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC8000+448.)++0x03
  line.long    0x00 "MB20,Message Buffer 20"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC8000+448.)&0x00200000)==0x00200000
group.long ((0xFFFC8000+448.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 20"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC8000+448.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 20"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC8000+448.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 20"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 20"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC8000+464.)++0x03
  line.long    0x00 "MB21,Message Buffer 21"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC8000+464.)&0x00200000)==0x00200000
group.long ((0xFFFC8000+464.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 21"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC8000+464.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 21"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC8000+464.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 21"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 21"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC8000+480.)++0x03
  line.long    0x00 "MB22,Message Buffer 22"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC8000+480.)&0x00200000)==0x00200000
group.long ((0xFFFC8000+480.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 22"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC8000+480.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 22"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC8000+480.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 22"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 22"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC8000+496.)++0x03
  line.long    0x00 "MB23,Message Buffer 23"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC8000+496.)&0x00200000)==0x00200000
group.long ((0xFFFC8000+496.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 23"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC8000+496.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 23"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC8000+496.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 23"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 23"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC8000+512.)++0x03
  line.long    0x00 "MB24,Message Buffer 24"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC8000+512.)&0x00200000)==0x00200000
group.long ((0xFFFC8000+512.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 24"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC8000+512.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 24"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC8000+512.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 24"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 24"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC8000+528.)++0x03
  line.long    0x00 "MB25,Message Buffer 25"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC8000+528.)&0x00200000)==0x00200000
group.long ((0xFFFC8000+528.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 25"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC8000+528.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 25"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC8000+528.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 25"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 25"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC8000+544.)++0x03
  line.long    0x00 "MB26,Message Buffer 26"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC8000+544.)&0x00200000)==0x00200000
group.long ((0xFFFC8000+544.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 26"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC8000+544.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 26"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC8000+544.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 26"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 26"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC8000+560.)++0x03
  line.long    0x00 "MB27,Message Buffer 27"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC8000+560.)&0x00200000)==0x00200000
group.long ((0xFFFC8000+560.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 27"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC8000+560.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 27"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC8000+560.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 27"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 27"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC8000+576.)++0x03
  line.long    0x00 "MB28,Message Buffer 28"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC8000+576.)&0x00200000)==0x00200000
group.long ((0xFFFC8000+576.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 28"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC8000+576.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 28"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC8000+576.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 28"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 28"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC8000+592.)++0x03
  line.long    0x00 "MB29,Message Buffer 29"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC8000+592.)&0x00200000)==0x00200000
group.long ((0xFFFC8000+592.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 29"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC8000+592.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 29"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC8000+592.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 29"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 29"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC8000+608.)++0x03
  line.long    0x00 "MB30,Message Buffer 30"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC8000+608.)&0x00200000)==0x00200000
group.long ((0xFFFC8000+608.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 30"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC8000+608.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 30"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC8000+608.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 30"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 30"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC8000+624.)++0x03
  line.long    0x00 "MB31,Message Buffer 31"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC8000+624.)&0x00200000)==0x00200000
group.long ((0xFFFC8000+624.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 31"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC8000+624.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 31"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC8000+624.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 31"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 31"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC8000+640.)++0x03
  line.long    0x00 "MB32,Message Buffer 32"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC8000+640.)&0x00200000)==0x00200000
group.long ((0xFFFC8000+640.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 32"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC8000+640.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 32"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC8000+640.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 32"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 32"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC8000+656.)++0x03
  line.long    0x00 "MB33,Message Buffer 33"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC8000+656.)&0x00200000)==0x00200000
group.long ((0xFFFC8000+656.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 33"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC8000+656.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 33"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC8000+656.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 33"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 33"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC8000+672.)++0x03
  line.long    0x00 "MB34,Message Buffer 34"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC8000+672.)&0x00200000)==0x00200000
group.long ((0xFFFC8000+672.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 34"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC8000+672.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 34"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC8000+672.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 34"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 34"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC8000+688.)++0x03
  line.long    0x00 "MB35,Message Buffer 35"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC8000+688.)&0x00200000)==0x00200000
group.long ((0xFFFC8000+688.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 35"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC8000+688.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 35"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC8000+688.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 35"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 35"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC8000+704.)++0x03
  line.long    0x00 "MB36,Message Buffer 36"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC8000+704.)&0x00200000)==0x00200000
group.long ((0xFFFC8000+704.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 36"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC8000+704.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 36"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC8000+704.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 36"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 36"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC8000+720.)++0x03
  line.long    0x00 "MB37,Message Buffer 37"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC8000+720.)&0x00200000)==0x00200000
group.long ((0xFFFC8000+720.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 37"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC8000+720.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 37"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC8000+720.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 37"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 37"
  hexmask.byte 0x04 00.--07. 1.            "Byte 4-7 ,Data Byte 4"
  hexmask.byte 0x05 00.--07. 1.          " ,Data Byte 5"
  hexmask.byte 0x06 00.--07. 1.          " ,Data Byte 6"
  hexmask.byte 0x07 00.--07. 1.          " ,Data Byte 7"

TEXTLINE ""

group.long (0xFFFC8000+736.)++0x03
  line.long    0x00 "MB38,Message Buffer 38"
  
  bitfld.long  0x00 24.--27.               "CODE ,Message buffer code" "NOT ACTIVE,RX BUSY,RX FULL,RX BUSY,RX EMPTY,RX BUSY,OVERRUN,RX BUSY,TX NOT RDY,res.,TX RESP,res.,TX ONCE->RX,res.,TX ONCE->TX,res."
  bitfld.long  0x00 22.                  "  SRR ,Substitute remote request" "0,1"
  bitfld.long  0x00 21.                  "  IDE ,ID extended bit" "STD,EXT"
  bitfld.long  0x00 20.                  "  RTR ,Remote transmission request" "0,1"
  bitfld.long  0x00 16.--19.             "  LENGTH ,Length of data in bytes" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--15. 1.          "  TIMESTAMP ,Free-running counter time stamp"

if (d.l(anc:0xFFFC8000+736.)&0x00200000)==0x00200000
group.long ((0xFFFC8000+736.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 38"
  hexmask.long 0x00 00.--28. 1.            "ID   ,Frame identifier (extended format)"
else
group.long ((0xFFFC8000+736.)+0x04)++0x03
  line.long    0x00 "    ,Message Buffer 38"
  hexmask.word 0x00 2.--12. 1.            "ID       ,Frame identifier (standard format)"
endif

group.long ((0xFFFC8000+736.)+0x08)++0x07
  line.long    0x00 "    ,Message Buffer 38"
  hexmask.byte 0x00 00.--07. 1.            "Byte 0-3 ,Data Byte 0"
  hexmask.byte 0x01 00.--07. 1.          " ,Data Byte 1"
  hexmask.byte 0x02 00.--07. 1.          " ,Data Byte 2"
  hexmask.byte 0x03 00.--07. 1.          " ,Data Byte 3"
  line.long    0x04 "    ,Message Buffer 38"
