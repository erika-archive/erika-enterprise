  bitfld.word 0x04 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x04 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x04 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x04 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x04 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x04 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x06 "PCR031,Pad Configuration Register 031"
  bitfld.word 0x06 10.--12.       "PA , Pin assignment" "GPIO,DATA03,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x06 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x06 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x06 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x06 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x06 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x06 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x06 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x08 "PCR032,Pad Configuration Register 032"
  bitfld.word 0x08 10.--12.       "PA , Pin assignment" "GPIO,DATA04,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x08 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x08 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x08 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x08 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x08 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x08 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x08 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0a "PCR033,Pad Configuration Register 033"
  bitfld.word 0x0a 10.--12.       "PA , Pin assignment" "GPIO,DATA05,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x0a 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0a 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0a 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x0a 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x0a 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0a 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0a 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0c "PCR034,Pad Configuration Register 034"
  bitfld.word 0x0c 10.--12.       "PA , Pin assignment" "GPIO,DATA06,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x0c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0c 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x0c 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x0c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0c 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0e "PCR035,Pad Configuration Register 035"
  bitfld.word 0x0e 10.--12.       "PA , Pin assignment" "GPIO,DATA07,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x0e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0e 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x0e 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x0e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0e 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0e 00.            "  WPS , Weak pull up/down select" "0,1"

TEXTLINE ""
  line.word 0x10 "PCR036,Pad Configuration Register 036"
  bitfld.word 0x10 10.--12.       "PA , Pin assignment" "GPIO,DATA08,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x10 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x10 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x10 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x10 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x10 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x10 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x10 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x12 "PCR037,Pad Configuration Register 037"
  bitfld.word 0x12 10.--12.       "PA , Pin assignment" "GPIO,DATA09,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x12 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x12 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x12 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x12 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x12 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x12 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x12 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x14 "PCR038,Pad Configuration Register 038"
  bitfld.word 0x14 10.--12.       "PA , Pin assignment" "GPIO,DATA10,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x14 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x14 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x14 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x14 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x14 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x14 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x14 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x16 "PCR039,Pad Configuration Register 039"
  bitfld.word 0x16 10.--12.       "PA , Pin assignment" "GPIO,DATA11,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x16 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x16 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x16 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x16 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x16 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x16 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x16 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x18 "PCR040,Pad Configuration Register 040"
  bitfld.word 0x18 10.--12.       "PA , Pin assignment" "GPIO,DATA12,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x18 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x18 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x18 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x18 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x18 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x18 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x18 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x1A "PCR041,Pad Configuration Register 041"
  bitfld.word 0x1A 10.--12.       "PA , Pin assignment" "GPIO,DATA13,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x1A 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x1A 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x1A 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x1A 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x1A 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x1A 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x1A 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x1c "PCR042,Pad Configuration Register 042"
  bitfld.word 0x1c 10.--12.       "PA , Pin assignment" "GPIO,DATA14,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x1c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x1c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x1c 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x1c 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x1c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x1c 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x1c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x1e "PCR043,Pad Configuration Register 043"
  bitfld.word 0x1e 10.--12.       "PA , Pin assignment" "GPIO,DATA15,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x1e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x1e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x1e 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x1e 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x1e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x1e 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x1e 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900BC++0x01 "PCR062: RD/!WR"
  line.word 0x00 "PCR062,Pad Configuration Register 062"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,RD/!WR,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900BE++0x01 "PCR063: !BDIP"
  line.word 0x00 "PCR063,Pad Configuration Register 063"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,!BDIP,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900C0++0x03 "PCR064-065: !WE_BE[0:3]"
  line.word 0x00 "PCR064,Pad Configuration Register 064"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,!WE0_BE0,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR065,Pad Configuration Register 065"
  bitfld.word 0x02 10.--12.       "PA , Pin assignment" "GPIO,!WE1_BE1,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x02 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900C8++0x01 "PCR068: !OE"
  line.word 0x00 "PCR068,Pad Configuration Register 068"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,!OE,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900CA++0x01 "PCR069: !TS"
  line.word 0x00 "PCR069,Pad Configuration Register 069"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,!TS,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900CC++0x01 "PCR070: !TA"
  line.word 0x00 "PCR070,Pad Configuration Register 070"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,!TA,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900D0++0x01 "PCR072: GPIO"
  line.word 0x00 "PCR072,Pad Configuration Register 072"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,res.,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900D2++0x01 "PCR073: GPIO"
  line.word 0x00 "PCR073,Pad Configuration Register 073"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,res.,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900D6++0x0f "PCR075-PCR082: MDO[4:11]"
  line.word 0x00 "PCR075,Pad Configuration Register 075"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO/MDO04,res.,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR076,Pad Configuration Register 076"
  bitfld.word 0x02 10.--12.       "PA , Pin assignment" "GPIO/MDO05,res.,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x02 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x04 "PCR077,Pad Configuration Register 077"
  bitfld.word 0x04 10.--12.       "PA , Pin assignment" "GPIO/MDO06,res.,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x04 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x04 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x04 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x04 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x04 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x04 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x04 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x06 "PCR078,Pad Configuration Register 078"
  bitfld.word 0x06 10.--12.       "PA , Pin assignment" "GPIO/MDO07,res.,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x06 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x06 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x06 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x06 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x06 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x06 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x06 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x08 "PCR079,Pad Configuration Register 079"
  bitfld.word 0x08 10.--12.       "PA , Pin assignment" "GPIO/MDO08,res.,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x08 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x08 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x08 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x08 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x08 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x08 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x08 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0a "PCR080,Pad Configuration Register 080"
  bitfld.word 0x0a 10.--12.       "PA , Pin assignment" "GPIO/MDO09,res.,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x0a 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0a 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0a 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x0a 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x0a 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0a 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0a 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0c "PCR081,Pad Configuration Register 081"
  bitfld.word 0x0c 10.--12.       "PA , Pin assignment" "GPIO/MDO10,res.,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x0c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0c 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x0c 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x0c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0c 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0e "PCR082,Pad Configuration Register 082"
  bitfld.word 0x0e 10.--12.       "PA , Pin assignment" "GPIO/MDO11,res.,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x0e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0e 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x0e 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x0e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0e 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0e 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900E6++0x01 "PCR083: CNTX_A"
  line.word 0x00 "PCR083,Pad Configuration Register 083"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,CNTX_A,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900E8++0x01 "PCR084: CNRX_A"
  line.word 0x00 "PCR084,Pad Configuration Register 084"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,CNRX_A,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900EA++0x01 "PCR085: CNTX_B / DSPI PCSC3"
  line.word 0x00 "PCR085,Pad Configuration Register 085"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,CNTX_B,PCSC3,CNTX_B,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900EC++0x01 "PCR086: CNRX_B / DSPI PCSC4"
  line.word 0x00 "PCR086,Pad Configuration Register 086"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,CNRX_B,PCSC4,CNRX_B,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900EE++0x01 "PCR087: CNTX_C / DSPI PCSD3"
  line.word 0x00 "PCR087,Pad Configuration Register 087"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,CNTX_C,PCSD3,CNTX_C,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900F0++0x01 "PCR088: CNRX_C / DSPI PCSD4"
  line.word 0x00 "PCR088,Pad Configuration Register 088"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,CNRX_C,PCSD4,CNRX_C,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900F2++0x01 "PCR089: TXD_A"
  line.word 0x00 "PCR089,Pad Configuration Register 089"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,TXD_A,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900F4++0x01 "PCR090: RXD_A"
  line.word 0x00 "PCR090,Pad Configuration Register 090"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,RXD_A,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900F6++0x01 "PCR091: TXD_B / DSPI PCSD1"
  line.word 0x00 "PCR091,Pad Configuration Register 091"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,TXD_B,PCSD1,TXD_B,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900F8++0x01 "PCR092: RXD_B / PCSD5"
  line.word 0x00 "PCR092,Pad Configuration Register 092"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,RXD_B,PCSD5,RXD_B,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900FA++0x01 "PCR093: DSPI SCK_A / DSPI PCSC1"
  line.word 0x00 "PCR093,Pad Configuration Register 093"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,SCK_A,PCSC1,SCK_A,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900FC++0x01 "PCR094: DSPI SIN_A / DSPI PCSC2"
  line.word 0x00 "PCR094,Pad Configuration Register 094"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,SIN_A,PCSC2,SIN_A,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900FE++0x01 "PCR095: DSPI SOUT_A / DSPI PCSC5"
  line.word 0x00 "PCR095,Pad Configuration Register 095"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,SOUT_A,PCSC5,SOUT_A,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90100++0x01 "PCR096: DSPI PCSA0 / DSPI PCSD2"
  line.word 0x00 "PCR096,Pad Configuration Register 096"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,PCSA0,PCSD2,PCSA0,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90102++0x01 "PCR097: DSPI PCSA1 / PCSB2"
  line.word 0x00 "PCR097,Pad Configuration Register 097"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,PCSA1,PCSB2,PCSA1,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90104++0x01 "PCR098: DSPI PCSA2 / DSPI SCKD"
  line.word 0x00 "PCR098,Pad Configuration Register 098"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,PCSA2,SCKD,PCSA2,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90106++0x01 "PCR099: DSPI PCSA3 / DSPI SIN_D"
  line.word 0x00 "PCR099,Pad Configuration Register 099"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,PCSA3,SIN_D,PCSA3,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90108++0x01 "PCR100: DSPI PCSA4 / DSPI SOUTD"
  line.word 0x00 "PCR100,Pad Configuration Register 100"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,PCSA4,SOUTD,PCSA4,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F9010a++0x01 "PCR101: DSPI PCSA5 / DSPI PCSB3"
  line.word 0x00 "PCR101,Pad Configuration Register 101"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,PCSA5,PCSB3,PCSA5,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F9010c++0x01 "PCR102: DSPI SCKB / DSPI PCSC1"
  line.word 0x00 "PCR102,Pad Configuration Register 102"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,SCKB,PCSC1,SCKB,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F9010e++0x01 "PCR103: DSPI SINB / DSPI PCSC2"
  line.word 0x00 "PCR103,Pad Configuration Register 103"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,SINB,PCSC2,SINB,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90110++0x01 "PCR104: DSPI SOUTB / DSPI PCSC5"
  line.word 0x00 "PCR104,Pad Configuration Register 104"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,SOUTB,PCSC5,SOUTB,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90112++0x01 "PCR105: DSPI PCSB0 / DSPI PCSD2"
  line.word 0x00 "PCR105,Pad Configuration Register 105"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,PCSB0,PCSD2,PCSB0,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90114++0x01 "PCR106: DSPI PCSB1 / DSPI PCSD0"
  line.word 0x00 "PCR106,Pad Configuration Register 106"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,PCSB1,PCSD0,PCSB1,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90116++0x01 "PCR107: DSPI PCSB2 / DSPI SOUTC"
  line.word 0x00 "PCR107,Pad Configuration Register 107"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,PCSB2,SOUTC,PCSB2,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90118++0x01 "PCR108: DSPI PCSB3 / DSPI SINC"
  line.word 0x00 "PCR108,Pad Configuration Register 108"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,PCSB3,SINC,PCSB3,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F9011A++0x01 "PCR109: DSPI PCSB4 / DSPI SCKC"
  line.word 0x00 "PCR109,Pad Configuration Register 109"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,PCSB4,SCKC,PCSB4,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F9011C++0x01 "PCR110: DSPI PCSB5 / DSPI PCSC0"
  line.word 0x00 "PCR110,Pad Configuration Register 110"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,PCSB5,PCSC0,PCSB5,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F9011E++0x03 "PCR111-112: ETRIG[0:1]"
  line.word 0x00 "PCR111,Pad Configuration Register 111"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,ETRIG0,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR112,Pad Configuration Register 112"
  bitfld.word 0x02 10.--12.       "PA , Pin assignment" "GPIO,ETRIG1,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x02 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90122++0x01 "PCR113: TCRCLKA / IRQ7"
  line.word 0x00 "PCR113,Pad Configuration Register 113"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,TCRCLKA,IRQ7,TCRCLKA.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90124++0x3F "PCR114-145: ETPUA[0:31] / ETPUA[12:23] / PCSB[1:4] / IRQ[8:15] / PCDC[1:4] / PCSD[1:4]"
  line.word 0x00 "PCR114,Pad Configuration Register 114"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,ETPUA00,ETPUA12,ETPUA00,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR115,Pad Configuration Register 115"
  bitfld.word 0x02 10.--12.       "PA , Pin assignment" "GPIO,ETPUA01,ETPUA13,ETPUA01,res.,res.,res.,res.      "
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x02 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x04 "PCR116,Pad Configuration Register 116"
  bitfld.word 0x04 10.--12.       "PA , Pin assignment" "GPIO,ETPUA02,ETPUA14,ETPUA02,res.,res.,res.,res.      "
  bitfld.word 0x04 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x04 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x04 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x04 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x04 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x04 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x04 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x06 "PCR117,Pad Configuration Register 117"
  bitfld.word 0x06 10.--12.       "PA , Pin assignment" "GPIO,ETPUA03,ETPUA15,ETPUA03,res.,res.,res.,res.      "
  bitfld.word 0x06 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x06 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x06 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x06 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x06 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x06 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x06 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x08 "PCR118,Pad Configuration Register 118"
  bitfld.word 0x08 10.--12.       "PA , Pin assignment" "GPIO,ETPUA04,ETPUA16,ETPUA04,res.,res.,res.,res.      "
  bitfld.word 0x08 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x08 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x08 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x08 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x08 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x08 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x08 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0a "PCR119,Pad Configuration Register 119"
  bitfld.word 0x0a 10.--12.       "PA , Pin assignment" "GPIO,ETPUA05,ETPUA17,ETPUA05,res.,res.,res.,res.      "
  bitfld.word 0x0a 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0a 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0a 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x0a 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0a 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x0a 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0a 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0c "PCR120,Pad Configuration Register 120"
  bitfld.word 0x0c 10.--12.       "PA , Pin assignment" "GPIO,ETPUA06,ETPUA18,ETPUA06,res.,res.,res.,res.      "
  bitfld.word 0x0c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0c 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x0c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0c 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x0c 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0e "PCR121,Pad Configuration Register 121"
  bitfld.word 0x0e 10.--12.       "PA , Pin assignment" "GPIO,ETPUA07,ETPUA19,ETPUA07,res.,res.,res.,res.      "
  bitfld.word 0x0e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0e 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x0e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0e 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x0e 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0e 00.            "  WPS , Weak pull up/down select" "0,1"

TEXTLINE "" 
  line.word 0x10 "PCR122,Pad Configuration Register 122"
  bitfld.word 0x10 10.--12.       "PA , Pin assignment" "GPIO,ETPUA08,ETPUA20,ETPUA08,res.,res.,res.,res.      "
  bitfld.word 0x10 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x10 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x10 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x10 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x10 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x10 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x10 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x12 "PCR123,Pad Configuration Register 123"
  bitfld.word 0x12 10.--12.       "PA , Pin assignment" "GPIO,ETPUA09,ETPUA21,ETPUA09,res.,res.,res.,res.      "
  bitfld.word 0x12 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x12 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x12 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x12 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x12 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x12 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x12 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x14 "PCR124,Pad Configuration Register 124"
  bitfld.word 0x14 10.--12.       "PA , Pin assignment" "GPIO,ETPUA10,ETPUA22,ETPUA10,res.,res.,res.,res.      "
  bitfld.word 0x14 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x14 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x14 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x14 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x14 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x14 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x14 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x16 "PCR125,Pad Configuration Register 125"
  bitfld.word 0x16 10.--12.       "PA , Pin assignment" "GPIO,ETPUA11,ETPUA23,ETPUA11,res.,res.,res.,res.      "
  bitfld.word 0x16 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x16 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x16 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x16 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x16 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x16 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x16 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x18 "PCR126,Pad Configuration Register 126"
  bitfld.word 0x18 10.--12.       "PA , Pin assignment" "GPIO,ETPUA12,PCSB1,ETPUA12,res.,res.,res.,res.      "
  bitfld.word 0x18 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x18 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x18 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x18 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x18 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x18 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x18 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x1A "PCR127,Pad Configuration Register 127"
  bitfld.word 0x1A 10.--12.       "PA , Pin assignment" "GPIO,ETPUA13,PCSB3,ETPUA13,res.,res.,res.,res.      "
  bitfld.word 0x1A 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x1A 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x1A 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x1A 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x1A 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x1A 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x1A 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x1c "PCR128,Pad Configuration Register 128"
  bitfld.word 0x1c 10.--12.       "PA , Pin assignment" "GPIO,ETPUA14,PCSB4,ETPUA14,res.,res.,res.,res.      "
  bitfld.word 0x1c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x1c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x1c 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x1c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x1c 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x1c 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x1c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x1e "PCR129,Pad Configuration Register 129"
  bitfld.word 0x1e 10.--12.       "PA , Pin assignment" "GPIO,ETPUA15,PCSB5,ETPUA15,res.,res.,res.,res.      "
  bitfld.word 0x1e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x1e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x1e 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x1e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x1e 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x1e 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x1e 00.            "  WPS , Weak pull up/down select" "0,1"

TEXTLINE ""
  line.word 0x20 "PCR130,Pad Configuration Register 130"
  bitfld.word 0x20 10.--12.       "PA , Pin assignment" "GPIO,ETPUA16,PCSD1,ETPUA16,res.,res.,res.,res.      "
  bitfld.word 0x20 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x20 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x20 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x20 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x20 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x20 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x20 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x22 "PCR131,Pad Configuration Register 131"
  bitfld.word 0x22 10.--12.       "PA , Pin assignment" "GPIO,ETPUA17,PCSD2,ETPUA17,res.,res.,res.,res.      "
  bitfld.word 0x22 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x22 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x22 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x22 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x22 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x22 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x22 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x24 "PCR132,Pad Configuration Register 132"
  bitfld.word 0x24 10.--12.       "PA , Pin assignment" "GPIO,ETPUA18,PCSD3,ETPUA18,res.,res.,res.,res.      "
  bitfld.word 0x24 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x24 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x24 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x24 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x24 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x24 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x24 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x26 "PCR133,Pad Configuration Register 133"
  bitfld.word 0x26 10.--12.       "PA , Pin assignment" "GPIO,ETPUA19,PCSD4,ETPUA19,res.,res.,res.,res.      "
  bitfld.word 0x26 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x26 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x26 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x26 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x26 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x26 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x26 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x28 "PCR134,Pad Configuration Register 134"
  bitfld.word 0x28 10.--12.       "PA , Pin assignment" "GPIO,ETPUA20,IRQ08,ETPUA20,res.,res.,res.,res.      "
  bitfld.word 0x28 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x28 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x28 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x28 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x28 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x28 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x28 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x2a "PCR135,Pad Configuration Register 135"
  bitfld.word 0x2a 10.--12.       "PA , Pin assignment" "GPIO,ETPUA21,IRQ09,ETPUA21,res.,res.,res.,res.      "
  bitfld.word 0x2a 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x2a 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x2a 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x2a 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x2a 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x2a 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x2a 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x2c "PCR136,Pad Configuration Register 136"
  bitfld.word 0x2c 10.--12.       "PA , Pin assignment" "GPIO,ETPUA22,IRQ10,ETPUA22,res.,res.,res.,res.      "
  bitfld.word 0x2c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x2c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x2c 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x2c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x2c 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x2c 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x2c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x2e "PCR137,Pad Configuration Register 137"
  bitfld.word 0x2e 10.--12.       "PA , Pin assignment" "GPIO,ETPUA23,IRQ11,ETPUA23,res.,res.,res.,res.      "
  bitfld.word 0x2e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x2e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x2e 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x2e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x2e 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x2e 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x2e 00.            "  WPS , Weak pull up/down select" "0,1"

TEXTLINE ""
  line.word 0x30 "PCR138,Pad Configuration Register 138"
  bitfld.word 0x30 10.--12.       "PA , Pin assignment" "GPIO,ETPUA24,IRQ12,ETPUA24,res.,res.,res.,res.      "
  bitfld.word 0x30 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x30 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x30 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x30 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x30 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x30 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x30 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x32 "PCR139,Pad Configuration Register 139"
  bitfld.word 0x32 10.--12.       "PA , Pin assignment" "GPIO,ETPUA25,IRQ13,ETPUA25,res.,res.,res.,res.      "
  bitfld.word 0x32 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x32 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x32 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x32 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x32 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x32 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x32 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x34 "PCR140,Pad Configuration Register 140"
  bitfld.word 0x34 10.--12.       "PA , Pin assignment" "GPIO,ETPUA26,IRQ14,ETPUA26,res.,res.,res.,res.      "
  bitfld.word 0x34 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x34 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x34 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x34 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x34 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x34 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x34 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x36 "PCR141,Pad Configuration Register 141"
  bitfld.word 0x36 10.--12.       "PA , Pin assignment" "GPIO,ETPUA27,IRQ15,ETPUA27,res.,res.,res.,res.      "
  bitfld.word 0x36 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x36 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x36 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x36 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x36 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x36 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x36 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x38 "PCR142,Pad Configuration Register 142"
  bitfld.word 0x38 10.--12.       "PA , Pin assignment" "GPIO,ETPUA28,PCSC1,ETPUA28,res.,res.,res.,res.      "
  bitfld.word 0x38 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x38 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x38 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x38 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x38 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x38 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x38 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x3a "PCR143,Pad Configuration Register 143"
  bitfld.word 0x3a 10.--12.       "PA , Pin assignment" "GPIO,ETPUA29,PCSC2,ETPUA29,res.,res.,res.,res.      "
  bitfld.word 0x3a 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x3a 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x3a 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x3a 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x3a 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x3a 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x3a 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x3c "PCR144,Pad Configuration Register 144"
  bitfld.word 0x3c 10.--12.       "PA , Pin assignment" "GPIO,ETPUA30,PCSC3,ETPUA30,res.,res.,res.,res.      "
  bitfld.word 0x3c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x3c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x3c 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x3c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x3c 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x3c 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x3c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x3e "PCR145,Pad Configuration Register 145"
  bitfld.word 0x3e 10.--12.       "PA , Pin assignment" "GPIO,ETPUA31,PCSC4,ETPUA31,res.,res.,res.,res.      "
  bitfld.word 0x3e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x3e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x3e 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x3e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x3e 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x3e 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x3e 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F901A6++0x31 "PCR179-202: EMIOS[0:23] / ETPUA[0:9] / SOUTC / SOUTD / IRQ[0:1] / ETPUB[0:7]"
  line.word 0x00 "PCR179,Pad Configuration Register 179"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,EMIOS00,ETPUA00,EMIOS00,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR180,Pad Configuration Register 180"
  bitfld.word 0x02 10.--12.       "PA , Pin assignment" "GPIO,EMIOS01,ETPUA01,EMIOS01,res.,res.,res.,res.      "
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x02 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x04 "PCR181,Pad Configuration Register 181"
  bitfld.word 0x04 10.--12.       "PA , Pin assignment" "GPIO,EMIOS02,ETPUA02,EMIOS02,res.,res.,res.,res.      "
  bitfld.word 0x04 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x04 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x04 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x04 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x04 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x04 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x04 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x06 "PCR182,Pad Configuration Register 182"
  bitfld.word 0x06 10.--12.       "PA , Pin assignment" "GPIO,EMIOS03,ETPUA03,EMIOS03,res.,res.,res.,res.      "
  bitfld.word 0x06 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x06 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x06 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x06 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x06 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x06 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x06 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x08 "PCR183,Pad Configuration Register 183"
  bitfld.word 0x08 10.--12.       "PA , Pin assignment" "GPIO,EMIOS04,ETPUA04,EMIOS04,res.,res.,res.,res.      "
  bitfld.word 0x08 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x08 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x08 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x08 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x08 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x08 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x08 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0a "PCR184,Pad Configuration Register 184"
  bitfld.word 0x0a 10.--12.       "PA , Pin assignment" "GPIO,EMIOS05,ETPUA05,EMIOS05,res.,res.,res.,res.      "
  bitfld.word 0x0a 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0a 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0a 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x0a 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0a 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x0a 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0a 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0c "PCR185,Pad Configuration Register 185"
  bitfld.word 0x0c 10.--12.       "PA , Pin assignment" "GPIO,EMIOS06,ETPUA06,EMIOS06,res.,res.,res.,res.      "
  bitfld.word 0x0c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0c 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x0c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0c 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x0c 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0e "PCR186,Pad Configuration Register 186"
  bitfld.word 0x0e 10.--12.       "PA , Pin assignment" "GPIO,EMIOS07,ETPUA07,EMIOS07,res.,res.,res.,res.      "
  bitfld.word 0x0e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0e 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x0e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0e 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x0e 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0e 00.            "  WPS , Weak pull up/down select" "0,1"

TEXTLINE "" 
  line.word 0x10 "PCR187,Pad Configuration Register 187"
  bitfld.word 0x10 10.--12.       "PA , Pin assignment" "GPIO,EMIOS08,ETPUA08,EMIOS08,res.,res.,res.,res.      "
  bitfld.word 0x10 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x10 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x10 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x10 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x10 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x10 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x10 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x12 "PCR188,Pad Configuration Register 188"
  bitfld.word 0x12 10.--12.       "PA , Pin assignment" "GPIO,EMIOS09,ETPUA09,EMIOS09,res.,res.,res.,res.      "
  bitfld.word 0x12 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x12 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x12 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x12 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x12 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x12 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x12 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x14 "PCR189,Pad Configuration Register 189"
  bitfld.word 0x14 10.--12.       "PA , Pin assignment" "GPIO,EMIOS10,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x14 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x14 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x14 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x14 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x14 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x14 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x14 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x16 "PCR190,Pad Configuration Register 190"
  bitfld.word 0x16 10.--12.       "PA , Pin assignment" "GPIO,EMIOS11,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x16 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x16 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x16 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x16 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x16 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x16 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x16 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x18 "PCR191,Pad Configuration Register 191"
  bitfld.word 0x18 10.--12.       "PA , Pin assignment" "GPIO,EMIOS12,SOUTC,EMIOS12,res.,res.,res.,res.      "
  bitfld.word 0x18 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x18 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x18 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x18 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x18 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x18 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x18 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x1A "PCR192,Pad Configuration Register 192"
  bitfld.word 0x1A 10.--12.       "PA , Pin assignment" "GPIO,EMIOS13,SOUTD,EMIOS13,res.,res.,res.,res.      "
  bitfld.word 0x1A 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x1A 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x1A 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x1A 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x1A 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x1A 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x1A 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x1c "PCR193,Pad Configuration Register 193"
  bitfld.word 0x1c 10.--12.       "PA , Pin assignment" "GPIO,EMIOS14,IRQ00,EMIOS14,res.,res.,res.,res.      "
  bitfld.word 0x1c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x1c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x1c 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x1c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x1c 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x1c 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x1c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x1e "PCR194,Pad Configuration Register 194"
  bitfld.word 0x1e 10.--12.       "PA , Pin assignment" "GPIO,EMIOS15,IRQ01,EMIOS15,res.,res.,res.,res.      "
  bitfld.word 0x1e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x1e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x1e 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x1e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x1e 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x1e 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x1e 00.            "  WPS , Weak pull up/down select" "0,1"

TEXTLINE ""
  line.word 0x20 "PCR195,Pad Configuration Register 195"
  bitfld.word 0x20 10.--12.       "PA , Pin assignment" "GPIO,EMIOS16,ETPUB00,EMIOS16,res.,res.,res.,res.      "
  bitfld.word 0x20 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x20 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x20 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x20 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x20 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x20 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x20 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x22 "PCR196,Pad Configuration Register 196"
  bitfld.word 0x22 10.--12.       "PA , Pin assignment" "GPIO,EMIOS17,ETPUB01,EMIOS17,res.,res.,res.,res.      "
  bitfld.word 0x22 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x22 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x22 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x22 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x22 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x22 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x22 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x24 "PCR197,Pad Configuration Register 197"
  bitfld.word 0x24 10.--12.       "PA , Pin assignment" "GPIO,EMIOS18,ETPUB02,EMIOS18,res.,res.,res.,res.      "
  bitfld.word 0x24 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x24 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x24 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x24 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x24 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x24 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x24 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x26 "PCR198,Pad Configuration Register 198"
  bitfld.word 0x26 10.--12.       "PA , Pin assignment" "GPIO,EMIOS19,ETPUB03,EMIOS19,res.,res.,res.,res.      "
  bitfld.word 0x26 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x26 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x26 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x26 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x26 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x26 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x26 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x28 "PCR199,Pad Configuration Register 199"
  bitfld.word 0x28 10.--12.       "PA , Pin assignment" "GPIO,EMIOS20,ETPUB04,EMIOS20,res.,res.,res.,res.      "
  bitfld.word 0x28 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x28 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x28 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x28 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x28 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x28 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x28 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x2a "PCR200,Pad Configuration Register 200"
  bitfld.word 0x2a 10.--12.       "PA , Pin assignment" "GPIO,EMIOS21,ETPUB05,EMIOS21,res.,res.,res.,res.      "
  bitfld.word 0x2a 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x2a 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x2a 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x2a 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x2a 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x2a 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x2a 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x2c "PCR201,Pad Configuration Register 201"
  bitfld.word 0x2c 10.--12.       "PA , Pin assignment" "GPIO,EMIOS22,ETPUB06,EMIOS22,res.,res.,res.,res.      "
  bitfld.word 0x2c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x2c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x2c 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x2c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x2c 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x2c 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x2c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x2e "PCR202,Pad Configuration Register 202"
  bitfld.word 0x2e 10.--12.       "PA , Pin assignment" "GPIO,EMIOS23,ETPUB07,EMIOS23,res.,res.,res.,res.      "
  bitfld.word 0x2e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x2e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x2e 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x2e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x2e 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x2e 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x2e 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F901D6++0x09 "PCR203-207: GPIO / EMIOS[14:15]"
  line.word 0x00 "PCR203,Pad Configuration Register 203"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "EMIOS14,GPIO,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR204,Pad Configuration Register 204"
  bitfld.word 0x02 10.--12.       "PA , Pin assignment" "EMIOS15,GPIO,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x02 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x04 "PCR205,Pad Configuration Register 205"
  bitfld.word 0x04 10.--12.       "PA , Pin assignment" "GPIO,res.,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x04 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x04 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x04 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x04 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x04 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x04 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x04 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x06 "PCR206,Pad Configuration Register 206"
  bitfld.word 0x06 10.--12.       "PA , Pin assignment" "GPIO,res.,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x06 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x06 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x06 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x06 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x06 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x06 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x06 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x08 "PCR207,Pad Configuration Register 207"
  bitfld.word 0x08 10.--12.       "PA , Pin assignment" "GPIO,res.,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x08 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x08 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x08 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x08 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x08 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x08 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x08 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F901E0++0x03 "PCR208-209: PLLCFG[0:1] / IRQ[4:5] / SOUTD"
  line.word 0x00 "PCR208,Pad Configuration Register 208"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,PLLCFG0,IRQ04,PLLCFG0,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR209,Pad Configuration Register 209"
  bitfld.word 0x02 10.--12.       "PA , Pin assignment" "GPIO,PLLCFG1,IRQ05,PLLCFG1,SOUTD,res.,res.,res.      "
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x02 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F901E4++0x01 "PCR210: !RSCFG"
  line.word 0x00 "PCR210,Pad Configuration Register 210"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,!RSCFG,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F901E6++0x03 "PCR211-212: BOOTCFG[0:1] / IRQ[2:3]"
  line.word 0x00 "PCR211,Pad Configuration Register 211"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,BOOTCFG0,IRQ02,BOOTCFG0,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR212,Pad Configuration Register 212"
  bitfld.word 0x02 10.--12.       "PA , Pin assignment" "GPIO,BOOTCFG1,IRQ03,BOOTCFG0,res.,res.,res.,res.      "
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x02 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F901EA++0x01 "PCR213: WKPCFG"
  line.word 0x00 "PCR213,Pad Configuration Register 213"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,WKPCFG,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F901EC++0x01 "PCR214: ENGCLK"
  line.word 0x00 "PCR214,Pad Configuration Register 214"

; bitfld.word 0x00 10.--13.       "PA , Pin assignment" "   0,   1,   2,   3,   4,   5,   6,   7,   8,   9,   A,   B,   C,   D,   E,   F"
  bitfld.word 0x00 09.            "         OBE , Output buffer enable" "0,1"
; bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "         DSC , Drive strength control" "10pF,20pF,30pF,50pF"
; bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
; bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
; bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
; bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
; bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

group 0xC3F901EE++0x01 "PCR215: AN12 / MA0 / !SDS"
  line.word 0x00 "PCR215,Pad Configuration Register 215"

  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "!SDS,res.,MA0,AN12,res.,res.,res.,res.      "
;  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
;  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
; bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
;  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
;  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
;  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F901F0++0x01 "PCR216: AN13 / MA1 / SDO"
  line.word 0x00 "PCR216,Pad Configuration Register 216"

  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "SDO,res.,MA1,AN13,res.,res.,res.,res.      "
;  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
;  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
; bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
;  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
;  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
;  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F901F2++0x01 "PCR217: AN14 / MA2 / SDI"
  line.word 0x00 "PCR217,Pad Configuration Register 217"

  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "SDI,res.,MA2,AN14,res.,res.,res.,res.      "
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F901F4++0x01 "PCR218: AN15 / FCK"
  line.word 0x00 "PCR218,Pad Configuration Register 218"

  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "FCK,AN15,res.,res.,res.,res.,res.,res.      "
;  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
;  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
; bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
;  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
;  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
;  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F901F6++0x01 "PCR219: MCKO"
  line.word 0x00 "PCR219,Pad Configuration Register 219"

;  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "   0,   1,   2,   3,   4,   5,   6,   7,   8,   9,   A,   B,   C,   D,   E,   F"
;  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
;  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "                       DSC , Drive strength control" "10pF,20pF,30pF,50pF"
;  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
;  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
;  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
;  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
;  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

group 0xC3F901F8++0x09 "PCR220-223: MDO[0:3]"
  line.word 0x00 "PCR220,Pad Configuration Register 220"

;  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "   0,   1,   2,   3,   4,   5,   6,   7,   8,   9,   A,   B,   C,   D,   E,   F"
;  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
;  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "                       DSC , Drive strength control" "10pF,20pF,30pF,50pF"
;  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
;  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
;  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
;  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
;  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"
  line.word 0x02 "PCR221,Pad Configuration Register 221"

;  bitfld.word 0x02 10.--13.       "PA , Pin assignment" "   0,   1,   2,   3,   4,   5,   6,   7,   8,   9,   A,   B,   C,   D,   E,   F"
;  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
;  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 06.--07.       "                       DSC , Drive strength control" "10pF,20pF,30pF,50pF"
;  bitfld.word 0x02 05.            "  ODE , Open drain output enable" "0,1"
;  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
;  bitfld.word 0x02 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
;  bitfld.word 0x02 01.            "  WPE , Weak pull up/down enable" "0,1"
;  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"
  line.word 0x04 "PCR222,Pad Configuration Register 222"

;  bitfld.word 0x04 10.--13.       "PA , Pin assignment" "   0,   1,   2,   3,   4,   5,   6,   7,   8,   9,   A,   B,   C,   D,   E,   F"
;  bitfld.word 0x04 09.            "  OBE , Output buffer enable" "0,1"
;  bitfld.word 0x04 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x04 06.--07.       "                       DSC , Drive strength control" "10pF,20pF,30pF,50pF"
;  bitfld.word 0x04 05.            "  ODE , Open drain output enable" "0,1"
;  bitfld.word 0x04 04.            "  HYS , Input hysteresis" "0,1"
;  bitfld.word 0x04 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
;  bitfld.word 0x04 01.            "  WPE , Weak pull up/down enable" "0,1"
;  bitfld.word 0x04 00.            "  WPS , Weak pull up/down select" "0,1"
  line.word 0x06 "PCR223,Pad Configuration Register 223"

;  bitfld.word 0x06 10.--13.       "PA , Pin assignment" "   0,   1,   2,   3,   4,   5,   6,   7,   8,   9,   A,   B,   C,   D,   E,   F"
;  bitfld.word 0x06 09.            "  OBE , Output buffer enable" "0,1"
;  bitfld.word 0x06 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x06 06.--07.       "                       DSC , Drive strength control" "10pF,20pF,30pF,50pF"
;  bitfld.word 0x06 05.            "  ODE , Open drain output enable" "0,1"
;  bitfld.word 0x06 04.            "  HYS , Input hysteresis" "0,1"
;  bitfld.word 0x06 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
;  bitfld.word 0x06 01.            "  WPE , Weak pull up/down enable" "0,1"
;  bitfld.word 0x06 00.            "  WPS , Weak pull up/down select" "0,1"

group 0xC3F90200++0x03 "PCR224-225: !MSEO[0:1]"
  line.word 0x00 "PCR224,Pad Configuration Register 224"

;  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "   0,   1,   2,   3,   4,   5,   6,   7,   8,   9,   A,   B,   C,   D,   E,   F"
;  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
;  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "                       DSC , Drive strength control" "10pF,20pF,30pF,50pF"
;  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
;  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
;  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
;  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
;  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"
  line.word 0x02 "PCR225,Pad Configuration Register 225"

;  bitfld.word 0x02 10.--13.       "PA , Pin assignment" "   0,   1,   2,   3,   4,   5,   6,   7,   8,   9,   A,   B,   C,   D,   E,   F"
;  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
;  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 06.--07.       "                       DSC , Drive strength control" "10pF,20pF,30pF,50pF"
;  bitfld.word 0x02 05.            "  ODE , Open drain output enable" "0,1"
;  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
;  bitfld.word 0x02 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
;  bitfld.word 0x02 01.            "  WPE , Weak pull up/down enable" "0,1"
;  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"

group 0xC3F90204++0x01 "PCR226: !RDY"
  line.word 0x00 "PCR226,Pad Configuration Register 226"

;  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "   0,   1,   2,   3,   4,   5,   6,   7,   8,   9,   A,   B,   C,   D,   E,   F"
;  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
;  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "                       DSC , Drive strength control" "10pF,20pF,30pF,50pF"
;  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
;  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
;  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
;  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
;  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

group 0xC3F90206++0x01 "PCR227: !EVTO"
  line.word 0x00 "PCR227,Pad Configuration Register 227"

;  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "   0,   1,   2,   3,   4,   5,   6,   7,   8,   9,   A,   B,   C,   D,   E,   F"
;  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
;  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "                       DSC , Drive strength control" "10pF,20pF,30pF,50pF"
;  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
;  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
;  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
;  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
;  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

group 0xC3F90208++0x01 "PCR228: TDO"
  line.word 0x00 "PCR228,Pad Configuration Register 228"

;  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "   0,   1,   2,   3,   4,   5,   6,   7,   8,   9,   A,   B,   C,   D,   E,   F"
;  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
;  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "                       DSC , Drive strength control" "10pF,20pF,30pF,50pF"
;  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
;  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
;  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
;  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
;  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

group 0xC3F9020A++0x01 "PCR229: !CLKOUT"
  line.word 0x00 "PCR229,Pad Configuration Register 229"

; bitfld.word 0x00 10.--13.       "PA , Pin assignment" "   0,   1,   2,   3,   4,   5,   6,   7,   8,   9,   A,   B,   C,   D,   E,   F"
  bitfld.word 0x00 09.            "         OBE , Output buffer enable" "0,1"
; bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "         DSC , Drive strength control" "10pF,20pF,30pF,50pF"
; bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
; bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
; bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
; bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
; bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

group 0xC3F9020C++0x01 "PCR230: !RSTOUT"
  line.word 0x00 "PCR230,Pad Configuration Register 230"

;  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "   0,   1,   2,   3,   4,   5,   6,   7,   8,   9,   A,   B,   C,   D,   E,   F"
;  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
;  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
;  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
;  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
;  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "                                               SRC , Slew rate control" "Min,Med,res,Max"
;  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
;  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

;calibration pins

group 0xC3F902E0++0x01 "PCR336: CAL_CS0"
  line.word 0x00 "PCR336,Pad Configuration Register 336"

;  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "   0,   1,   2,   3,   4,   5,   6,   7,   8,   9,   A,   B,   C,   D,   E,   F"
;  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
;  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "                       DSC , Drive strength control" "10pF,20pF,30pF,50pF"
;  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
;  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
;  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
;  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
;  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

group 0xC3F902E4++0x03 "PCR338-339: CAL_CS[2:3] / CAL_ADDR[10:11]"
  line.word 0x00 "PCR338,Pad Configuration Register 338"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "CAL_CS2,CAL_ADDR10,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR339,Pad Configuration Register 339"
  bitfld.word 0x02 10.--12.       "PA , Pin assignment" "CAL_CS3,CAL_ADDR11,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x02 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F902E8++0x01 "PCR340: CAL_ADDR[12:30]"
  line.word 0x00 "PCR340,Pad Configuration Register 340"

;  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "   0,   1,   2,   3,   4,   5,   6,   7,   8,   9,   A,   B,   C,   D,   E,   F"
;  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
;  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "                       DSC , Drive strength control" "10pF,20pF,30pF,50pF"
;  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
;  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
;  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
;  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
;  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

group 0xC3F902EA++0x01 "PCR341: CAL_DATA[0:15]"
  line.word 0x00 "PCR341,Pad Configuration Register 341"

;  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "   0,   1,   2,   3,   4,   5,   6,   7,   8,   9,   A,   B,   C,   D,   E,   F"
;  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
;  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "                       DSC , Drive strength control" "10pF,20pF,30pF,50pF"
;  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
;  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
;  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
;  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
;  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

group 0xC3F902EC++0x01 "PCR342: CAL_RD_WR, CAL_WE[0:1], CAL_OE, CAL_TS"
  line.word 0x00 "PCR342,Pad Configuration Register 342"

;  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "   0,   1,   2,   3,   4,   5,   6,   7,   8,   9,   A,   B,   C,   D,   E,   F"
;  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
;  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "                       DSC , Drive strength control" "10pF,20pF,30pF,50pF"
;  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
;  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
;  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
;  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
;  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

endif

sif (CPU()=="MPC5561")
group 0xC3F90040++0x07 "PCR000-PCR003: !CS[0:3] / ADDR[8:11]"
  line.word 0x00 "PCR000,Pad Configuration Register 000"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPI0,!CS0,ADDR08,!CS0,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR001,Pad Configuration Register 001"
  bitfld.word 0x02 10.--12.       "PA , Pin assignment" "GPI0,!CS1,ADDR09,!CS1,res.,res.,res.,res.      "
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x02 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x04 "PCR002,Pad Configuration Register 002"
  bitfld.word 0x04 10.--12.       "PA , Pin assignment" "GPI0,!CS2,ADDR10,!CS2,res.,res.,res.,res.      "
  bitfld.word 0x04 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x04 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x04 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x04 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x04 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x04 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x04 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x06 "PCR003,Pad Configuration Register 003"
  bitfld.word 0x06 10.--12.       "PA , Pin assignment" "GPI0,!CS3,ADDR11,!CS3,res.,res.,res.,res.      "
  bitfld.word 0x06 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x06 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x06 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x06 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x06 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x06 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x06 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90048++0x2f "PCR004-PCR011: ADDR[8:15]"
  line.word 0x00 "PCR004,Pad Configuration Register 004"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,ADDR08,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR005,Pad Configuration Register 005"
  bitfld.word 0x02 10.--12.       "PA , Pin assignment" "GPIO,ADDR09,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x02 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x04 "PCR006,Pad Configuration Register 006"
  bitfld.word 0x04 10.--12.       "PA , Pin assignment" "GPIO,ADDR10,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x04 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x04 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x04 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x04 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x04 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x04 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x04 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x06 "PCR007,Pad Configuration Register 007"
  bitfld.word 0x06 10.--12.       "PA , Pin assignment" "GPIO,ADDR11,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x06 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x06 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x06 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x06 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x06 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x06 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x06 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x08 "PCR008,Pad Configuration Register 008"
  bitfld.word 0x08 10.--12.       "PA , Pin assignment" "GPIO,ADDR12,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x08 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x08 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x08 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x08 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x08 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x08 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x08 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0a "PCR009,Pad Configuration Register 009"
  bitfld.word 0x0a 10.--12.       "PA , Pin assignment" "GPIO,ADDR13,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x0a 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0a 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0a 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x0a 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x0a 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0a 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0a 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0c "PCR010,Pad Configuration Register 010"
  bitfld.word 0x0c 10.--12.       "PA , Pin assignment" "GPIO,ADDR14,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x0c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0c 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x0c 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x0c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0c 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0e "PCR011,Pad Configuration Register 011"
  bitfld.word 0x0e 10.--12.       "PA , Pin assignment" "GPIO,ADDR15,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x0e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0e 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x0e 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x0e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0e 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0e 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90048++0x2f "PCR012-PCR027: ADDR[16:31]"
  line.word 0x10 "PCR012,Pad Configuration Register 012"
  bitfld.word 0x10 10.--12.       "PA , Pin assignment" "GPIO,ADDR16,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x10 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x10 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x10 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x10 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x10 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x10 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x10 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x12 "PCR013,Pad Configuration Register 013"
  bitfld.word 0x12 10.--12.       "PA , Pin assignment" "GPIO,ADDR17,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x12 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x12 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x12 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x12 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x12 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x12 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x12 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x14 "PCR014,Pad Configuration Register 014"
  bitfld.word 0x14 10.--12.       "PA , Pin assignment" "GPIO,ADDR18,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x14 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x14 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x14 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x14 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x14 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x14 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x14 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x16 "PCR015,Pad Configuration Register 015"
  bitfld.word 0x16 10.--12.       "PA , Pin assignment" "GPIO,ADDR19,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x16 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x16 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x16 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x16 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x16 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x16 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x16 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x18 "PCR016,Pad Configuration Register 016"
  bitfld.word 0x18 10.--12.       "PA , Pin assignment" "GPIO,ADDR20,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x18 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x18 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x18 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x18 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x18 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x18 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x18 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x1A "PCR017,Pad Configuration Register 017"
  bitfld.word 0x1A 10.--12.       "PA , Pin assignment" "GPIO,ADDR21,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x1A 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x1A 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x1A 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x1A 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x1A 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x1A 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x1A 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x1C "PCR018,Pad Configuration Register 018"
  bitfld.word 0x1C 10.--12.       "PA , Pin assignment" "GPIO,ADDR22,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x1C 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x1C 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x1C 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x1C 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x1C 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x1C 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x1C 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x1E "PCR019,Pad Configuration Register 019"
  bitfld.word 0x1E 10.--12.       "PA , Pin assignment" "GPIO,ADDR23,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x1E 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x1E 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x1E 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x1E 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x1E 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x1E 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x1E 00.            "  WPS , Weak pull up/down select" "0,1"

TEXTLINE ""
  line.word 0x20 "PCR020,Pad Configuration Register 020"
  bitfld.word 0x20 10.--12.       "PA , Pin assignment" "GPIO,ADDR24,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x20 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x20 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x20 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x20 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x20 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x20 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x20 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x22 "PCR021,Pad Configuration Register 021"
  bitfld.word 0x22 10.--12.       "PA , Pin assignment" "GPIO,ADDR25,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x22 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x22 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x22 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x22 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x22 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x22 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x22 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x24 "PCR022,Pad Configuration Register 022"
  bitfld.word 0x24 10.--12.       "PA , Pin assignment" "GPIO,ADDR26,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x24 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x24 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x24 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x24 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x24 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x24 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x24 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x26 "PCR023,Pad Configuration Register 023"
  bitfld.word 0x26 10.--12.       "PA , Pin assignment" "GPIO,ADDR27,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x26 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x26 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x26 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x26 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x26 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x26 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x26 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x28 "PCR024,Pad Configuration Register 024"
  bitfld.word 0x28 10.--12.       "PA , Pin assignment" "GPIO,ADDR28,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x28 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x28 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x28 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x28 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x28 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x28 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x28 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x2a "PCR025,Pad Configuration Register 025"
  bitfld.word 0x2a 10.--12.       "PA , Pin assignment" "GPIO,ADDR29,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x2a 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x2a 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x2a 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x2a 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x2a 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x2a 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x2a 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x2c "PCR026,Pad Configuration Register 026"
  bitfld.word 0x2c 10.--12.       "PA , Pin assignment" "GPIO,ADDR30,ADDR06,ADDR30,res.,res.,res.,res.      "
  bitfld.word 0x2c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x2c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x2c 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x2c 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x2c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x2c 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x2c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x2e "PCR027,Pad Configuration Register 027"
  bitfld.word 0x2e 10.--12.       "PA , Pin assignment" "GPIO,ADDR31,ADDR07,ADDR31,res.,res.,res.,res.      "
  bitfld.word 0x2e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x2e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x2e 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x2e 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x2e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x2e 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x2e 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90078++0x3f "PCR028-PCR043: DATA[0:15]"
  line.word 0x00 "PCR028,Pad Configuration Register 028"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,DATA00,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR029,Pad Configuration Register 029"
  bitfld.word 0x02 10.--12.       "PA , Pin assignment" "GPIO,DATA01,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x02 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x04 "PCR030,Pad Configuration Register 030"
  bitfld.word 0x04 10.--12.       "PA , Pin assignment" "GPIO,DATA02,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x04 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x04 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x04 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x04 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x04 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x04 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x04 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x06 "PCR031,Pad Configuration Register 031"
  bitfld.word 0x06 10.--12.       "PA , Pin assignment" "GPIO,DATA03,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x06 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x06 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x06 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x06 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x06 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x06 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x06 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x08 "PCR032,Pad Configuration Register 032"
  bitfld.word 0x08 10.--12.       "PA , Pin assignment" "GPIO,DATA04,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x08 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x08 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x08 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x08 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x08 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x08 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x08 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0a "PCR033,Pad Configuration Register 033"
  bitfld.word 0x0a 10.--12.       "PA , Pin assignment" "GPIO,DATA05,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x0a 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0a 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0a 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x0a 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x0a 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0a 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0a 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0c "PCR034,Pad Configuration Register 034"
  bitfld.word 0x0c 10.--12.       "PA , Pin assignment" "GPIO,DATA06,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x0c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0c 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x0c 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x0c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0c 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0e "PCR035,Pad Configuration Register 035"
  bitfld.word 0x0e 10.--12.       "PA , Pin assignment" "GPIO,DATA07,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x0e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0e 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x0e 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x0e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0e 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0e 00.            "  WPS , Weak pull up/down select" "0,1"

TEXTLINE ""
  line.word 0x10 "PCR036,Pad Configuration Register 036"
  bitfld.word 0x10 10.--12.       "PA , Pin assignment" "GPIO,DATA08,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x10 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x10 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x10 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x10 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x10 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x10 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x10 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x12 "PCR037,Pad Configuration Register 037"
  bitfld.word 0x12 10.--12.       "PA , Pin assignment" "GPIO,DATA09,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x12 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x12 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x12 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x12 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x12 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x12 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x12 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x14 "PCR038,Pad Configuration Register 038"
  bitfld.word 0x14 10.--12.       "PA , Pin assignment" "GPIO,DATA10,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x14 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x14 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x14 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x14 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x14 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x14 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x14 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x16 "PCR039,Pad Configuration Register 039"
  bitfld.word 0x16 10.--12.       "PA , Pin assignment" "GPIO,DATA11,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x16 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x16 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x16 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x16 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x16 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x16 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x16 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x18 "PCR040,Pad Configuration Register 040"
  bitfld.word 0x18 10.--12.       "PA , Pin assignment" "GPIO,DATA12,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x18 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x18 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x18 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x18 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x18 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x18 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x18 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x1A "PCR041,Pad Configuration Register 041"
  bitfld.word 0x1A 10.--12.       "PA , Pin assignment" "GPIO,DATA13,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x1A 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x1A 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x1A 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x1A 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x1A 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x1A 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x1A 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x1c "PCR042,Pad Configuration Register 042"
  bitfld.word 0x1c 10.--12.       "PA , Pin assignment" "GPIO,DATA14,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x1c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x1c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x1c 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x1c 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x1c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x1c 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x1c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x1e "PCR043,Pad Configuration Register 043"
  bitfld.word 0x1e 10.--12.       "PA , Pin assignment" "GPIO,DATA15,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x1e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x1e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x1e 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x1e 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x1e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x1e 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x1e 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90078++0x3f "PCR044-PCR059: DATA[16:31] / FR_A / FR_B"
  line.word 0x20 "PCR044,Pad Configuration Register 044"
  bitfld.word 0x20 10.--12.       "PA , Pin assignment" "GPIO,DATA16,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x20 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x20 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x20 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x20 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x20 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x20 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x20 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x22 "PCR045,Pad Configuration Register 045"
  bitfld.word 0x22 10.--12.       "PA , Pin assignment" "GPIO,DATA17,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x22 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x22 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x22 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x22 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x22 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x22 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x22 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x24 "PCR046,Pad Configuration Register 046"
  bitfld.word 0x24 10.--12.       "PA , Pin assignment" "GPIO,DATA18,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x24 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x24 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x24 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x24 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x24 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x24 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x24 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x26 "PCR047,Pad Configuration Register 047"
  bitfld.word 0x26 10.--12.       "PA , Pin assignment" "GPIO,DATA19,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x26 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x26 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x26 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x26 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x26 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x26 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x26 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x28 "PCR048,Pad Configuration Register 048"
  bitfld.word 0x28 10.--12.       "PA , Pin assignment" "GPIO,DATA20,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x28 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x28 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x28 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x28 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x28 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x28 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x28 00.            "  WPS , Weak pull up/down select" "0,1"


  line.word 0x2a "PCR049,Pad Configuration Register 049"
  bitfld.word 0x2a 10.--12.       "PA , Pin assignment" "GPIO,DATA21,FR_A_TX,DATA21,res.,res.,res.,res.      "
  bitfld.word 0x2a 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x2a 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x2a 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x2a 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x2a 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x2a 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x2a 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x2c "PCR050,Pad Configuration Register 050"
  bitfld.word 0x2c 10.--12.       "PA , Pin assignment" "GPIO,DATA22,FR_A_RX,DATA22,res.,res.,res.,res.      "
  bitfld.word 0x2c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x2c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x2c 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x2c 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x2c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x2c 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x2c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x2e "PCR051,Pad Configuration Register 051"
  bitfld.word 0x2e 10.--12.       "PA , Pin assignment" "GPIO,DATA23,FR_A_TXEN,DATA23,res.,res.,res.,res.      "
  bitfld.word 0x2e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x2e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x2e 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x2e 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x2e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x2e 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x2e 00.            "  WPS , Weak pull up/down select" "0,1"

TEXTLINE ""
  line.word 0x30 "PCR052,Pad Configuration Register 052"
  bitfld.word 0x30 10.--12.       "PA , Pin assignment" "GPIO,DATA24,res.,DATA24,res.,res.,res.,res.      "
  bitfld.word 0x30 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x30 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x30 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x30 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x30 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x30 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x30 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x32 "PCR053,Pad Configuration Register 053"
  bitfld.word 0x32 10.--12.       "PA , Pin assignment" "GPIO,DATA25,FR_B_TX,DATA25,res.,res.,res.,res.      "
  bitfld.word 0x32 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x32 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x32 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x32 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x32 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x32 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x32 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x34 "PCR054,Pad Configuration Register 054"
  bitfld.word 0x34 10.--12.       "PA , Pin assignment" "GPIO,DATA26,FR_B_RX,DATA26,res.,res.,res.,res.      "
  bitfld.word 0x34 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x34 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x34 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x34 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x34 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x34 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x34 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x36 "PCR055,Pad Configuration Register 055"
  bitfld.word 0x36 10.--12.       "PA , Pin assignment" "GPIO,DATA27,FR_B_TXEN,DATA27,res.,res.,res.,res.      "
  bitfld.word 0x36 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x36 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x36 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x36 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x36 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x36 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x36 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x38 "PCR056,Pad Configuration Register 056"
  bitfld.word 0x38 10.--12.       "PA , Pin assignment" "GPIO,DATA28,res.,DATA28,res.,res.,res.,res.      "
  bitfld.word 0x38 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x38 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x38 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x38 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x38 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x38 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x38 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x3a "PCR057,Pad Configuration Register 057"
  bitfld.word 0x3a 10.--12.       "PA , Pin assignment" "GPIO,DATA29,res.,DATA29,res.,res.,res.,res.      "
  bitfld.word 0x3a 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x3a 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x3a 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x3a 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x3a 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x3a 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x3a 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x3c "PCR058,Pad Configuration Register 058"
  bitfld.word 0x3c 10.--12.       "PA , Pin assignment" "GPIO,DATA30,res.,DATA30,res.,res.,res.,res.      "
  bitfld.word 0x3c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x3c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x3c 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x3c 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x3c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x3c 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x3c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x3e "PCR059,Pad Configuration Register 059"
  bitfld.word 0x3e 10.--12.       "PA , Pin assignment" "GPIO,DATA31,res.,DATA31,res.,res.,res.,res.      "
  bitfld.word 0x3e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x3e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x3e 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x3e 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x3e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x3e 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x3e 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900BC++0x01 "PCR062: RD/!WR"
  line.word 0x00 "PCR062,Pad Configuration Register 062"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,RD/!WR,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900BE++0x01 "PCR063: !BDIP"
  line.word 0x00 "PCR063,Pad Configuration Register 063"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,!BDIP,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900C0++0x07 "PCR064-067: !WE_BE[0:3]"
  line.word 0x00 "PCR064,Pad Configuration Register 064"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,!WE0_BE0,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR065,Pad Configuration Register 065"
  bitfld.word 0x02 10.--12.       "PA , Pin assignment" "GPIO,!WE1_BE1,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x02 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x04 "PCR066,Pad Configuration Register 066"
  bitfld.word 0x04 10.--12.       "PA , Pin assignment" "GPIO,!WE2_BE2,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x04 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x04 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x04 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x04 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x04 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x04 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x04 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x06 "PCR067,Pad Configuration Register 067"
  bitfld.word 0x06 10.--12.       "PA , Pin assignment" "GPIO,!WE3_BE3,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x06 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x06 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x06 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x06 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x06 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x06 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x06 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900C8++0x01 "PCR068: !OE"
  line.word 0x00 "PCR068,Pad Configuration Register 068"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,!OE,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900CA++0x01 "PCR069: !TS"
  line.word 0x00 "PCR069,Pad Configuration Register 069"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,!TS,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900CC++0x01 "PCR070: !TA"
  line.word 0x00 "PCR070,Pad Configuration Register 070"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,!TA,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900CE++0x01 "PCR071: !TEA"
  line.word 0x00 "PCR071,Pad Configuration Register 071"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,!TEA,res.,!TEA,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900D0++0x01 "PCR072: !BR / MDC"
  line.word 0x00 "PCR072,Pad Configuration Register 072"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,!BR,MDC,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900D2++0x01 "PCR073: !BG / MDIO"
  line.word 0x00 "PCR073,Pad Configuration Register 073"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,!BG,MDIO,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900D4++0x01 "PCR074: !BB"
  line.word 0x00 "PCR073,Pad Configuration Register 073"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,!BB,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900D6++0x0f "PCR075-PCR082: MDO[4:11]"
  line.word 0x00 "PCR075,Pad Configuration Register 075"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO/MDO04,res.,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR076,Pad Configuration Register 076"
  bitfld.word 0x02 10.--12.       "PA , Pin assignment" "GPIO/MDO05,res.,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x02 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x04 "PCR077,Pad Configuration Register 077"
  bitfld.word 0x04 10.--12.       "PA , Pin assignment" "GPIO/MDO06,res.,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x04 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x04 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x04 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x04 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x04 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x04 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x04 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x06 "PCR078,Pad Configuration Register 078"
  bitfld.word 0x06 10.--12.       "PA , Pin assignment" "GPIO/MDO07,res.,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x06 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x06 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x06 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x06 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x06 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x06 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x06 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x08 "PCR079,Pad Configuration Register 079"
  bitfld.word 0x08 10.--12.       "PA , Pin assignment" "GPIO/MDO08,res.,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x08 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x08 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x08 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x08 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x08 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x08 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x08 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0a "PCR080,Pad Configuration Register 080"
  bitfld.word 0x0a 10.--12.       "PA , Pin assignment" "GPIO/MDO09,res.,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x0a 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0a 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0a 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x0a 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x0a 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0a 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0a 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0c "PCR081,Pad Configuration Register 081"
  bitfld.word 0x0c 10.--12.       "PA , Pin assignment" "GPIO/MDO10,res.,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x0c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0c 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x0c 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x0c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0c 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0e "PCR082,Pad Configuration Register 082"
  bitfld.word 0x0e 10.--12.       "PA , Pin assignment" "GPIO/MDO11,res.,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x0e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0e 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x0e 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x0e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0e 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0e 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900E6++0x01 "PCR083: CNTX_A / TXDA"
  line.word 0x00 "PCR083,Pad Configuration Register 083"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,CNTX_A,TXDA,CNTX_A,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900E8++0x01 "PCR084: CNRX_A / RXDA"
  line.word 0x00 "PCR084,Pad Configuration Register 084"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,CNRX_A,RXDA,CNRX_A,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900EA++0x01 "PCR085: CNTX_B / DSPI PCSC3 / FR_A_TX"
  line.word 0x00 "PCR085,Pad Configuration Register 085"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,CNTX_B,PCSC3,CNTX_B,FR_A_TX,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900EC++0x01 "PCR086: CNRX_B / DSPI PCSC4 / FR_A_RX"
  line.word 0x00 "PCR086,Pad Configuration Register 086"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,CNRX_B,PCSC4,CNRX_B,FR_A_RX,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900EE++0x01 "PCR087: CNTX_C"
  line.word 0x00 "PCR087,Pad Configuration Register 087"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,CNTX_C,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900F0++0x01 "PCR088: CNRX_C"
  line.word 0x00 "PCR088,Pad Configuration Register 088"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,CNRX_C,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900F2++0x01 "PCR089: TXD_A"
  line.word 0x00 "PCR089,Pad Configuration Register 089"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,TXD_A,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900F4++0x01 "PCR090: RXD_A"
  line.word 0x00 "PCR090,Pad Configuration Register 090"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,RXD_A,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900F6++0x01 "PCR091: TXD_B"
  line.word 0x00 "PCR091,Pad Configuration Register 091"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,TXD_B,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900F8++0x01 "PCR092: RXD_B"
  line.word 0x00 "PCR092,Pad Configuration Register 092"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,RXD_B,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900FA++0x01 "PCR093: DSPI PCSC1"
  line.word 0x00 "PCR093,Pad Configuration Register 093"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,res.,PCSC1,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900FC++0x01 "PCR094: DSPI PCSC2"
  line.word 0x00 "PCR094,Pad Configuration Register 094"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,res.,PCSC2,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900FE++0x01 "PCR095: DSPI PCSC5"
  line.word 0x00 "PCR095,Pad Configuration Register 095"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,res.,PCSC5,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90100++0x01 "PCR096: SCI_C_TX"
  line.word 0x00 "PCR096,Pad Configuration Register 096"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,res.,SCI_C_TX,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90102++0x01 "PCR097: DSPI PCSB2"
  line.word 0x00 "PCR097,Pad Configuration Register 097"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,res.,PCSB2,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90104++0x01 "PCR098: DSPI SCI_D_TX"
  line.word 0x00 "PCR098,Pad Configuration Register 098"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,res.,SCI_D_TX,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90106++0x01 "PCR099: DSPI SCI_D_RX"
  line.word 0x00 "PCR099,Pad Configuration Register 099"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,res.,SCI_D_RX,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90108++0x01 "PCR100: DSPI SCI_C_RX"
  line.word 0x00 "PCR100,Pad Configuration Register 100"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,res.,SCI_C_RX,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F9010a++0x01 "PCR101: DSPI PCSB3"
  line.word 0x00 "PCR101,Pad Configuration Register 101"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,res.,PCSB3,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F9010c++0x01 "PCR102: DSPI SCKB / DSPI PCSC1"
  line.word 0x00 "PCR102,Pad Configuration Register 102"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,SCKB,PCSC1,SCKB,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F9010e++0x01 "PCR103: DSPI SINB / DSPI PCSC2"
  line.word 0x00 "PCR103,Pad Configuration Register 103"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,SINB,PCSC2,SINB,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90110++0x01 "PCR104: DSPI SOUTB / DSPI PCSC5"
  line.word 0x00 "PCR104,Pad Configuration Register 104"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,SOUTB,PCSC5,SOUTB,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90112++0x01 "PCR105: DSPI PCSB0 / DSPI PCSD2"
  line.word 0x00 "PCR105,Pad Configuration Register 105"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,PCSB0,PCSD2,PCSB0,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90114++0x01 "PCR106: DSPI PCSB1 / DSPI PCSD0"
  line.word 0x00 "PCR106,Pad Configuration Register 106"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,PCSB1,PCSD0,PCSB1,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90116++0x01 "PCR107: DSPI PCSB2 / DSPI SOUTC"
  line.word 0x00 "PCR107,Pad Configuration Register 107"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,PCSB2,SOUTC,PCSB2,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90118++0x01 "PCR108: DSPI PCSB3 / DSPI SINC"
  line.word 0x00 "PCR108,Pad Configuration Register 108"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,PCSB3,SINC,PCSB3,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F9011A++0x01 "PCR109: DSPI PCSB4 / DSPI SCKC"
  line.word 0x00 "PCR109,Pad Configuration Register 109"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,PCSB4,SCKC,PCSB4,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F9011C++0x01 "PCR110: DSPI PCSB5 / DSPI PCSC0"
  line.word 0x00 "PCR110,Pad Configuration Register 110"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,PCSB5,PCSC0,PCSB5,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F9011E++0x03 "PCR111-112: ETRIG[0:1]"
  line.word 0x00 "PCR111,Pad Configuration Register 111"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,ETRIG0,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR112,Pad Configuration Register 112"
  bitfld.word 0x02 10.--12.       "PA , Pin assignment" "GPIO,ETRIG1,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x02 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90122++0x01 "PCR113: TCRCLKA / IRQ7"
  line.word 0x00 "PCR113,Pad Configuration Register 113"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,TCRCLKA,IRQ7,TCRCLKA,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90124++0x3F "PCR114-145: ETPUA[0:31] / ETPUA[12:23] / PCSB[1:4] / IRQ[8:15] / PCDC[1:4] / PCSD[1:4]"
  line.word 0x00 "PCR114,Pad Configuration Register 114"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,ETPUA00,ETPUA12,ETPUA00,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR115,Pad Configuration Register 115"
  bitfld.word 0x02 10.--12.       "PA , Pin assignment" "GPIO,ETPUA01,ETPUA13,ETPUA01,res.,res.,res.,res.      "
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x02 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x04 "PCR116,Pad Configuration Register 116"
  bitfld.word 0x04 10.--12.       "PA , Pin assignment" "GPIO,ETPUA02,ETPUA14,ETPUA02,res.,res.,res.,res.      "
  bitfld.word 0x04 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x04 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x04 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x04 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x04 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x04 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x04 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x06 "PCR117,Pad Configuration Register 117"
  bitfld.word 0x06 10.--12.       "PA , Pin assignment" "GPIO,ETPUA03,ETPUA15,ETPUA03,res.,res.,res.,res.      "
  bitfld.word 0x06 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x06 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x06 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x06 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x06 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x06 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x06 00.            "  WPS , Weak pull up/down select" "0,1"


  line.word 0x08 "PCR118,Pad Configuration Register 118"
  bitfld.word 0x08 10.--12.       "PA , Pin assignment" "GPIO,ETPUA04,ETPUA16,ETPUA04,res.,res.,res.,res.      "
  bitfld.word 0x08 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x08 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x08 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x08 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x08 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x08 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x08 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0a "PCR119,Pad Configuration Register 119"
  bitfld.word 0x0a 10.--12.       "PA , Pin assignment" "GPIO,ETPUA05,ETPUA17,ETPUA05,res.,res.,res.,res.      "
  bitfld.word 0x0a 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0a 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0a 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x0a 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0a 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x0a 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0a 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0c "PCR120,Pad Configuration Register 120"
  bitfld.word 0x0c 10.--12.       "PA , Pin assignment" "GPIO,ETPUA06,ETPUA18,ETPUA06,res.,res.,res.,res.      "
  bitfld.word 0x0c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0c 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x0c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0c 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x0c 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0e "PCR121,Pad Configuration Register 121"
  bitfld.word 0x0e 10.--12.       "PA , Pin assignment" "GPIO,ETPUA07,ETPUA19,ETPUA07,res.,res.,res.,res.      "
  bitfld.word 0x0e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0e 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x0e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0e 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x0e 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0e 00.            "  WPS , Weak pull up/down select" "0,1"

TEXTLINE "" 
  line.word 0x10 "PCR122,Pad Configuration Register 122"
  bitfld.word 0x10 10.--12.       "PA , Pin assignment" "GPIO,ETPUA08,ETPUA20,ETPUA08,res.,res.,res.,res.      "
  bitfld.word 0x10 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x10 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x10 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x10 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x10 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x10 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x10 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x12 "PCR123,Pad Configuration Register 123"
  bitfld.word 0x12 10.--12.       "PA , Pin assignment" "GPIO,ETPUA09,ETPUA21,ETPUA09,res.,res.,res.,res.      "
  bitfld.word 0x12 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x12 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x12 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x12 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x12 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x12 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x12 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x14 "PCR124,Pad Configuration Register 124"
  bitfld.word 0x14 10.--12.       "PA , Pin assignment" "GPIO,ETPUA10,ETPUA22,ETPUA10,res.,res.,res.,res.      "
  bitfld.word 0x14 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x14 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x14 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x14 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x14 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x14 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x14 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x16 "PCR125,Pad Configuration Register 125"
  bitfld.word 0x16 10.--12.       "PA , Pin assignment" "GPIO,ETPUA11,ETPUA23,ETPUA11,res.,res.,res.,res.      "
  bitfld.word 0x16 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x16 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x16 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x16 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x16 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x16 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x16 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x18 "PCR126,Pad Configuration Register 126"
  bitfld.word 0x18 10.--12.       "PA , Pin assignment" "GPIO,ETPUA12,PCSB1,ETPUA12,res.,res.,res.,res.      "
  bitfld.word 0x18 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x18 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x18 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x18 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x18 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x18 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x18 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x1A "PCR127,Pad Configuration Register 127"
  bitfld.word 0x1A 10.--12.       "PA , Pin assignment" "GPIO,ETPUA13,PCSB3,ETPUA13,res.,res.,res.,res.      "
  bitfld.word 0x1A 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x1A 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x1A 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x1A 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x1A 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x1A 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x1A 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x1c "PCR128,Pad Configuration Register 128"
  bitfld.word 0x1c 10.--12.       "PA , Pin assignment" "GPIO,ETPUA14,PCSB4,ETPUA14,res.,res.,res.,res.      "
  bitfld.word 0x1c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x1c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x1c 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x1c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x1c 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x1c 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x1c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x1e "PCR129,Pad Configuration Register 129"
  bitfld.word 0x1e 10.--12.       "PA , Pin assignment" "GPIO,ETPUA15,PCSB5,ETPUA15,res.,res.,res.,res.      "
  bitfld.word 0x1e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x1e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x1e 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x1e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x1e 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x1e 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x1e 00.            "  WPS , Weak pull up/down select" "0,1"

TEXTLINE ""
  line.word 0x20 "PCR130,Pad Configuration Register 130"
  bitfld.word 0x20 10.--12.       "PA , Pin assignment" "GPIO,ETPUA16,PCSD1,ETPUA16,res.,res.,res.,res.      "
  bitfld.word 0x20 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x20 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x20 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x20 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x20 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x20 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x20 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x22 "PCR131,Pad Configuration Register 131"
  bitfld.word 0x22 10.--12.       "PA , Pin assignment" "GPIO,ETPUA17,PCSD2,ETPUA17,res.,res.,res.,res.      "
  bitfld.word 0x22 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x22 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x22 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x22 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x22 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x22 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x22 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x24 "PCR132,Pad Configuration Register 132"
  bitfld.word 0x24 10.--12.       "PA , Pin assignment" "GPIO,ETPUA18,PCSD3,ETPUA18,res.,res.,res.,res.      "
  bitfld.word 0x24 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x24 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x24 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x24 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x24 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x24 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x24 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x26 "PCR133,Pad Configuration Register 133"
  bitfld.word 0x26 10.--12.       "PA , Pin assignment" "GPIO,ETPUA19,PCSD4,ETPUA19,res.,res.,res.,res.      "
  bitfld.word 0x26 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x26 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x26 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x26 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x26 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x26 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x26 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x28 "PCR134,Pad Configuration Register 134"
  bitfld.word 0x28 10.--12.       "PA , Pin assignment" "GPIO,ETPUA20,IRQ08,ETPUA20,res.,res.,res.,res.      "
  bitfld.word 0x28 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x28 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x28 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x28 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x28 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x28 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x28 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x2a "PCR135,Pad Configuration Register 135"
  bitfld.word 0x2a 10.--12.       "PA , Pin assignment" "GPIO,ETPUA21,IRQ09,ETPUA21,res.,res.,res.,res.      "
  bitfld.word 0x2a 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x2a 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x2a 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x2a 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x2a 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x2a 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x2a 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x2c "PCR136,Pad Configuration Register 136"
  bitfld.word 0x2c 10.--12.       "PA , Pin assignment" "GPIO,ETPUA22,IRQ10,ETPUA22,res.,res.,res.,res.      "
  bitfld.word 0x2c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x2c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x2c 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x2c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x2c 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x2c 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x2c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x2e "PCR137,Pad Configuration Register 137"
  bitfld.word 0x2e 10.--12.       "PA , Pin assignment" "GPIO,ETPUA23,IRQ11,ETPUA23,res.,res.,res.,res.      "
  bitfld.word 0x2e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x2e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x2e 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x2e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x2e 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x2e 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x2e 00.            "  WPS , Weak pull up/down select" "0,1"

TEXTLINE ""
  line.word 0x30 "PCR138,Pad Configuration Register 138"
  bitfld.word 0x30 10.--12.       "PA , Pin assignment" "GPIO,ETPUA24,IRQ12,ETPUA24,res.,res.,res.,res.      "
  bitfld.word 0x30 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x30 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x30 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x30 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x30 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x30 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x30 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x32 "PCR139,Pad Configuration Register 139"
  bitfld.word 0x32 10.--12.       "PA , Pin assignment" "GPIO,ETPUA25,IRQ13,ETPUA25,res.,res.,res.,res.      "
  bitfld.word 0x32 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x32 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x32 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x32 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x32 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x32 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x32 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x34 "PCR140,Pad Configuration Register 140"
  bitfld.word 0x34 10.--12.       "PA , Pin assignment" "GPIO,ETPUA26,IRQ14,ETPUA26,res.,res.,res.,res.      "
  bitfld.word 0x34 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x34 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x34 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x34 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x34 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x34 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x34 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x36 "PCR141,Pad Configuration Register 141"
  bitfld.word 0x36 10.--12.       "PA , Pin assignment" "GPIO,ETPUA27,IRQ15,ETPUA27,res.,res.,res.,res.      "
  bitfld.word 0x36 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x36 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x36 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x36 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x36 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x36 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x36 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x38 "PCR142,Pad Configuration Register 142"
  bitfld.word 0x38 10.--12.       "PA , Pin assignment" "GPIO,ETPUA28,PCSC1,ETPUA28,res.,res.,res.,res.      "
  bitfld.word 0x38 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x38 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x38 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x38 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x38 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x38 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x38 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x3a "PCR143,Pad Configuration Register 143"
  bitfld.word 0x3a 10.--12.       "PA , Pin assignment" "GPIO,ETPUA29,PCSC2,ETPUA29,res.,res.,res.,res.      "
  bitfld.word 0x3a 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x3a 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x3a 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x3a 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x3a 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x3a 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x3a 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x3c "PCR144,Pad Configuration Register 144"
  bitfld.word 0x3c 10.--12.       "PA , Pin assignment" "GPIO,ETPUA30,PCSC3,ETPUA30,res.,res.,res.,res.      "
  bitfld.word 0x3c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x3c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x3c 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x3c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x3c 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x3c 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x3c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x3e "PCR145,Pad Configuration Register 145"
  bitfld.word 0x3e 10.--12.       "PA , Pin assignment" "GPIO,ETPUA31,PCSC4,ETPUA31,res.,res.,res.,res.      "
  bitfld.word 0x3e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x3e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x3e 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x3e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x3e 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x3e 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x3e 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90164++0x01 "PCR146: TCRCLKB / IRQ6"
  line.word 0x00 "PCR146,Pad Configuration Register 146"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,TCRCLKB,IRQ06,TCRCLKB,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90166++0x3F "PCR147-178: ETPUB[0:31] / ETPUB[16:31] / PCSA[1:4]"
  line.word 0x00 "PCR147,Pad Configuration Register 147"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,ETPUB00,ETPUB16,ETPUB00,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR148,Pad Configuration Register 148"
  bitfld.word 0x02 10.--12.       "PA , Pin assignment" "GPIO,ETPUB01,ETPUB17,ETPUB01,res.,res.,res.,res.      "
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x02 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x04 "PCR149,Pad Configuration Register 149"
  bitfld.word 0x04 10.--12.       "PA , Pin assignment" "GPIO,ETPUB02,ETPUB18,ETPUB02,res.,res.,res.,res.      "
  bitfld.word 0x04 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x04 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x04 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x04 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x04 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x04 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x04 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x06 "PCR150,Pad Configuration Register 150"
  bitfld.word 0x06 10.--12.       "PA , Pin assignment" "GPIO,ETPUB03,ETPUB19,ETPUB03,res.,res.,res.,res.      "
  bitfld.word 0x06 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x06 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x06 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x06 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x06 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x06 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x06 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x08 "PCR151,Pad Configuration Register 151"
  bitfld.word 0x08 10.--12.       "PA , Pin assignment" "GPIO,ETPUB04,ETPUB20,ETPUB04,res.,res.,res.,res.      "
  bitfld.word 0x08 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x08 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x08 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x08 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x08 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x08 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x08 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0a "PCR152,Pad Configuration Register 152"
  bitfld.word 0x0a 10.--12.       "PA , Pin assignment" "GPIO,ETPUB05,ETPUB21,ETPUB05,res.,res.,res.,res.      "
  bitfld.word 0x0a 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0a 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0a 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x0a 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0a 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x0a 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0a 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0c "PCR153,Pad Configuration Register 153"
  bitfld.word 0x0c 10.--12.       "PA , Pin assignment" "GPIO,ETPUB06,ETPUB22,ETPUB06,res.,res.,res.,res.      "
  bitfld.word 0x0c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0c 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x0c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0c 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x0c 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0e "PCR154,Pad Configuration Register 154"
  bitfld.word 0x0e 10.--12.       "PA , Pin assignment" "GPIO,ETPUB07,ETPUB23,ETPUB07,res.,res.,res.,res.      "
  bitfld.word 0x0e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0e 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x0e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0e 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x0e 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0e 00.            "  WPS , Weak pull up/down select" "0,1"

TEXTLINE "" 
  line.word 0x10 "PCR155,Pad Configuration Register 155"
  bitfld.word 0x10 10.--12.       "PA , Pin assignment" "GPIO,ETPUB08,ETPUB24,ETPUB08,res.,res.,res.,res.      "
  bitfld.word 0x10 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x10 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x10 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x10 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x10 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x10 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x10 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x12 "PCR156,Pad Configuration Register 156"
  bitfld.word 0x12 10.--12.       "PA , Pin assignment" "GPIO,ETPUB09,ETPUB25,ETPUB09,res.,res.,res.,res.      "
  bitfld.word 0x12 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x12 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x12 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x12 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x12 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x12 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x12 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x14 "PCR157,Pad Configuration Register 157"
  bitfld.word 0x14 10.--12.       "PA , Pin assignment" "GPIO,ETPUB10,ETPUB26,ETPUB10,res.,res.,res.,res.      "
  bitfld.word 0x14 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x14 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x14 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x14 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x14 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x14 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x14 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x16 "PCR158,Pad Configuration Register 158"
  bitfld.word 0x16 10.--12.       "PA , Pin assignment" "GPIO,ETPUB11,ETPUB27,ETPUB11,res.,res.,res.,res.      "
  bitfld.word 0x16 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x16 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x16 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x16 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x16 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x16 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x16 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x18 "PCR159,Pad Configuration Register 159"
  bitfld.word 0x18 10.--12.       "PA , Pin assignment" "GPIO,ETPUB12,ETPUB28,ETPUB12,res.,res.,res.,res.      "
  bitfld.word 0x18 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x18 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x18 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x18 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x18 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x18 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x18 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x1A "PCR160,Pad Configuration Register 160"
  bitfld.word 0x1A 10.--12.       "PA , Pin assignment" "GPIO,ETPUB13,ETPUB29,ETPUB13,res.,res.,res.,res.      "
  bitfld.word 0x1A 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x1A 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x1A 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x1A 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x1A 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x1A 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x1A 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x1c "PCR161,Pad Configuration Register 161"
  bitfld.word 0x1c 10.--12.       "PA , Pin assignment" "GPIO,ETPUB14,ETPUB30,ETPUB14,res.,res.,res.,res.      "
  bitfld.word 0x1c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x1c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x1c 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x1c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x1c 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x1c 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x1c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x1e "PCR162,Pad Configuration Register 162"
  bitfld.word 0x1e 10.--12.       "PA , Pin assignment" "GPIO,ETPUB15,ETPUB31,ETPUB15,res.,res.,res.,res.      "
  bitfld.word 0x1e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x1e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x1e 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x1e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x1e 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x1e 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x1e 00.            "  WPS , Weak pull up/down select" "0,1"

TEXTLINE ""
  line.word 0x20 "PCR163,Pad Configuration Register 163"
  bitfld.word 0x20 10.--12.       "PA , Pin assignment" "GPIO,ETPUB16,PCSA1,ETPUB16,res.,res.,res.,res.      "
  bitfld.word 0x20 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x20 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x20 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x20 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x20 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x20 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x20 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x22 "PCR164,Pad Configuration Register 164"
  bitfld.word 0x22 10.--12.       "PA , Pin assignment" "GPIO,ETPUB17,PCSA2,ETPUB17,res.,res.,res.,res.      "
  bitfld.word 0x22 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x22 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x22 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x22 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x22 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x22 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x22 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x24 "PCR165,Pad Configuration Register 165"
  bitfld.word 0x24 10.--12.       "PA , Pin assignment" "GPIO,ETPUB18,PCSA3,ETPUB18,res.,res.,res.,res.      "
  bitfld.word 0x24 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x24 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x24 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x24 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x24 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x24 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x24 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x26 "PCR166,Pad Configuration Register 166"
  bitfld.word 0x26 10.--12.       "PA , Pin assignment" "GPIO,ETPUB19,PCSA4,ETPUB19,res.,res.,res.,res.      "
  bitfld.word 0x26 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x26 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x26 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x26 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x26 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x26 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x26 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x28 "PCR167,Pad Configuration Register 167"
  bitfld.word 0x28 10.--12.       "PA , Pin assignment" "GPIO,ETPUB20,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x28 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x28 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x28 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x28 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x28 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x28 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x28 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x2a "PCR168,Pad Configuration Register 168"
  bitfld.word 0x2a 10.--12.       "PA , Pin assignment" "GPIO,ETPUB21,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x2a 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x2a 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x2a 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x2a 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x2a 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x2a 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x2a 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x2c "PCR169,Pad Configuration Register 169"
  bitfld.word 0x2c 10.--12.       "PA , Pin assignment" "GPIO,ETPUB22,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x2c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x2c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x2c 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x2c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x2c 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x2c 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x2c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x2e "PCR170,Pad Configuration Register 170"
  bitfld.word 0x2e 10.--12.       "PA , Pin assignment" "GPIO,ETPUB23,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x2e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x2e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x2e 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x2e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x2e 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x2e 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x2e 00.            "  WPS , Weak pull up/down select" "0,1"

TEXTLINE "" 
  line.word 0x30 "PCR171,Pad Configuration Register 171"
  bitfld.word 0x30 10.--12.       "PA , Pin assignment" "GPIO,ETPUB24,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x30 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x30 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x30 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x30 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x30 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x30 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x30 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x32 "PCR172,Pad Configuration Register 172"
  bitfld.word 0x32 10.--12.       "PA , Pin assignment" "GPIO,ETPUB25,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x32 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x32 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x32 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x32 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x32 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x32 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x32 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x34 "PCR173,Pad Configuration Register 173"
  bitfld.word 0x34 10.--12.       "PA , Pin assignment" "GPIO,ETPUB26,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x34 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x34 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x34 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x34 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x34 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x34 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x34 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x36 "PCR174,Pad Configuration Register 174"
  bitfld.word 0x36 10.--12.       "PA , Pin assignment" "GPIO,ETPUB27,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x36 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x36 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x36 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x36 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x36 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x36 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x36 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x38 "PCR175,Pad Configuration Register 175"
  bitfld.word 0x38 10.--12.       "PA , Pin assignment" "GPIO,ETPUB28,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x38 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x38 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x38 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x38 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x38 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x38 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x38 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x3a "PCR176,Pad Configuration Register 176"
  bitfld.word 0x3a 10.--12.       "PA , Pin assignment" "GPIO,ETPUB29,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x3a 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x3a 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x3a 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x3a 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x3a 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x3a 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x3a 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x3c "PCR177,Pad Configuration Register 177"
  bitfld.word 0x3c 10.--12.       "PA , Pin assignment" "GPIO,ETPUB30,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x3c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x3c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x3c 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x3c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x3c 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x3c 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x3c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x3e "PCR178,Pad Configuration Register 178"
  bitfld.word 0x3e 10.--12.       "PA , Pin assignment" "GPIO,ETPUB31,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x3e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x3e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x3e 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x3e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x3e 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x3e 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x3e 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F901A6++0x31 "PCR179-202: EMIOS[0:23] / ETPUA[0:9] / SOUTC / SOUTD / IRQ[0:1] / ETPUB[0:7]"
  line.word 0x00 "PCR179,Pad Configuration Register 179"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,EMIOS00,ETPUA00,EMIOS00,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR180,Pad Configuration Register 180"
  bitfld.word 0x02 10.--12.       "PA , Pin assignment" "GPIO,EMIOS01,ETPUA01,EMIOS01,res.,res.,res.,res.      "
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x02 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x04 "PCR181,Pad Configuration Register 181"
  bitfld.word 0x04 10.--12.       "PA , Pin assignment" "GPIO,EMIOS02,ETPUA02,EMIOS02,res.,res.,res.,res.      "
  bitfld.word 0x04 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x04 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x04 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x04 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x04 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x04 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x04 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x06 "PCR182,Pad Configuration Register 182"
  bitfld.word 0x06 10.--12.       "PA , Pin assignment" "GPIO,EMIOS03,ETPUA03,EMIOS03,res.,res.,res.,res.      "
  bitfld.word 0x06 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x06 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x06 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x06 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x06 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x06 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x06 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x08 "PCR183,Pad Configuration Register 183"
  bitfld.word 0x08 10.--12.       "PA , Pin assignment" "GPIO,EMIOS04,ETPUA04,EMIOS04,res.,res.,res.,res.      "
  bitfld.word 0x08 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x08 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x08 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x08 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x08 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x08 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x08 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0a "PCR184,Pad Configuration Register 184"
  bitfld.word 0x0a 10.--12.       "PA , Pin assignment" "GPIO,EMIOS05,ETPUA05,EMIOS05,res.,res.,res.,res.      "
  bitfld.word 0x0a 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0a 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0a 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x0a 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0a 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x0a 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0a 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0c "PCR185,Pad Configuration Register 185"
  bitfld.word 0x0c 10.--12.       "PA , Pin assignment" "GPIO,EMIOS06,ETPUA06,EMIOS06,res.,res.,res.,res.      "
  bitfld.word 0x0c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0c 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x0c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0c 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x0c 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0e "PCR186,Pad Configuration Register 186"
  bitfld.word 0x0e 10.--12.       "PA , Pin assignment" "GPIO,EMIOS07,ETPUA07,EMIOS07,res.,res.,res.,res.      "
  bitfld.word 0x0e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0e 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x0e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0e 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x0e 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0e 00.            "  WPS , Weak pull up/down select" "0,1"

TEXTLINE "" 
  line.word 0x10 "PCR187,Pad Configuration Register 187"
  bitfld.word 0x10 10.--12.       "PA , Pin assignment" "GPIO,EMIOS08,ETPUA08,EMIOS08,res.,res.,res.,res.      "
  bitfld.word 0x10 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x10 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x10 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x10 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x10 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x10 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x10 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x12 "PCR188,Pad Configuration Register 188"
  bitfld.word 0x12 10.--12.       "PA , Pin assignment" "GPIO,EMIOS09,ETPUA09,EMIOS09,res.,res.,res.,res.      "
  bitfld.word 0x12 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x12 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x12 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x12 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x12 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x12 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x12 00.            "  WPS , Weak pull up/down select" "0,1"


  line.word 0x14 "PCR189,Pad Configuration Register 189"
  bitfld.word 0x14 10.--12.       "PA , Pin assignment" "GPIO,EMIOS10,PCSD3,EMIOS10,res.,res.,res.,res.      "
  bitfld.word 0x14 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x14 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x14 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x14 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x14 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x14 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x14 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x16 "PCR190,Pad Configuration Register 190"
  bitfld.word 0x16 10.--12.       "PA , Pin assignment" "GPIO,EMIOS11,PCSD4,EMIOS11,res.,res.,res.,res.      "
  bitfld.word 0x16 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x16 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x16 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x16 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x16 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x16 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x16 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x18 "PCR191,Pad Configuration Register 191"
  bitfld.word 0x18 10.--12.       "PA , Pin assignment" "GPIO,EMIOS12,SOUTC,EMIOS12,res.,res.,res.,res.      "
  bitfld.word 0x18 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x18 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x18 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x18 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x18 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x18 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x18 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x1A "PCR192,Pad Configuration Register 192"
  bitfld.word 0x1A 10.--12.       "PA , Pin assignment" "GPIO,EMIOS13,SOUTD,EMIOS13,res.,res.,res.,res.      "
  bitfld.word 0x1A 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x1A 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x1A 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x1A 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x1A 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x1A 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x1A 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x1c "PCR193,Pad Configuration Register 193"
  bitfld.word 0x1c 10.--12.       "PA , Pin assignment" "GPIO,EMIOS14,IRQ00,EMIOS14,res.,res.,res.,res.      "
  bitfld.word 0x1c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x1c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x1c 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x1c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x1c 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x1c 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x1c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x1e "PCR194,Pad Configuration Register 194"
  bitfld.word 0x1e 10.--12.       "PA , Pin assignment" "GPIO,EMIOS15,IRQ01,EMIOS15,res.,res.,res.,res.      "
  bitfld.word 0x1e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x1e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x1e 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x1e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x1e 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x1e 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x1e 00.            "  WPS , Weak pull up/down select" "0,1"

TEXTLINE ""
  line.word 0x20 "PCR195,Pad Configuration Register 195"
  bitfld.word 0x20 10.--12.       "PA , Pin assignment" "GPIO,EMIOS16,res.,EMIOS16,res.,res.,res.,res.      "
  bitfld.word 0x20 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x20 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x20 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x20 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x20 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x20 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x20 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x22 "PCR196,Pad Configuration Register 196"
  bitfld.word 0x22 10.--12.       "PA , Pin assignment" "GPIO,EMIOS17,res.,EMIOS17,res.,res.,res.,res.      "
  bitfld.word 0x22 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x22 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x22 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x22 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x22 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x22 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x22 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x24 "PCR197,Pad Configuration Register 197"
  bitfld.word 0x24 10.--12.       "PA , Pin assignment" "GPIO,EMIOS18,res.,EMIOS18,res.,res.,res.,res.      "
  bitfld.word 0x24 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x24 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x24 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x24 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x24 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x24 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x24 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x26 "PCR198,Pad Configuration Register 198"
  bitfld.word 0x26 10.--12.       "PA , Pin assignment" "GPIO,EMIOS19,res.,EMIOS19,res.,res.,res.,res.      "
  bitfld.word 0x26 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x26 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x26 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x26 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x26 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x26 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x26 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x28 "PCR199,Pad Configuration Register 199"
  bitfld.word 0x28 10.--12.       "PA , Pin assignment" "GPIO,EMIOS20,res.,EMIOS20,res.,res.,res.,res.      "
  bitfld.word 0x28 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x28 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x28 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x28 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x28 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x28 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x28 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x2a "PCR200,Pad Configuration Register 200"
  bitfld.word 0x2a 10.--12.       "PA , Pin assignment" "GPIO,EMIOS21,res.,EMIOS21,res.,res.,res.,res.      "
  bitfld.word 0x2a 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x2a 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x2a 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x2a 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x2a 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x2a 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x2a 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x2c "PCR201,Pad Configuration Register 201"
  bitfld.word 0x2c 10.--12.       "PA , Pin assignment" "GPIO,EMIOS22,res.,EMIOS22,res.,res.,res.,res.      "
  bitfld.word 0x2c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x2c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x2c 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x2c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x2c 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x2c 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x2c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x2e "PCR202,Pad Configuration Register 202"
  bitfld.word 0x2e 10.--12.       "PA , Pin assignment" "GPIO,EMIOS23,res.,EMIOS23,res.,res.,res.,res.      "
  bitfld.word 0x2e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x2e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x2e 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x2e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x2e 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x2e 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x2e 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F901D6++0x09 "PCR203-207: GPIO / EMIOS[14:15]"
  line.word 0x00 "PCR203,Pad Configuration Register 203"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,EMIOS14,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR204,Pad Configuration Register 204"
  bitfld.word 0x02 10.--12.       "PA , Pin assignment" "GPIO,EMIOS15,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x02 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x04 "PCR205,Pad Configuration Register 205"
  bitfld.word 0x04 10.--12.       "PA , Pin assignment" "GPIO,res.,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x04 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x04 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x04 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x04 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x04 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x04 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x04 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x06 "PCR206,Pad Configuration Register 206"
  bitfld.word 0x06 10.--12.       "PA , Pin assignment" "GPIO,res.,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x06 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x06 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x06 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x06 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x06 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x06 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x06 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x08 "PCR207,Pad Configuration Register 207"
  bitfld.word 0x08 10.--12.       "PA , Pin assignment" "GPIO,res.,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x08 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x08 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x08 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x08 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x08 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x08 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x08 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F901E0++0x03 "PCR208-209: PLLCFG[0:1] / IRQ[4:5] / SOUTD"
  line.word 0x00 "PCR208,Pad Configuration Register 208"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,PLLCFG0,IRQ04,PLLCFG0,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR209,Pad Configuration Register 209"
  bitfld.word 0x02 10.--12.       "PA , Pin assignment" "GPIO,PLLCFG1,IRQ05,PLLCFG1,SOUTD,res.,res.,res.      "
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x02 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F901E4++0x01 "PCR210: !RSCFG"
  line.word 0x00 "PCR210,Pad Configuration Register 210"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,!RSCFG,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F901E6++0x03 "PCR211-212: BOOTCFG[0:1] / IRQ[2:3]"
  line.word 0x00 "PCR211,Pad Configuration Register 211"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,BOOTCFG0,IRQ02,BOOTCFG0,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR212,Pad Configuration Register 212"
  bitfld.word 0x02 10.--12.       "PA , Pin assignment" "GPIO,BOOTCFG1,IRQ03,BOOTCFG0,res.,res.,res.,res.      "
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x02 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F901EA++0x01 "PCR213: WKPCFG"
  line.word 0x00 "PCR213,Pad Configuration Register 213"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,WKPCFG,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F901EC++0x01 "PCR214: ENGCLK"
  line.word 0x00 "PCR214,Pad Configuration Register 214"

; bitfld.word 0x00 10.--13.       "PA , Pin assignment" "   0,   1,   2,   3,   4,   5,   6,   7,   8,   9,   A,   B,   C,   D,   E,   F"
  bitfld.word 0x00 09.            "         OBE , Output buffer enable" "0,1"
; bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "         DSC , Drive strength control" "10pF,20pF,30pF,50pF"
; bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
; bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
; bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
; bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
; bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

group 0xC3F901EE++0x01 "PCR215: AN12 / MA0 / !SDS"
  line.word 0x00 "PCR215,Pad Configuration Register 215"

  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "!SDS,res.,MA0,AN12,res.,res.,res.,res.      "
;  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
;  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
; bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
;  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
;  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
;  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F901F0++0x01 "PCR216: AN13 / MA1 / SDO"
  line.word 0x00 "PCR216,Pad Configuration Register 216"

  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "SDO,res.,MA1,AN13,res.,res.,res.,res.      "
;  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
;  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
; bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
;  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
;  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
;  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F901F2++0x01 "PCR217: AN14 / MA2 / SDI"
  line.word 0x00 "PCR217,Pad Configuration Register 217"

  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "SDI,res.,MA2,AN14,res.,res.,res.,res.      "
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F901F4++0x01 "PCR218: AN15 / FCK"
  line.word 0x00 "PCR218,Pad Configuration Register 218"

  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "FCK,AN15,res.,res.,res.,res.,res.,res.      "
;  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
;  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
; bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
;  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
;  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
;  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F901F6++0x01 "PCR219: MCKO"
  line.word 0x00 "PCR219,Pad Configuration Register 219"

;  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "   0,   1,   2,   3,   4,   5,   6,   7,   8,   9,   A,   B,   C,   D,   E,   F"
;  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
;  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "                       DSC , Drive strength control" "10pF,20pF,30pF,50pF"
;  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
;  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
;  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
;  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
;  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

group 0xC3F901F8++0x09 "PCR220-223: MDO[0:3]"
  line.word 0x00 "PCR220,Pad Configuration Register 220"

;  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "   0,   1,   2,   3,   4,   5,   6,   7,   8,   9,   A,   B,   C,   D,   E,   F"
;  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
;  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "                       DSC , Drive strength control" "10pF,20pF,30pF,50pF"
;  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
;  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
;  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
;  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
;  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"
  line.word 0x02 "PCR221,Pad Configuration Register 221"

;  bitfld.word 0x02 10.--13.       "PA , Pin assignment" "   0,   1,   2,   3,   4,   5,   6,   7,   8,   9,   A,   B,   C,   D,   E,   F"
;  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
;  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 06.--07.       "                       DSC , Drive strength control" "10pF,20pF,30pF,50pF"
;  bitfld.word 0x02 05.            "  ODE , Open drain output enable" "0,1"
;  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
;  bitfld.word 0x02 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
;  bitfld.word 0x02 01.            "  WPE , Weak pull up/down enable" "0,1"
;  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"
  line.word 0x04 "PCR222,Pad Configuration Register 222"

;  bitfld.word 0x04 10.--13.       "PA , Pin assignment" "   0,   1,   2,   3,   4,   5,   6,   7,   8,   9,   A,   B,   C,   D,   E,   F"
;  bitfld.word 0x04 09.            "  OBE , Output buffer enable" "0,1"
;  bitfld.word 0x04 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x04 06.--07.       "                       DSC , Drive strength control" "10pF,20pF,30pF,50pF"
;  bitfld.word 0x04 05.            "  ODE , Open drain output enable" "0,1"
;  bitfld.word 0x04 04.            "  HYS , Input hysteresis" "0,1"
;  bitfld.word 0x04 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
;  bitfld.word 0x04 01.            "  WPE , Weak pull up/down enable" "0,1"
;  bitfld.word 0x04 00.            "  WPS , Weak pull up/down select" "0,1"
  line.word 0x06 "PCR223,Pad Configuration Register 223"

;  bitfld.word 0x06 10.--13.       "PA , Pin assignment" "   0,   1,   2,   3,   4,   5,   6,   7,   8,   9,   A,   B,   C,   D,   E,   F"
;  bitfld.word 0x06 09.            "  OBE , Output buffer enable" "0,1"
;  bitfld.word 0x06 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x06 06.--07.       "                       DSC , Drive strength control" "10pF,20pF,30pF,50pF"
;  bitfld.word 0x06 05.            "  ODE , Open drain output enable" "0,1"
;  bitfld.word 0x06 04.            "  HYS , Input hysteresis" "0,1"
;  bitfld.word 0x06 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
;  bitfld.word 0x06 01.            "  WPE , Weak pull up/down enable" "0,1"
;  bitfld.word 0x06 00.            "  WPS , Weak pull up/down select" "0,1"

group 0xC3F90200++0x03 "PCR224-225: !MSEO[0:1]"
  line.word 0x00 "PCR224,Pad Configuration Register 224"

;  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "   0,   1,   2,   3,   4,   5,   6,   7,   8,   9,   A,   B,   C,   D,   E,   F"
;  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
;  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "                       DSC , Drive strength control" "10pF,20pF,30pF,50pF"
;  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
;  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
;  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
;  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
;  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"
  line.word 0x02 "PCR225,Pad Configuration Register 225"

;  bitfld.word 0x02 10.--13.       "PA , Pin assignment" "   0,   1,   2,   3,   4,   5,   6,   7,   8,   9,   A,   B,   C,   D,   E,   F"
;  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
;  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 06.--07.       "                       DSC , Drive strength control" "10pF,20pF,30pF,50pF"
;  bitfld.word 0x02 05.            "  ODE , Open drain output enable" "0,1"
;  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
;  bitfld.word 0x02 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
;  bitfld.word 0x02 01.            "  WPE , Weak pull up/down enable" "0,1"
;  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"

group 0xC3F90204++0x01 "PCR226: !RDY"
  line.word 0x00 "PCR226,Pad Configuration Register 226"

;  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "   0,   1,   2,   3,   4,   5,   6,   7,   8,   9,   A,   B,   C,   D,   E,   F"
;  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
;  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "                       DSC , Drive strength control" "10pF,20pF,30pF,50pF"
;  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
;  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
;  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
;  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
;  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

group 0xC3F90206++0x01 "PCR227: !EVTO"
  line.word 0x00 "PCR227,Pad Configuration Register 227"

;  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "   0,   1,   2,   3,   4,   5,   6,   7,   8,   9,   A,   B,   C,   D,   E,   F"
;  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
;  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "                       DSC , Drive strength control" "10pF,20pF,30pF,50pF"
;  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
;  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
;  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
;  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
;  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

group 0xC3F90208++0x01 "PCR228: TDO"
  line.word 0x00 "PCR228,Pad Configuration Register 228"

;  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "   0,   1,   2,   3,   4,   5,   6,   7,   8,   9,   A,   B,   C,   D,   E,   F"
;  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
;  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "                       DSC , Drive strength control" "10pF,20pF,30pF,50pF"
;  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
;  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
;  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
;  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
;  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

group 0xC3F9020A++0x01 "PCR229: !CLKOUT"
  line.word 0x00 "PCR229,Pad Configuration Register 229"

; bitfld.word 0x00 10.--13.       "PA , Pin assignment" "   0,   1,   2,   3,   4,   5,   6,   7,   8,   9,   A,   B,   C,   D,   E,   F"
  bitfld.word 0x00 09.            "         OBE , Output buffer enable" "0,1"
; bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "         DSC , Drive strength control" "10pF,20pF,30pF,50pF"
; bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
; bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
; bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
; bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
; bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

group 0xC3F9020C++0x01 "PCR230: !RSTOUT"
  line.word 0x00 "PCR230,Pad Configuration Register 230"

;  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "   0,   1,   2,   3,   4,   5,   6,   7,   8,   9,   A,   B,   C,   D,   E,   F"
;  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
;  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
;  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
;  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
;  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "                                               SRC , Slew rate control" "Min,Med,res,Max"
;  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
;  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"
endif

sif (CPU()=="MPC5565")
group 0xC3F90040++0x07 "PCR000-PCR003: !CS[0:3] / ADDR[8:11]"
  line.word 0x00 "PCR000,Pad Configuration Register 000"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPI0,!CS0,ADDR08,!CS0,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR001,Pad Configuration Register 001"
  bitfld.word 0x02 10.--12.       "PA , Pin assignment" "GPI0,!CS1,ADDR09,!CS1,res.,res.,res.,res.      "
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x02 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x04 "PCR002,Pad Configuration Register 002"
  bitfld.word 0x04 10.--12.       "PA , Pin assignment" "GPI0,!CS2,ADDR10,!CS2,res.,res.,res.,res.      "
  bitfld.word 0x04 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x04 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x04 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x04 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x04 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x04 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x04 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x06 "PCR003,Pad Configuration Register 003"
  bitfld.word 0x06 10.--12.       "PA , Pin assignment" "GPI0,!CS3,ADDR11,!CS3,res.,res.,res.,res.      "
  bitfld.word 0x06 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x06 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x06 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x06 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x06 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x06 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x06 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90048++0x2f "PCR004-PCR011: ADDR[8:15]"
  line.word 0x00 "PCR004,Pad Configuration Register 004"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,ADDR08,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR005,Pad Configuration Register 005"
  bitfld.word 0x02 10.--12.       "PA , Pin assignment" "GPIO,ADDR09,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x02 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x04 "PCR006,Pad Configuration Register 006"
  bitfld.word 0x04 10.--12.       "PA , Pin assignment" "GPIO,ADDR10,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x04 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x04 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x04 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x04 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x04 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x04 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x04 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x06 "PCR007,Pad Configuration Register 007"
  bitfld.word 0x06 10.--12.       "PA , Pin assignment" "GPIO,ADDR11,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x06 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x06 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x06 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x06 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x06 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x06 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x06 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x08 "PCR008,Pad Configuration Register 008"
  bitfld.word 0x08 10.--12.       "PA , Pin assignment" "GPIO,ADDR12,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x08 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x08 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x08 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x08 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x08 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x08 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x08 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0a "PCR009,Pad Configuration Register 009"
  bitfld.word 0x0a 10.--12.       "PA , Pin assignment" "GPIO,ADDR13,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x0a 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0a 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0a 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x0a 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x0a 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0a 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0a 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0c "PCR010,Pad Configuration Register 010"
  bitfld.word 0x0c 10.--12.       "PA , Pin assignment" "GPIO,ADDR14,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x0c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0c 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x0c 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x0c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0c 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0e "PCR011,Pad Configuration Register 011"
  bitfld.word 0x0e 10.--12.       "PA , Pin assignment" "GPIO,ADDR15,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x0e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0e 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x0e 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x0e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0e 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0e 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90048++0x2f "PCR012-PCR027: ADDR[16:31]"
  line.word 0x10 "PCR012,Pad Configuration Register 012"
  bitfld.word 0x10 10.--12.       "PA , Pin assignment" "GPIO,ADDR16,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x10 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x10 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x10 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x10 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x10 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x10 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x10 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x12 "PCR013,Pad Configuration Register 013"
  bitfld.word 0x12 10.--12.       "PA , Pin assignment" "GPIO,ADDR17,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x12 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x12 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x12 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x12 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x12 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x12 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x12 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x14 "PCR014,Pad Configuration Register 014"
  bitfld.word 0x14 10.--12.       "PA , Pin assignment" "GPIO,ADDR18,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x14 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x14 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x14 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x14 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x14 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x14 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x14 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x16 "PCR015,Pad Configuration Register 015"
  bitfld.word 0x16 10.--12.       "PA , Pin assignment" "GPIO,ADDR19,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x16 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x16 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x16 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x16 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x16 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x16 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x16 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x18 "PCR016,Pad Configuration Register 016"
  bitfld.word 0x18 10.--12.       "PA , Pin assignment" "GPIO,ADDR20,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x18 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x18 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x18 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x18 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x18 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x18 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x18 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x1A "PCR017,Pad Configuration Register 017"
  bitfld.word 0x1A 10.--12.       "PA , Pin assignment" "GPIO,ADDR21,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x1A 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x1A 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x1A 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x1A 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x1A 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x1A 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x1A 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x1C "PCR018,Pad Configuration Register 018"
  bitfld.word 0x1C 10.--12.       "PA , Pin assignment" "GPIO,ADDR22,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x1C 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x1C 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x1C 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x1C 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x1C 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x1C 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x1C 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x1E "PCR019,Pad Configuration Register 019"
  bitfld.word 0x1E 10.--12.       "PA , Pin assignment" "GPIO,ADDR23,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x1E 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x1E 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x1E 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x1E 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x1E 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x1E 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x1E 00.            "  WPS , Weak pull up/down select" "0,1"

TEXTLINE ""
  line.word 0x20 "PCR020,Pad Configuration Register 020"
  bitfld.word 0x20 10.--12.       "PA , Pin assignment" "GPIO,ADDR24,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x20 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x20 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x20 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x20 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x20 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x20 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x20 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x22 "PCR021,Pad Configuration Register 021"
  bitfld.word 0x22 10.--12.       "PA , Pin assignment" "GPIO,ADDR25,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x22 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x22 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x22 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x22 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x22 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x22 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x22 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x24 "PCR022,Pad Configuration Register 022"
  bitfld.word 0x24 10.--12.       "PA , Pin assignment" "GPIO,ADDR26,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x24 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x24 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x24 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x24 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x24 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x24 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x24 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x26 "PCR023,Pad Configuration Register 023"
  bitfld.word 0x26 10.--12.       "PA , Pin assignment" "GPIO,ADDR27,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x26 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x26 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x26 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x26 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x26 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x26 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x26 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x28 "PCR024,Pad Configuration Register 024"
  bitfld.word 0x28 10.--12.       "PA , Pin assignment" "GPIO,ADDR28,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x28 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x28 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x28 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x28 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x28 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x28 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x28 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x2a "PCR025,Pad Configuration Register 025"
  bitfld.word 0x2a 10.--12.       "PA , Pin assignment" "GPIO,ADDR29,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x2a 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x2a 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x2a 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x2a 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x2a 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x2a 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x2a 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x2c "PCR026,Pad Configuration Register 026"
  bitfld.word 0x2c 10.--12.       "PA , Pin assignment" "GPIO,ADDR30,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x2c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x2c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x2c 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x2c 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x2c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x2c 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x2c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x2e "PCR027,Pad Configuration Register 027"
  bitfld.word 0x2e 10.--12.       "PA , Pin assignment" "GPIO,ADDR31,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x2e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x2e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x2e 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x2e 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x2e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x2e 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x2e 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90078++0x3f "PCR028-PCR043: DATA[0:15]"
  line.word 0x00 "PCR028,Pad Configuration Register 028"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,DATA00,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR029,Pad Configuration Register 029"
  bitfld.word 0x02 10.--12.       "PA , Pin assignment" "GPIO,DATA01,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x02 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x04 "PCR030,Pad Configuration Register 030"
  bitfld.word 0x04 10.--12.       "PA , Pin assignment" "GPIO,DATA02,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x04 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x04 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x04 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x04 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x04 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x04 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x04 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x06 "PCR031,Pad Configuration Register 031"
  bitfld.word 0x06 10.--12.       "PA , Pin assignment" "GPIO,DATA03,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x06 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x06 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x06 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x06 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x06 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x06 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x06 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x08 "PCR032,Pad Configuration Register 032"
  bitfld.word 0x08 10.--12.       "PA , Pin assignment" "GPIO,DATA04,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x08 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x08 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x08 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x08 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x08 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x08 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x08 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0a "PCR033,Pad Configuration Register 033"
  bitfld.word 0x0a 10.--12.       "PA , Pin assignment" "GPIO,DATA05,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x0a 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0a 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0a 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x0a 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x0a 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0a 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0a 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0c "PCR034,Pad Configuration Register 034"
  bitfld.word 0x0c 10.--12.       "PA , Pin assignment" "GPIO,DATA06,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x0c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0c 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x0c 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x0c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0c 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0e "PCR035,Pad Configuration Register 035"
  bitfld.word 0x0e 10.--12.       "PA , Pin assignment" "GPIO,DATA07,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x0e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0e 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x0e 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x0e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0e 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0e 00.            "  WPS , Weak pull up/down select" "0,1"

TEXTLINE ""
  line.word 0x10 "PCR036,Pad Configuration Register 036"
  bitfld.word 0x10 10.--12.       "PA , Pin assignment" "GPIO,DATA08,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x10 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x10 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x10 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x10 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x10 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x10 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x10 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x12 "PCR037,Pad Configuration Register 037"
  bitfld.word 0x12 10.--12.       "PA , Pin assignment" "GPIO,DATA09,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x12 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x12 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x12 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x12 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x12 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x12 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x12 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x14 "PCR038,Pad Configuration Register 038"
  bitfld.word 0x14 10.--12.       "PA , Pin assignment" "GPIO,DATA10,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x14 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x14 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x14 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x14 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x14 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x14 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x14 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x16 "PCR039,Pad Configuration Register 039"
  bitfld.word 0x16 10.--12.       "PA , Pin assignment" "GPIO,DATA11,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x16 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x16 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x16 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x16 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x16 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x16 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x16 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x18 "PCR040,Pad Configuration Register 040"
  bitfld.word 0x18 10.--12.       "PA , Pin assignment" "GPIO,DATA12,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x18 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x18 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x18 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x18 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x18 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x18 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x18 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x1A "PCR041,Pad Configuration Register 041"
  bitfld.word 0x1A 10.--12.       "PA , Pin assignment" "GPIO,DATA13,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x1A 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x1A 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x1A 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x1A 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x1A 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x1A 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x1A 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x1c "PCR042,Pad Configuration Register 042"
  bitfld.word 0x1c 10.--12.       "PA , Pin assignment" "GPIO,DATA14,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x1c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x1c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x1c 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x1c 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x1c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x1c 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x1c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x1e "PCR043,Pad Configuration Register 043"
  bitfld.word 0x1e 10.--12.       "PA , Pin assignment" "GPIO,DATA15,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x1e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x1e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x1e 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x1e 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x1e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x1e 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x1e 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90078++0x3f "PCR044-PCR059: DATA[16:31]"
  line.word 0x20 "PCR044,Pad Configuration Register 044"
  bitfld.word 0x20 10.--12.       "PA , Pin assignment" "GPIO,DATA16,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x20 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x20 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x20 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x20 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x20 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x20 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x20 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x22 "PCR045,Pad Configuration Register 045"
  bitfld.word 0x22 10.--12.       "PA , Pin assignment" "GPIO,DATA17,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x22 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x22 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x22 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x22 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x22 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x22 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x22 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x24 "PCR046,Pad Configuration Register 046"
  bitfld.word 0x24 10.--12.       "PA , Pin assignment" "GPIO,DATA18,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x24 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x24 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x24 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x24 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x24 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x24 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x24 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x26 "PCR047,Pad Configuration Register 047"
  bitfld.word 0x26 10.--12.       "PA , Pin assignment" "GPIO,DATA19,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x26 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x26 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x26 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x26 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x26 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x26 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x26 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x28 "PCR048,Pad Configuration Register 048"
  bitfld.word 0x28 10.--12.       "PA , Pin assignment" "GPIO,DATA20,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x28 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x28 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x28 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x28 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x28 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x28 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x28 00.            "  WPS , Weak pull up/down select" "0,1"


  line.word 0x2a "PCR049,Pad Configuration Register 049"
  bitfld.word 0x2a 10.--12.       "PA , Pin assignment" "GPIO,DATA21,res.,DATA21,res.,res.,res.,res.      "
  bitfld.word 0x2a 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x2a 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x2a 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x2a 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x2a 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x2a 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x2a 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x2c "PCR050,Pad Configuration Register 050"
  bitfld.word 0x2c 10.--12.       "PA , Pin assignment" "GPIO,DATA22,res.,DATA22,res.,res.,res.,res.      "
  bitfld.word 0x2c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x2c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x2c 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x2c 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x2c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x2c 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x2c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x2e "PCR051,Pad Configuration Register 051"
  bitfld.word 0x2e 10.--12.       "PA , Pin assignment" "GPIO,DATA23,res.,DATA23,res.,res.,res.,res.      "
  bitfld.word 0x2e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x2e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x2e 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x2e 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x2e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x2e 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x2e 00.            "  WPS , Weak pull up/down select" "0,1"

TEXTLINE ""
  line.word 0x30 "PCR052,Pad Configuration Register 052"
  bitfld.word 0x30 10.--12.       "PA , Pin assignment" "GPIO,DATA24,res.,DATA24,res.,res.,res.,res.      "
  bitfld.word 0x30 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x30 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x30 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x30 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x30 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x30 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x30 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x32 "PCR053,Pad Configuration Register 053"
  bitfld.word 0x32 10.--12.       "PA , Pin assignment" "GPIO,DATA25,res.,DATA25,res.,res.,res.,res.      "
  bitfld.word 0x32 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x32 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x32 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x32 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x32 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x32 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x32 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x34 "PCR054,Pad Configuration Register 054"
  bitfld.word 0x34 10.--12.       "PA , Pin assignment" "GPIO,DATA26,res.,DATA26,res.,res.,res.,res.      "
  bitfld.word 0x34 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x34 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x34 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x34 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x34 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x34 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x34 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x36 "PCR055,Pad Configuration Register 055"
  bitfld.word 0x36 10.--12.       "PA , Pin assignment" "GPIO,DATA27,res.,DATA27,res.,res.,res.,res.      "
  bitfld.word 0x36 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x36 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x36 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x36 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x36 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x36 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x36 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x38 "PCR056,Pad Configuration Register 056"
  bitfld.word 0x38 10.--12.       "PA , Pin assignment" "GPIO,DATA28,res.,DATA28,res.,res.,res.,res.      "
  bitfld.word 0x38 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x38 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x38 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x38 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x38 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x38 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x38 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x3a "PCR057,Pad Configuration Register 057"
  bitfld.word 0x3a 10.--12.       "PA , Pin assignment" "GPIO,DATA29,res.,DATA29,res.,res.,res.,res.      "
  bitfld.word 0x3a 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x3a 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x3a 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x3a 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x3a 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x3a 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x3a 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x3c "PCR058,Pad Configuration Register 058"
  bitfld.word 0x3c 10.--12.       "PA , Pin assignment" "GPIO,DATA30,res.,DATA30,res.,res.,res.,res.      "
  bitfld.word 0x3c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x3c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x3c 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x3c 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x3c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x3c 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x3c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x3e "PCR059,Pad Configuration Register 059"
  bitfld.word 0x3e 10.--12.       "PA , Pin assignment" "GPIO,DATA31,res.,DATA31,res.,res.,res.,res.      "
  bitfld.word 0x3e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x3e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x3e 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x3e 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x3e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x3e 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x3e 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900BC++0x01 "PCR062: RD/!WR"
  line.word 0x00 "PCR062,Pad Configuration Register 062"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,RD/!WR,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900BE++0x01 "PCR063: !BDIP"
  line.word 0x00 "PCR063,Pad Configuration Register 063"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,!BDIP,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900C0++0x07 "PCR064-067: !WE_BE[0:3]"
  line.word 0x00 "PCR064,Pad Configuration Register 064"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,!WE0_BE0,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR065,Pad Configuration Register 065"
  bitfld.word 0x02 10.--12.       "PA , Pin assignment" "GPIO,!WE1_BE1,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x02 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x04 "PCR066,Pad Configuration Register 066"
  bitfld.word 0x04 10.--12.       "PA , Pin assignment" "GPIO,!WE2_BE2,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x04 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x04 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x04 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x04 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x04 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x04 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x04 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x06 "PCR067,Pad Configuration Register 067"
  bitfld.word 0x06 10.--12.       "PA , Pin assignment" "GPIO,!WE3_BE3,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x06 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x06 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x06 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x06 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x06 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x06 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x06 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900C8++0x01 "PCR068: !OE"
  line.word 0x00 "PCR068,Pad Configuration Register 068"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,!OE,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900CA++0x01 "PCR069: !TS"
  line.word 0x00 "PCR069,Pad Configuration Register 069"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,!TS,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900CC++0x01 "PCR070: !TA"
  line.word 0x00 "PCR070,Pad Configuration Register 070"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,!TA,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900CE++0x01 "PCR071: !TEA"
  line.word 0x00 "PCR071,Pad Configuration Register 071"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,!TEA,res.,!TEA,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900D0++0x01 "PCR072: GPIO"
  line.word 0x00 "PCR072,Pad Configuration Register 072"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,res.,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900D2++0x01 "PCR073: GPIO"
  line.word 0x00 "PCR073,Pad Configuration Register 073"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,res.,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900D6++0x0f "PCR075-PCR082: MDO[4:11]"
  line.word 0x00 "PCR075,Pad Configuration Register 075"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO/MDO04,res.,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR076,Pad Configuration Register 076"
  bitfld.word 0x02 10.--12.       "PA , Pin assignment" "GPIO/MDO05,res.,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x02 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x04 "PCR077,Pad Configuration Register 077"
  bitfld.word 0x04 10.--12.       "PA , Pin assignment" "GPIO/MDO06,res.,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x04 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x04 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x04 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x04 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x04 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x04 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x04 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x06 "PCR078,Pad Configuration Register 078"
  bitfld.word 0x06 10.--12.       "PA , Pin assignment" "GPIO/MDO07,res.,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x06 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x06 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x06 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x06 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x06 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x06 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x06 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x08 "PCR079,Pad Configuration Register 079"
  bitfld.word 0x08 10.--12.       "PA , Pin assignment" "GPIO/MDO08,res.,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x08 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x08 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x08 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x08 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x08 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x08 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x08 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0a "PCR080,Pad Configuration Register 080"
  bitfld.word 0x0a 10.--12.       "PA , Pin assignment" "GPIO/MDO09,res.,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x0a 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0a 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0a 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x0a 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x0a 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0a 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0a 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0c "PCR081,Pad Configuration Register 081"
  bitfld.word 0x0c 10.--12.       "PA , Pin assignment" "GPIO/MDO10,res.,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x0c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0c 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x0c 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x0c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0c 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0e "PCR082,Pad Configuration Register 082"
  bitfld.word 0x0e 10.--12.       "PA , Pin assignment" "GPIO/MDO11,res.,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x0e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0e 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x0e 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x0e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0e 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0e 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900E6++0x01 "PCR083: CNTX_A"
  line.word 0x00 "PCR083,Pad Configuration Register 083"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,CNTX_A,res.,CNTX_A,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900E8++0x01 "PCR084: CNRX_A"
  line.word 0x00 "PCR084,Pad Configuration Register 084"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,CNRX_A,res.,CNRX_A,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900EA++0x01 "PCR085: CNTX_B / DSPI PCSC3"
  line.word 0x00 "PCR085,Pad Configuration Register 085"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,CNTX_B,PCSC3,CNTX_B,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900EC++0x01 "PCR086: CNRX_B / DSPI PCSC4"
  line.word 0x00 "PCR086,Pad Configuration Register 086"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,CNRX_B,PCSC4,CNRX_B,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900EE++0x01 "PCR087: CNTX_C / DSPI PCSD3"
  line.word 0x00 "PCR087,Pad Configuration Register 087"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,CNTX_C,PCSD3,CNTX_C,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900F0++0x01 "PCR088: CNRX_C / DSPI PCSD4"
  line.word 0x00 "PCR088,Pad Configuration Register 088"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,CNRX_C,PCSD4,CNRX_C,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900F2++0x01 "PCR089: TXD_A"
  line.word 0x00 "PCR089,Pad Configuration Register 089"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,TXD_A,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900F4++0x01 "PCR090: RXD_A"
  line.word 0x00 "PCR090,Pad Configuration Register 090"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,RXD_A,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900F6++0x01 "PCR091: TXD_B / DSPI PCSD1"
  line.word 0x00 "PCR091,Pad Configuration Register 091"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,TXD_B,PCSD1,TXD_B,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900F8++0x01 "PCR092: RXD_B / PCSD5"
  line.word 0x00 "PCR092,Pad Configuration Register 092"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,RXD_B,PCSD5,RXD_B,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900FA++0x01 "PCR093: DSPI PCSC1"
  line.word 0x00 "PCR093,Pad Configuration Register 093"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,res.,PCSC1,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900FC++0x01 "PCR094: DSPI PCSC2"
  line.word 0x00 "PCR094,Pad Configuration Register 094"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,res.,PCSC2,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900FE++0x01 "PCR095: DSPI PCSC5"
  line.word 0x00 "PCR095,Pad Configuration Register 095"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,res.,PCSC5,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90100++0x01 "PCR096: DSPI PCSD2"
  line.word 0x00 "PCR096,Pad Configuration Register 096"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,res.,PCSD2,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90102++0x01 "PCR097: PCSB2"
  line.word 0x00 "PCR097,Pad Configuration Register 097"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,res.,PCSB2,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90104++0x01 "PCR098: DSPI SCKD"
  line.word 0x00 "PCR098,Pad Configuration Register 098"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,res.,SCKD,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90106++0x01 "PCR099: DSPI SIN_D"
  line.word 0x00 "PCR099,Pad Configuration Register 099"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,res.,SIN_D,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90108++0x01 "PCR100: DSPI SOUTD"
  line.word 0x00 "PCR100,Pad Configuration Register 100"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,res.,SOUTD,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F9010a++0x01 "PCR101: DSPI PCSB3"
  line.word 0x00 "PCR101,Pad Configuration Register 101"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,res.,PCSB3,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F9010c++0x01 "PCR102: DSPI SCKB / DSPI PCSC1"
  line.word 0x00 "PCR102,Pad Configuration Register 102"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,SCKB,PCSC1,SCKB,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F9010e++0x01 "PCR103: DSPI SINB / DSPI PCSC2"
  line.word 0x00 "PCR103,Pad Configuration Register 103"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,SINB,PCSC2,SINB,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90110++0x01 "PCR104: DSPI SOUTB / DSPI PCSC5"
  line.word 0x00 "PCR104,Pad Configuration Register 104"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,SOUTB,PCSC5,SOUTB,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90112++0x01 "PCR105: DSPI PCSB0 / DSPI PCSD2"
  line.word 0x00 "PCR105,Pad Configuration Register 105"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,PCSB0,PCSD2,PCSB0,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90114++0x01 "PCR106: DSPI PCSB1 / DSPI PCSD0"
  line.word 0x00 "PCR106,Pad Configuration Register 106"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,PCSB1,PCSD0,PCSB1,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90116++0x01 "PCR107: DSPI PCSB2 / DSPI SOUTC"
  line.word 0x00 "PCR107,Pad Configuration Register 107"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,PCSB2,SOUTC,PCSB2,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90118++0x01 "PCR108: DSPI PCSB3 / DSPI SINC"
  line.word 0x00 "PCR108,Pad Configuration Register 108"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,PCSB3,SINC,PCSB3,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F9011A++0x01 "PCR109: DSPI PCSB4 / DSPI SCKC"
  line.word 0x00 "PCR109,Pad Configuration Register 109"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,PCSB4,SCKC,PCSB4,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F9011C++0x01 "PCR110: DSPI PCSB5 / DSPI PCSC0"
  line.word 0x00 "PCR110,Pad Configuration Register 110"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,PCSB5,PCSC0,PCSB5,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F9011E++0x03 "PCR111-112: ETRIG[0:1]"
  line.word 0x00 "PCR111,Pad Configuration Register 111"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,ETRIG0,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR112,Pad Configuration Register 112"
  bitfld.word 0x02 10.--12.       "PA , Pin assignment" "GPIO,ETRIG1,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x02 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90122++0x01 "PCR113: TCRCLKA / IRQ7"
  line.word 0x00 "PCR113,Pad Configuration Register 113"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,TCRCLKA,IRQ7,TCRCLKA,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90124++0x3F "PCR114-145: ETPUA[0:31] / ETPUA[12:23] / PCSB[1:4] / IRQ[8:15] / PCDC[1:4] / PCSD[1:4]"
  line.word 0x00 "PCR114,Pad Configuration Register 114"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,ETPUA00,ETPUA12,ETPUA00,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR115,Pad Configuration Register 115"
  bitfld.word 0x02 10.--12.       "PA , Pin assignment" "GPIO,ETPUA01,ETPUA13,ETPUA01,res.,res.,res.,res.      "
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x02 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x04 "PCR116,Pad Configuration Register 116"
  bitfld.word 0x04 10.--12.       "PA , Pin assignment" "GPIO,ETPUA02,ETPUA14,ETPUA02,res.,res.,res.,res.      "
  bitfld.word 0x04 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x04 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x04 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x04 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x04 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x04 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x04 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x06 "PCR117,Pad Configuration Register 117"
  bitfld.word 0x06 10.--12.       "PA , Pin assignment" "GPIO,ETPUA03,ETPUA15,ETPUA03,res.,res.,res.,res.      "
  bitfld.word 0x06 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x06 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x06 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x06 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x06 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x06 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x06 00.            "  WPS , Weak pull up/down select" "0,1"


  line.word 0x08 "PCR118,Pad Configuration Register 118"
  bitfld.word 0x08 10.--12.       "PA , Pin assignment" "GPIO,ETPUA04,ETPUA16,ETPUA04,res.,res.,res.,res.      "
  bitfld.word 0x08 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x08 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x08 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x08 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x08 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x08 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x08 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0a "PCR119,Pad Configuration Register 119"
  bitfld.word 0x0a 10.--12.       "PA , Pin assignment" "GPIO,ETPUA05,ETPUA17,ETPUA05,res.,res.,res.,res.      "
  bitfld.word 0x0a 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0a 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0a 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x0a 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0a 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x0a 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0a 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0c "PCR120,Pad Configuration Register 120"
  bitfld.word 0x0c 10.--12.       "PA , Pin assignment" "GPIO,ETPUA06,ETPUA18,ETPUA06,res.,res.,res.,res.      "
  bitfld.word 0x0c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0c 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x0c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0c 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x0c 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0e "PCR121,Pad Configuration Register 121"
  bitfld.word 0x0e 10.--12.       "PA , Pin assignment" "GPIO,ETPUA07,ETPUA19,ETPUA07,res.,res.,res.,res.      "
  bitfld.word 0x0e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0e 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x0e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0e 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x0e 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0e 00.            "  WPS , Weak pull up/down select" "0,1"

TEXTLINE "" 
  line.word 0x10 "PCR122,Pad Configuration Register 122"
  bitfld.word 0x10 10.--12.       "PA , Pin assignment" "GPIO,ETPUA08,ETPUA20,ETPUA08,res.,res.,res.,res.      "
  bitfld.word 0x10 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x10 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x10 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x10 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x10 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x10 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x10 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x12 "PCR123,Pad Configuration Register 123"
  bitfld.word 0x12 10.--12.       "PA , Pin assignment" "GPIO,ETPUA09,ETPUA21,ETPUA09,res.,res.,res.,res.      "
  bitfld.word 0x12 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x12 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x12 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x12 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x12 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x12 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x12 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x14 "PCR124,Pad Configuration Register 124"
  bitfld.word 0x14 10.--12.       "PA , Pin assignment" "GPIO,ETPUA10,ETPUA22,ETPUA10,res.,res.,res.,res.      "
  bitfld.word 0x14 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x14 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x14 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x14 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x14 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x14 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x14 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x16 "PCR125,Pad Configuration Register 125"
  bitfld.word 0x16 10.--12.       "PA , Pin assignment" "GPIO,ETPUA11,ETPUA23,ETPUA11,res.,res.,res.,res.      "
  bitfld.word 0x16 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x16 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x16 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x16 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x16 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x16 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x16 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x18 "PCR126,Pad Configuration Register 126"
  bitfld.word 0x18 10.--12.       "PA , Pin assignment" "GPIO,ETPUA12,PCSB1,ETPUA12,res.,res.,res.,res.      "
  bitfld.word 0x18 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x18 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x18 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x18 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x18 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x18 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x18 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x1A "PCR127,Pad Configuration Register 127"
  bitfld.word 0x1A 10.--12.       "PA , Pin assignment" "GPIO,ETPUA13,PCSB3,ETPUA13,res.,res.,res.,res.      "
  bitfld.word 0x1A 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x1A 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x1A 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x1A 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x1A 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x1A 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x1A 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x1c "PCR128,Pad Configuration Register 128"
  bitfld.word 0x1c 10.--12.       "PA , Pin assignment" "GPIO,ETPUA14,PCSB4,ETPUA14,res.,res.,res.,res.      "
  bitfld.word 0x1c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x1c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x1c 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x1c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x1c 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x1c 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x1c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x1e "PCR129,Pad Configuration Register 129"
  bitfld.word 0x1e 10.--12.       "PA , Pin assignment" "GPIO,ETPUA15,PCSB5,ETPUA15,res.,res.,res.,res.      "
  bitfld.word 0x1e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x1e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x1e 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x1e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x1e 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x1e 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x1e 00.            "  WPS , Weak pull up/down select" "0,1"

TEXTLINE ""
  line.word 0x20 "PCR130,Pad Configuration Register 130"
  bitfld.word 0x20 10.--12.       "PA , Pin assignment" "GPIO,ETPUA16,PCSD1,ETPUA16,res.,res.,res.,res.      "
  bitfld.word 0x20 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x20 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x20 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x20 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x20 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x20 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x20 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x22 "PCR131,Pad Configuration Register 131"
  bitfld.word 0x22 10.--12.       "PA , Pin assignment" "GPIO,ETPUA17,PCSD2,ETPUA17,res.,res.,res.,res.      "
  bitfld.word 0x22 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x22 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x22 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x22 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x22 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x22 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x22 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x24 "PCR132,Pad Configuration Register 132"
  bitfld.word 0x24 10.--12.       "PA , Pin assignment" "GPIO,ETPUA18,PCSD3,ETPUA18,res.,res.,res.,res.      "
  bitfld.word 0x24 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x24 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x24 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x24 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x24 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x24 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x24 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x26 "PCR133,Pad Configuration Register 133"
  bitfld.word 0x26 10.--12.       "PA , Pin assignment" "GPIO,ETPUA19,PCSD4,ETPUA19,res.,res.,res.,res.      "
  bitfld.word 0x26 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x26 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x26 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x26 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x26 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x26 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x26 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x28 "PCR134,Pad Configuration Register 134"
  bitfld.word 0x28 10.--12.       "PA , Pin assignment" "GPIO,ETPUA20,IRQ08,ETPUA20,res.,res.,res.,res.      "
  bitfld.word 0x28 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x28 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x28 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x28 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x28 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x28 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x28 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x2a "PCR135,Pad Configuration Register 135"
  bitfld.word 0x2a 10.--12.       "PA , Pin assignment" "GPIO,ETPUA21,IRQ09,ETPUA21,res.,res.,res.,res.      "
  bitfld.word 0x2a 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x2a 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x2a 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x2a 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x2a 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x2a 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x2a 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x2c "PCR136,Pad Configuration Register 136"
  bitfld.word 0x2c 10.--12.       "PA , Pin assignment" "GPIO,ETPUA22,IRQ10,ETPUA22,res.,res.,res.,res.      "
  bitfld.word 0x2c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x2c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x2c 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x2c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x2c 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x2c 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x2c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x2e "PCR137,Pad Configuration Register 137"
  bitfld.word 0x2e 10.--12.       "PA , Pin assignment" "GPIO,ETPUA23,IRQ11,ETPUA23,res.,res.,res.,res.      "
  bitfld.word 0x2e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x2e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x2e 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x2e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x2e 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x2e 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x2e 00.            "  WPS , Weak pull up/down select" "0,1"

TEXTLINE ""
  line.word 0x30 "PCR138,Pad Configuration Register 138"
  bitfld.word 0x30 10.--12.       "PA , Pin assignment" "GPIO,ETPUA24,IRQ12,ETPUA24,res.,res.,res.,res.      "
  bitfld.word 0x30 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x30 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x30 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x30 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x30 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x30 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x30 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x32 "PCR139,Pad Configuration Register 139"
  bitfld.word 0x32 10.--12.       "PA , Pin assignment" "GPIO,ETPUA25,IRQ13,ETPUA25,res.,res.,res.,res.      "
  bitfld.word 0x32 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x32 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x32 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x32 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x32 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x32 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x32 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x34 "PCR140,Pad Configuration Register 140"
  bitfld.word 0x34 10.--12.       "PA , Pin assignment" "GPIO,ETPUA26,IRQ14,ETPUA26,res.,res.,res.,res.      "
  bitfld.word 0x34 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x34 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x34 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x34 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x34 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x34 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x34 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x36 "PCR141,Pad Configuration Register 141"
  bitfld.word 0x36 10.--12.       "PA , Pin assignment" "GPIO,ETPUA27,IRQ15,ETPUA27,res.,res.,res.,res.      "
  bitfld.word 0x36 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x36 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x36 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x36 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x36 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x36 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x36 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x38 "PCR142,Pad Configuration Register 142"
  bitfld.word 0x38 10.--12.       "PA , Pin assignment" "GPIO,ETPUA28,PCSC1,ETPUA28,res.,res.,res.,res.      "
  bitfld.word 0x38 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x38 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x38 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x38 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x38 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x38 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x38 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x3a "PCR143,Pad Configuration Register 143"
  bitfld.word 0x3a 10.--12.       "PA , Pin assignment" "GPIO,ETPUA29,PCSC2,ETPUA29,res.,res.,res.,res.      "
  bitfld.word 0x3a 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x3a 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x3a 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x3a 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x3a 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x3a 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x3a 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x3c "PCR144,Pad Configuration Register 144"
  bitfld.word 0x3c 10.--12.       "PA , Pin assignment" "GPIO,ETPUA30,PCSC3,ETPUA30,res.,res.,res.,res.      "
  bitfld.word 0x3c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x3c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x3c 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x3c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x3c 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x3c 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x3c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x3e "PCR145,Pad Configuration Register 145"
  bitfld.word 0x3e 10.--12.       "PA , Pin assignment" "GPIO,ETPUA31,PCSC4,ETPUA31,res.,res.,res.,res.      "
  bitfld.word 0x3e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x3e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x3e 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x3e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x3e 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x3e 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x3e 00.            "  WPS , Weak pull up/down select" "0,1"



group 0xC3F901A6++0x31 "PCR179-202: EMIOS[0:23] / ETPUA[0:9] / SOUTC / SOUTD / IRQ[0:1] / ETPUB[0:7]"
  line.word 0x00 "PCR179,Pad Configuration Register 179"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,EMIOS00,ETPUA00,EMIOS00,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR180,Pad Configuration Register 180"
  bitfld.word 0x02 10.--12.       "PA , Pin assignment" "GPIO,EMIOS01,ETPUA01,EMIOS01,res.,res.,res.,res.      "
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x02 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x04 "PCR181,Pad Configuration Register 181"
  bitfld.word 0x04 10.--12.       "PA , Pin assignment" "GPIO,EMIOS02,ETPUA02,EMIOS02,res.,res.,res.,res.      "
  bitfld.word 0x04 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x04 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x04 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x04 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x04 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x04 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x04 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x06 "PCR182,Pad Configuration Register 182"
  bitfld.word 0x06 10.--12.       "PA , Pin assignment" "GPIO,EMIOS03,ETPUA03,EMIOS03,res.,res.,res.,res.      "
  bitfld.word 0x06 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x06 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x06 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x06 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x06 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x06 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x06 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x08 "PCR183,Pad Configuration Register 183"
  bitfld.word 0x08 10.--12.       "PA , Pin assignment" "GPIO,EMIOS04,ETPUA04,EMIOS04,res.,res.,res.,res.      "
  bitfld.word 0x08 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x08 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x08 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x08 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x08 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x08 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x08 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0a "PCR184,Pad Configuration Register 184"
  bitfld.word 0x0a 10.--12.       "PA , Pin assignment" "GPIO,EMIOS05,ETPUA05,EMIOS05,res.,res.,res.,res.      "
  bitfld.word 0x0a 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0a 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0a 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x0a 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0a 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x0a 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0a 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0c "PCR185,Pad Configuration Register 185"
  bitfld.word 0x0c 10.--12.       "PA , Pin assignment" "GPIO,EMIOS06,ETPUA06,EMIOS06,res.,res.,res.,res.      "
  bitfld.word 0x0c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0c 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x0c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0c 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x0c 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0e "PCR186,Pad Configuration Register 186"
  bitfld.word 0x0e 10.--12.       "PA , Pin assignment" "GPIO,EMIOS07,ETPUA07,EMIOS07,res.,res.,res.,res.      "
  bitfld.word 0x0e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0e 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x0e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0e 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x0e 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0e 00.            "  WPS , Weak pull up/down select" "0,1"

TEXTLINE "" 
  line.word 0x10 "PCR187,Pad Configuration Register 187"
  bitfld.word 0x10 10.--12.       "PA , Pin assignment" "GPIO,EMIOS08,ETPUA08,EMIOS08,res.,res.,res.,res.      "
  bitfld.word 0x10 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x10 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x10 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x10 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x10 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x10 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x10 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x12 "PCR188,Pad Configuration Register 188"
  bitfld.word 0x12 10.--12.       "PA , Pin assignment" "GPIO,EMIOS09,ETPUA09,EMIOS09,res.,res.,res.,res.      "
  bitfld.word 0x12 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x12 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x12 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x12 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x12 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x12 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x12 00.            "  WPS , Weak pull up/down select" "0,1"


  line.word 0x14 "PCR189,Pad Configuration Register 189"
  bitfld.word 0x14 10.--12.       "PA , Pin assignment" "GPIO,EMIOS10,PCSD3,EMIOS10,res.,res.,res.,res.      "
  bitfld.word 0x14 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x14 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x14 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x14 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x14 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x14 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x14 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x16 "PCR190,Pad Configuration Register 190"
  bitfld.word 0x16 10.--12.       "PA , Pin assignment" "GPIO,EMIOS11,PCSD4,EMIOS11,res.,res.,res.,res.      "
  bitfld.word 0x16 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x16 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x16 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x16 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x16 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x16 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x16 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x18 "PCR191,Pad Configuration Register 191"
  bitfld.word 0x18 10.--12.       "PA , Pin assignment" "GPIO,EMIOS12,SOUTC,EMIOS12,res.,res.,res.,res.      "
  bitfld.word 0x18 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x18 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x18 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x18 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x18 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x18 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x18 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x1A "PCR192,Pad Configuration Register 192"
  bitfld.word 0x1A 10.--12.       "PA , Pin assignment" "GPIO,EMIOS13,SOUTD,EMIOS13,res.,res.,res.,res.      "
  bitfld.word 0x1A 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x1A 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x1A 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x1A 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x1A 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x1A 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x1A 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x1c "PCR193,Pad Configuration Register 193"
  bitfld.word 0x1c 10.--12.       "PA , Pin assignment" "GPIO,EMIOS14,IRQ00,EMIOS14,res.,res.,res.,res.      "
  bitfld.word 0x1c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x1c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x1c 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x1c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x1c 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x1c 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x1c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x1e "PCR194,Pad Configuration Register 194"
  bitfld.word 0x1e 10.--12.       "PA , Pin assignment" "GPIO,EMIOS15,IRQ01,EMIOS15,res.,res.,res.,res.      "
  bitfld.word 0x1e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x1e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x1e 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x1e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x1e 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x1e 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x1e 00.            "  WPS , Weak pull up/down select" "0,1"

TEXTLINE ""
  line.word 0x20 "PCR195,Pad Configuration Register 195"
  bitfld.word 0x20 10.--12.       "PA , Pin assignment" "GPIO,EMIOS16,res.,EMIOS16,res.,res.,res.,res.      "
  bitfld.word 0x20 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x20 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x20 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x20 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x20 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x20 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x20 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x22 "PCR196,Pad Configuration Register 196"
  bitfld.word 0x22 10.--12.       "PA , Pin assignment" "GPIO,EMIOS17,res.,EMIOS17,res.,res.,res.,res.      "
  bitfld.word 0x22 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x22 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x22 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x22 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x22 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x22 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x22 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x24 "PCR197,Pad Configuration Register 197"
  bitfld.word 0x24 10.--12.       "PA , Pin assignment" "GPIO,EMIOS18,res.,EMIOS18,res.,res.,res.,res.      "
  bitfld.word 0x24 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x24 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x24 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x24 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x24 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x24 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x24 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x26 "PCR198,Pad Configuration Register 198"
  bitfld.word 0x26 10.--12.       "PA , Pin assignment" "GPIO,EMIOS19,res.,EMIOS19,res.,res.,res.,res.      "
  bitfld.word 0x26 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x26 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x26 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x26 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x26 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x26 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x26 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x28 "PCR199,Pad Configuration Register 199"
  bitfld.word 0x28 10.--12.       "PA , Pin assignment" "GPIO,EMIOS20,res.,EMIOS20,res.,res.,res.,res.      "
  bitfld.word 0x28 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x28 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x28 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x28 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x28 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x28 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x28 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x2a "PCR200,Pad Configuration Register 200"
  bitfld.word 0x2a 10.--12.       "PA , Pin assignment" "GPIO,EMIOS21,res.,EMIOS21,res.,res.,res.,res.      "
  bitfld.word 0x2a 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x2a 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x2a 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x2a 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x2a 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x2a 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x2a 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x2c "PCR201,Pad Configuration Register 201"
  bitfld.word 0x2c 10.--12.       "PA , Pin assignment" "GPIO,EMIOS22,res.,EMIOS22,res.,res.,res.,res.      "
  bitfld.word 0x2c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x2c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x2c 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x2c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x2c 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x2c 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x2c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x2e "PCR202,Pad Configuration Register 202"
  bitfld.word 0x2e 10.--12.       "PA , Pin assignment" "GPIO,EMIOS23,res.,EMIOS23,res.,res.,res.,res.      "
  bitfld.word 0x2e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x2e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x2e 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x2e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x2e 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x2e 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x2e 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F901D6++0x09 "PCR203-207: GPIO / EMIOS[14:15]"
  line.word 0x00 "PCR203,Pad Configuration Register 203"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,EMIOS14,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR204,Pad Configuration Register 204"
  bitfld.word 0x02 10.--12.       "PA , Pin assignment" "GPIO,EMIOS15,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x02 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x04 "PCR205,Pad Configuration Register 205"
  bitfld.word 0x04 10.--12.       "PA , Pin assignment" "GPIO,res.,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x04 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x04 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x04 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x04 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x04 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x04 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x04 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x06 "PCR206,Pad Configuration Register 206"
  bitfld.word 0x06 10.--12.       "PA , Pin assignment" "GPIO,res.,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x06 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x06 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x06 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x06 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x06 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x06 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x06 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x08 "PCR207,Pad Configuration Register 207"
  bitfld.word 0x08 10.--12.       "PA , Pin assignment" "GPIO,res.,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x08 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x08 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x08 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x08 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x08 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x08 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x08 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F901E0++0x03 "PCR208-209: PLLCFG[0:1] / IRQ[4:5] / SOUTD"
  line.word 0x00 "PCR208,Pad Configuration Register 208"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,PLLCFG0,IRQ04,PLLCFG0,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR209,Pad Configuration Register 209"
  bitfld.word 0x02 10.--12.       "PA , Pin assignment" "GPIO,PLLCFG1,IRQ05,PLLCFG1,SOUTD,res.,res.,res.      "
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x02 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F901E4++0x01 "PCR210: !RSCFG"
  line.word 0x00 "PCR210,Pad Configuration Register 210"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,!RSCFG,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F901E6++0x03 "PCR211-212: BOOTCFG[0:1] / IRQ[2:3]"
  line.word 0x00 "PCR211,Pad Configuration Register 211"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,BOOTCFG0,IRQ02,BOOTCFG0,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR212,Pad Configuration Register 212"
  bitfld.word 0x02 10.--12.       "PA , Pin assignment" "GPIO,BOOTCFG1,IRQ03,BOOTCFG0,res.,res.,res.,res.      "
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x02 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F901EA++0x01 "PCR213: WKPCFG"
  line.word 0x00 "PCR213,Pad Configuration Register 213"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,WKPCFG,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F901EC++0x01 "PCR214: ENGCLK"
  line.word 0x00 "PCR214,Pad Configuration Register 214"

; bitfld.word 0x00 10.--13.       "PA , Pin assignment" "   0,   1,   2,   3,   4,   5,   6,   7,   8,   9,   A,   B,   C,   D,   E,   F"
  bitfld.word 0x00 09.            "         OBE , Output buffer enable" "0,1"
; bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "         DSC , Drive strength control" "10pF,20pF,30pF,50pF"
; bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
; bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
; bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
; bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
; bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

group 0xC3F901EE++0x01 "PCR215: AN12 / MA0 / !SDS"
  line.word 0x00 "PCR215,Pad Configuration Register 215"

  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "!SDS,res.,MA0,AN12,res.,res.,res.,res.      "
;  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
;  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
; bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
;  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
;  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
;  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F901F0++0x01 "PCR216: AN13 / MA1 / SDO"
  line.word 0x00 "PCR216,Pad Configuration Register 216"

  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "SDO,res.,MA1,AN13,res.,res.,res.,res.      "
;  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
;  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
; bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
;  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
;  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
;  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F901F2++0x01 "PCR217: AN14 / MA2 / SDI"
  line.word 0x00 "PCR217,Pad Configuration Register 217"

  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "SDI,res.,MA2,AN14,res.,res.,res.,res.      "
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F901F4++0x01 "PCR218: AN15 / FCK"
  line.word 0x00 "PCR218,Pad Configuration Register 218"

  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "FCK,AN15,res.,res.,res.,res.,res.,res.      "
;  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
;  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
; bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
;  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
;  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
;  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F901F6++0x01 "PCR219: MCKO"
  line.word 0x00 "PCR219,Pad Configuration Register 219"

;  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "   0,   1,   2,   3,   4,   5,   6,   7,   8,   9,   A,   B,   C,   D,   E,   F"
;  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
;  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "                       DSC , Drive strength control" "10pF,20pF,30pF,50pF"
;  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
;  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
;  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
;  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
;  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

group 0xC3F901F8++0x09 "PCR220-223: MDO[0:3]"
  line.word 0x00 "PCR220,Pad Configuration Register 220"

;  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "   0,   1,   2,   3,   4,   5,   6,   7,   8,   9,   A,   B,   C,   D,   E,   F"
;  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
;  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "                       DSC , Drive strength control" "10pF,20pF,30pF,50pF"
;  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
;  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
;  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
;  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
;  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"
  line.word 0x02 "PCR221,Pad Configuration Register 221"

;  bitfld.word 0x02 10.--13.       "PA , Pin assignment" "   0,   1,   2,   3,   4,   5,   6,   7,   8,   9,   A,   B,   C,   D,   E,   F"
;  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
;  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 06.--07.       "                       DSC , Drive strength control" "10pF,20pF,30pF,50pF"
;  bitfld.word 0x02 05.            "  ODE , Open drain output enable" "0,1"
;  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
;  bitfld.word 0x02 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
;  bitfld.word 0x02 01.            "  WPE , Weak pull up/down enable" "0,1"
;  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"
  line.word 0x04 "PCR222,Pad Configuration Register 222"

;  bitfld.word 0x04 10.--13.       "PA , Pin assignment" "   0,   1,   2,   3,   4,   5,   6,   7,   8,   9,   A,   B,   C,   D,   E,   F"
;  bitfld.word 0x04 09.            "  OBE , Output buffer enable" "0,1"
;  bitfld.word 0x04 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x04 06.--07.       "                       DSC , Drive strength control" "10pF,20pF,30pF,50pF"
;  bitfld.word 0x04 05.            "  ODE , Open drain output enable" "0,1"
;  bitfld.word 0x04 04.            "  HYS , Input hysteresis" "0,1"
;  bitfld.word 0x04 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
;  bitfld.word 0x04 01.            "  WPE , Weak pull up/down enable" "0,1"
;  bitfld.word 0x04 00.            "  WPS , Weak pull up/down select" "0,1"
  line.word 0x06 "PCR223,Pad Configuration Register 223"

;  bitfld.word 0x06 10.--13.       "PA , Pin assignment" "   0,   1,   2,   3,   4,   5,   6,   7,   8,   9,   A,   B,   C,   D,   E,   F"
;  bitfld.word 0x06 09.            "  OBE , Output buffer enable" "0,1"
;  bitfld.word 0x06 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x06 06.--07.       "                       DSC , Drive strength control" "10pF,20pF,30pF,50pF"
;  bitfld.word 0x06 05.            "  ODE , Open drain output enable" "0,1"
;  bitfld.word 0x06 04.            "  HYS , Input hysteresis" "0,1"
;  bitfld.word 0x06 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
;  bitfld.word 0x06 01.            "  WPE , Weak pull up/down enable" "0,1"
;  bitfld.word 0x06 00.            "  WPS , Weak pull up/down select" "0,1"

group 0xC3F90200++0x03 "PCR224-225: !MSEO[0:1]"
  line.word 0x00 "PCR224,Pad Configuration Register 224"

;  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "   0,   1,   2,   3,   4,   5,   6,   7,   8,   9,   A,   B,   C,   D,   E,   F"
;  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
;  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "                       DSC , Drive strength control" "10pF,20pF,30pF,50pF"
;  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
;  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
;  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
;  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
;  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"
  line.word 0x02 "PCR225,Pad Configuration Register 225"

;  bitfld.word 0x02 10.--13.       "PA , Pin assignment" "   0,   1,   2,   3,   4,   5,   6,   7,   8,   9,   A,   B,   C,   D,   E,   F"
;  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
;  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 06.--07.       "                       DSC , Drive strength control" "10pF,20pF,30pF,50pF"
;  bitfld.word 0x02 05.            "  ODE , Open drain output enable" "0,1"
;  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
;  bitfld.word 0x02 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
;  bitfld.word 0x02 01.            "  WPE , Weak pull up/down enable" "0,1"
;  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"

group 0xC3F90204++0x01 "PCR226: !RDY"
  line.word 0x00 "PCR226,Pad Configuration Register 226"

;  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "   0,   1,   2,   3,   4,   5,   6,   7,   8,   9,   A,   B,   C,   D,   E,   F"
;  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
;  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "                       DSC , Drive strength control" "10pF,20pF,30pF,50pF"
;  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
;  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
;  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
;  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
;  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

group 0xC3F90206++0x01 "PCR227: !EVTO"
  line.word 0x00 "PCR227,Pad Configuration Register 227"

;  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "   0,   1,   2,   3,   4,   5,   6,   7,   8,   9,   A,   B,   C,   D,   E,   F"
;  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
;  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "                       DSC , Drive strength control" "10pF,20pF,30pF,50pF"
;  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
;  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
;  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
;  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
;  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

group 0xC3F90208++0x01 "PCR228: TDO"
  line.word 0x00 "PCR228,Pad Configuration Register 228"

;  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "   0,   1,   2,   3,   4,   5,   6,   7,   8,   9,   A,   B,   C,   D,   E,   F"
;  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
;  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "                       DSC , Drive strength control" "10pF,20pF,30pF,50pF"
;  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
;  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
;  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
;  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
;  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

group 0xC3F9020A++0x01 "PCR229: !CLKOUT"
  line.word 0x00 "PCR229,Pad Configuration Register 229"

; bitfld.word 0x00 10.--13.       "PA , Pin assignment" "   0,   1,   2,   3,   4,   5,   6,   7,   8,   9,   A,   B,   C,   D,   E,   F"
  bitfld.word 0x00 09.            "         OBE , Output buffer enable" "0,1"
; bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "         DSC , Drive strength control" "10pF,20pF,30pF,50pF"
; bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
; bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
; bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
; bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
; bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

group 0xC3F9020C++0x01 "PCR230: !RSTOUT"
  line.word 0x00 "PCR230,Pad Configuration Register 230"

;  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "   0,   1,   2,   3,   4,   5,   6,   7,   8,   9,   A,   B,   C,   D,   E,   F"
;  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
;  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
;  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
;  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
;  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "                                               SRC , Slew rate control" "Min,Med,res,Max"
;  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
;  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

;calibration pins

group 0xC3F90240++0x01 "PCR256: CAL_CS0"
  line.word 0x00 "PCR256,Pad Configuration Register 256"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "res.,CAL_CS0,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90242++0x03 "PCR257-258: CAL_CS[2:3] / CAL_ADDR[10:11]"
  line.word 0x00 "PCR257,Pad Configuration Register 257"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "res.,CAL_CS2,CAL_ADDR10,CAL_CS2,res.,res.,res.,res."
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR258,Pad Configuration Register 258"
  bitfld.word 0x02 10.--12.       "PA , Pin assignment" "res.,CAL_CS3,CAL_ADDR11,CAL_CS3,res.,res.,res.,res."
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x02 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90246++0x25 "PCR259-277: CAL_ADDR[12:30]"
  line.word 0x00 "PCR259,Pad Configuration Register 259"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "res.,CAL_ADDR12,res.,CAL_ADDR12,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR260,Pad Configuration Register 260"
  bitfld.word 0x02 10.--12.       "PA , Pin assignment" "res.,CAL_ADDR13,res.,CAL_ADDR13,res.,res.,res.,res.      "
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x02 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x04 "PCR261,Pad Configuration Register 261"
  bitfld.word 0x04 10.--12.       "PA , Pin assignment" "res.,CAL_ADDR14,res.,CAL_ADDR14,res.,res.,res.,res.      "
  bitfld.word 0x04 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x04 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x04 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x04 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x04 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x04 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x04 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x06 "PCR262,Pad Configuration Register 262"
  bitfld.word 0x06 10.--12.       "PA , Pin assignment" "res.,CAL_ADDR15,res.,CAL_ADDR15,res.,res.,res.,res.      "
  bitfld.word 0x06 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x06 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x06 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x06 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x06 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x06 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x06 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x08 "PCR263,Pad Configuration Register 263"
  bitfld.word 0x08 10.--12.       "PA , Pin assignment" "res.,CAL_ADDR16,res.,CAL_ADDR16,res.,res.,res.,res.      "
  bitfld.word 0x08 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x08 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x08 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x08 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x08 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x08 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x08 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0a "PCR264,Pad Configuration Register 264"
  bitfld.word 0x0a 10.--12.       "PA , Pin assignment" "res.,CAL_ADDR17,res.,CAL_ADDR17,res.,res.,res.,res.      "
  bitfld.word 0x0a 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0a 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0a 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x0a 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x0a 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0a 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0a 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0c "PCR265,Pad Configuration Register 265"
  bitfld.word 0x0c 10.--12.       "PA , Pin assignment" "res.,CAL_ADDR18,res.,CAL_ADDR18,res.,res.,res.,res.      "
  bitfld.word 0x0c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0c 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x0c 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x0c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0c 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0e "PCR266,Pad Configuration Register 266"
  bitfld.word 0x0e 10.--12.       "PA , Pin assignment" "res.,CAL_ADDR19,res.,CAL_ADDR19,res.,res.,res.,res.      "
  bitfld.word 0x0e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0e 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x0e 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x0e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0e 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0e 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x10 "PCR267,Pad Configuration Register 267"
  bitfld.word 0x10 10.--12.       "PA , Pin assignment" "res.,CAL_ADDR20,res.,CAL_ADDR20,res.,res.,res.,res.      "
  bitfld.word 0x10 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x10 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x10 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x10 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x10 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x10 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x10 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x12 "PCR268,Pad Configuration Register 268"
  bitfld.word 0x12 10.--12.       "PA , Pin assignment" "res.,CAL_ADDR21,res.,CAL_ADDR21,res.,res.,res.,res.      "
  bitfld.word 0x12 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x12 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x12 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x12 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x12 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x12 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x12 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x14 "PCR269,Pad Configuration Register 269"
  bitfld.word 0x14 10.--12.       "PA , Pin assignment" "res.,CAL_ADDR22,res.,CAL_ADDR22,res.,res.,res.,res.      "
  bitfld.word 0x14 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x14 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x14 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x14 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x14 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x14 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x14 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x16 "PCR270,Pad Configuration Register 270"
  bitfld.word 0x16 10.--12.       "PA , Pin assignment" "res.,CAL_ADDR23,res.,CAL_ADDR23,res.,res.,res.,res.      "
  bitfld.word 0x16 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x16 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x16 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x16 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x16 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x16 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x16 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x18 "PCR271,Pad Configuration Register 271"
  bitfld.word 0x18 10.--12.       "PA , Pin assignment" "res.,CAL_ADDR24,res.,CAL_ADDR24,res.,res.,res.,res.      "
  bitfld.word 0x18 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x18 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x18 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x18 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x18 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x18 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x18 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x1a "PCR272,Pad Configuration Register 272"
  bitfld.word 0x1a 10.--12.       "PA , Pin assignment" "res.,CAL_ADDR25,res.,CAL_ADDR25,res.,res.,res.,res.      "
  bitfld.word 0x1a 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x1a 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x1a 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x1a 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x1a 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x1a 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x1a 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x1c "PCR273,Pad Configuration Register 273"
  bitfld.word 0x1c 10.--12.       "PA , Pin assignment" "res.,CAL_ADDR26,res.,CAL_ADDR26,res.,res.,res.,res.      "
  bitfld.word 0x1c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x1c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x1c 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x1c 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x1c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x1c 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x1c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x1e "PCR274,Pad Configuration Register 274"
  bitfld.word 0x1e 10.--12.       "PA , Pin assignment" "res.,CAL_ADDR27,res.,CAL_ADDR27,res.,res.,res.,res.      "
  bitfld.word 0x1e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x1e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x1e 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x1e 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x1e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x1e 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x1e 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x20 "PCR275,Pad Configuration Register 275"
  bitfld.word 0x20 10.--12.       "PA , Pin assignment" "res.,CAL_ADDR28,res.,CAL_ADDR28,res.,res.,res.,res.      "
  bitfld.word 0x20 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x20 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x20 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x20 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x20 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x20 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x20 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x22 "PCR276,Pad Configuration Register 276"
  bitfld.word 0x22 10.--12.       "PA , Pin assignment" "res.,CAL_ADDR29,res.,CAL_ADDR29,res.,res.,res.,res.      "
  bitfld.word 0x22 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x22 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x22 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x22 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x22 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x22 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x22 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x24 "PCR277,Pad Configuration Register 277"
  bitfld.word 0x24 10.--12.       "PA , Pin assignment" "res.,CAL_ADDR30,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x24 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x24 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x24 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x24 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x24 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x24 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x24 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F9026C++0x1f "PCR278-293: CAL_DATA[0:15]"
  line.word 0x00 "PCR278,Pad Configuration Register 278"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "res.,CAL_DATA00,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR279,Pad Configuration Register 279"
  bitfld.word 0x02 10.--12.       "PA , Pin assignment" "res.,CAL_DATA01,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x02 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x04 "PCR280,Pad Configuration Register 280"
  bitfld.word 0x04 10.--12.       "PA , Pin assignment" "res.,CAL_DATA02,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x04 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x04 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x04 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x04 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x04 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x04 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x04 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x06 "PCR281,Pad Configuration Register 281"
  bitfld.word 0x06 10.--12.       "PA , Pin assignment" "res.,CAL_DATA03,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x06 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x06 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x06 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x06 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x06 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x06 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x06 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x08 "PCR282,Pad Configuration Register 282"
  bitfld.word 0x08 10.--12.       "PA , Pin assignment" "res.,CAL_DATA04,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x08 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x08 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x08 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x08 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x08 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x08 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x08 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0a "PCR283,Pad Configuration Register 283"
  bitfld.word 0x0a 10.--12.       "PA , Pin assignment" "res.,CAL_DATA05,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x0a 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0a 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0a 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x0a 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x0a 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0a 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0a 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0c "PCR284,Pad Configuration Register 284"
  bitfld.word 0x0c 10.--12.       "PA , Pin assignment" "res.,CAL_DATA06,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x0c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0c 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x0c 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x0c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0c 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0e "PCR285,Pad Configuration Register 285"
  bitfld.word 0x0e 10.--12.       "PA , Pin assignment" "res.,CAL_DATA07,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x0e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0e 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x0e 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x0e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0e 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0e 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x10 "PCR286,Pad Configuration Register 286"
  bitfld.word 0x10 10.--12.       "PA , Pin assignment" "res.,CAL_DATA08,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x10 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x10 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x10 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x10 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x10 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x10 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x10 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x12 "PCR287,Pad Configuration Register 287"
  bitfld.word 0x12 10.--12.       "PA , Pin assignment" "res.,CAL_DATA09,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x12 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x12 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x12 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x12 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x12 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x12 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x12 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x14 "PCR288,Pad Configuration Register 288"
  bitfld.word 0x14 10.--12.       "PA , Pin assignment" "res.,CAL_DATA10,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x14 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x14 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x14 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x14 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x14 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x14 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x14 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x16 "PCR289,Pad Configuration Register 289"
  bitfld.word 0x16 10.--12.       "PA , Pin assignment" "res.,CAL_DATA11,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x16 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x16 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x16 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x16 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x16 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x16 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x16 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x18 "PCR290,Pad Configuration Register 290"
  bitfld.word 0x18 10.--12.       "PA , Pin assignment" "res.,CAL_DATA12,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x18 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x18 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x18 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x18 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x18 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x18 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x18 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x1a "PCR291,Pad Configuration Register 291"
  bitfld.word 0x1a 10.--12.       "PA , Pin assignment" "res.,CAL_DATA13,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x1a 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x1a 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x1a 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x1a 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x1a 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x1a 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x1a 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x1c "PCR292,Pad Configuration Register 292"
  bitfld.word 0x1c 10.--12.       "PA , Pin assignment" "res.,CAL_DATA14,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x1c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x1c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x1c 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x1c 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x1c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x1c 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x1c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x1e "PCR293,Pad Configuration Register 293"
  bitfld.word 0x1e 10.--12.       "PA , Pin assignment" "res.,CAL_DATA15,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x1e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x1e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x1e 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x1e 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x1e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x1e 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x1e 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F9028C++0x09 "PCR294-298: CAL_RD_WR, CAL_WE[0:1], CAL_OE, CAL_TS"
  line.word 0x00 "PCR294,Pad Configuration Register 294"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "res.,CAL_RD_WR,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR295,Pad Configuration Register 295"
  bitfld.word 0x02 10.--12.       "PA , Pin assignment" "res.,CAL_WEBE0,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x02 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x04 "PCR296,Pad Configuration Register 296"
  bitfld.word 0x04 10.--12.       "PA , Pin assignment" "res.,CAL_WEBE1,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x04 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x04 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x04 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x04 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x04 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x04 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x04 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x06 "PCR297,Pad Configuration Register 297"
  bitfld.word 0x06 10.--12.       "PA , Pin assignment" "res.,CAL_OE,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x06 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x06 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x06 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x06 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x06 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x06 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x06 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x08 "PCR298,Pad Configuration Register 298"
  bitfld.word 0x08 10.--12.       "PA , Pin assignment" "res.,CAL_TS,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x08 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x08 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x08 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x08 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x08 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x08 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x08 00.            "  WPS , Weak pull up/down select" "0,1"



endif

sif (CPU()=="MPC5566")
group 0xC3F90040++0x07 "PCR000-PCR003: !CS[0:3] / ADDR[8:11]"
  line.word 0x00 "PCR000,Pad Configuration Register 000"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPI0,!CS0,ADDR08,!CS0,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR001,Pad Configuration Register 001"
  bitfld.word 0x02 10.--12.       "PA , Pin assignment" "GPI0,!CS1,ADDR09,!CS1,res.,res.,res.,res.      "
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x02 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x04 "PCR002,Pad Configuration Register 002"
  bitfld.word 0x04 10.--12.       "PA , Pin assignment" "GPI0,!CS2,ADDR10,!CS2,res.,res.,res.,res.      "
  bitfld.word 0x04 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x04 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x04 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x04 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x04 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x04 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x04 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x06 "PCR003,Pad Configuration Register 003"
  bitfld.word 0x06 10.--12.       "PA , Pin assignment" "GPI0,!CS3,ADDR11,!CS3,res.,res.,res.,res.      "
  bitfld.word 0x06 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x06 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x06 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x06 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x06 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x06 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x06 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90048++0x2f "PCR004-PCR011: ADDR[8:15]"
  line.word 0x00 "PCR004,Pad Configuration Register 004"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,ADDR08,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR005,Pad Configuration Register 005"
  bitfld.word 0x02 10.--12.       "PA , Pin assignment" "GPIO,ADDR09,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x02 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x04 "PCR006,Pad Configuration Register 006"
  bitfld.word 0x04 10.--12.       "PA , Pin assignment" "GPIO,ADDR10,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x04 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x04 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x04 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x04 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x04 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x04 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x04 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x06 "PCR007,Pad Configuration Register 007"
  bitfld.word 0x06 10.--12.       "PA , Pin assignment" "GPIO,ADDR11,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x06 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x06 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x06 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x06 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x06 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x06 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x06 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x08 "PCR008,Pad Configuration Register 008"
  bitfld.word 0x08 10.--12.       "PA , Pin assignment" "GPIO,ADDR12,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x08 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x08 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x08 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x08 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x08 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x08 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x08 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0a "PCR009,Pad Configuration Register 009"
  bitfld.word 0x0a 10.--12.       "PA , Pin assignment" "GPIO,ADDR13,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x0a 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0a 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0a 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x0a 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x0a 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0a 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0a 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0c "PCR010,Pad Configuration Register 010"
  bitfld.word 0x0c 10.--12.       "PA , Pin assignment" "GPIO,ADDR14,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x0c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0c 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x0c 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x0c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0c 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0e "PCR011,Pad Configuration Register 011"
  bitfld.word 0x0e 10.--12.       "PA , Pin assignment" "GPIO,ADDR15,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x0e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0e 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x0e 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x0e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0e 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0e 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90048++0x2f "PCR012-PCR027: ADDR[16:31]"
  line.word 0x10 "PCR012,Pad Configuration Register 012"
  bitfld.word 0x10 10.--12.       "PA , Pin assignment" "GPIO,ADDR16,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x10 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x10 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x10 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x10 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x10 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x10 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x10 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x12 "PCR013,Pad Configuration Register 013"
  bitfld.word 0x12 10.--12.       "PA , Pin assignment" "GPIO,ADDR17,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x12 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x12 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x12 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x12 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x12 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x12 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x12 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x14 "PCR014,Pad Configuration Register 014"
  bitfld.word 0x14 10.--12.       "PA , Pin assignment" "GPIO,ADDR18,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x14 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x14 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x14 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x14 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x14 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x14 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x14 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x16 "PCR015,Pad Configuration Register 015"
  bitfld.word 0x16 10.--12.       "PA , Pin assignment" "GPIO,ADDR19,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x16 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x16 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x16 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x16 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x16 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x16 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x16 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x18 "PCR016,Pad Configuration Register 016"
  bitfld.word 0x18 10.--12.       "PA , Pin assignment" "GPIO,ADDR20,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x18 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x18 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x18 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x18 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x18 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x18 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x18 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x1A "PCR017,Pad Configuration Register 017"
  bitfld.word 0x1A 10.--12.       "PA , Pin assignment" "GPIO,ADDR21,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x1A 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x1A 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x1A 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x1A 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x1A 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x1A 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x1A 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x1C "PCR018,Pad Configuration Register 018"
  bitfld.word 0x1C 10.--12.       "PA , Pin assignment" "GPIO,ADDR22,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x1C 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x1C 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x1C 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x1C 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x1C 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x1C 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x1C 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x1E "PCR019,Pad Configuration Register 019"
  bitfld.word 0x1E 10.--12.       "PA , Pin assignment" "GPIO,ADDR23,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x1E 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x1E 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x1E 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x1E 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x1E 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x1E 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x1E 00.            "  WPS , Weak pull up/down select" "0,1"

TEXTLINE ""
  line.word 0x20 "PCR020,Pad Configuration Register 020"
  bitfld.word 0x20 10.--12.       "PA , Pin assignment" "GPIO,ADDR24,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x20 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x20 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x20 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x20 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x20 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x20 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x20 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x22 "PCR021,Pad Configuration Register 021"
  bitfld.word 0x22 10.--12.       "PA , Pin assignment" "GPIO,ADDR25,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x22 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x22 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x22 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x22 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x22 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x22 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x22 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x24 "PCR022,Pad Configuration Register 022"
  bitfld.word 0x24 10.--12.       "PA , Pin assignment" "GPIO,ADDR26,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x24 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x24 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x24 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x24 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x24 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x24 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x24 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x26 "PCR023,Pad Configuration Register 023"
  bitfld.word 0x26 10.--12.       "PA , Pin assignment" "GPIO,ADDR27,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x26 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x26 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x26 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x26 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x26 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x26 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x26 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x28 "PCR024,Pad Configuration Register 024"
  bitfld.word 0x28 10.--12.       "PA , Pin assignment" "GPIO,ADDR28,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x28 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x28 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x28 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x28 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x28 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x28 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x28 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x2a "PCR025,Pad Configuration Register 025"
  bitfld.word 0x2a 10.--12.       "PA , Pin assignment" "GPIO,ADDR29,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x2a 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x2a 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x2a 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x2a 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x2a 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x2a 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x2a 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x2c "PCR026,Pad Configuration Register 026"
  bitfld.word 0x2c 10.--12.       "PA , Pin assignment" "GPIO,ADDR30,ADDR06,ADDR30,res.,res.,res.,res.      "
  bitfld.word 0x2c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x2c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x2c 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x2c 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x2c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x2c 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x2c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x2e "PCR027,Pad Configuration Register 027"
  bitfld.word 0x2e 10.--12.       "PA , Pin assignment" "GPIO,ADDR31,ADDR07,ADDR31,res.,res.,res.,res.      "
  bitfld.word 0x2e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x2e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x2e 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x2e 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x2e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x2e 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x2e 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90078++0x3f "PCR028-PCR043: DATA[0:15]"
  line.word 0x00 "PCR028,Pad Configuration Register 028"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,DATA00,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR029,Pad Configuration Register 029"
  bitfld.word 0x02 10.--12.       "PA , Pin assignment" "GPIO,DATA01,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x02 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x04 "PCR030,Pad Configuration Register 030"
  bitfld.word 0x04 10.--12.       "PA , Pin assignment" "GPIO,DATA02,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x04 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x04 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x04 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x04 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x04 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x04 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x04 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x06 "PCR031,Pad Configuration Register 031"
  bitfld.word 0x06 10.--12.       "PA , Pin assignment" "GPIO,DATA03,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x06 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x06 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x06 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x06 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x06 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x06 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x06 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x08 "PCR032,Pad Configuration Register 032"
  bitfld.word 0x08 10.--12.       "PA , Pin assignment" "GPIO,DATA04,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x08 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x08 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x08 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x08 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x08 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x08 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x08 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0a "PCR033,Pad Configuration Register 033"
  bitfld.word 0x0a 10.--12.       "PA , Pin assignment" "GPIO,DATA05,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x0a 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0a 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0a 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x0a 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x0a 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0a 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0a 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0c "PCR034,Pad Configuration Register 034"
  bitfld.word 0x0c 10.--12.       "PA , Pin assignment" "GPIO,DATA06,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x0c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0c 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x0c 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x0c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0c 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0e "PCR035,Pad Configuration Register 035"
  bitfld.word 0x0e 10.--12.       "PA , Pin assignment" "GPIO,DATA07,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x0e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0e 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x0e 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x0e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0e 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0e 00.            "  WPS , Weak pull up/down select" "0,1"

TEXTLINE ""
  line.word 0x10 "PCR036,Pad Configuration Register 036"
  bitfld.word 0x10 10.--12.       "PA , Pin assignment" "GPIO,DATA08,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x10 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x10 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x10 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x10 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x10 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x10 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x10 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x12 "PCR037,Pad Configuration Register 037"
  bitfld.word 0x12 10.--12.       "PA , Pin assignment" "GPIO,DATA09,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x12 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x12 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x12 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x12 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x12 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x12 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x12 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x14 "PCR038,Pad Configuration Register 038"
  bitfld.word 0x14 10.--12.       "PA , Pin assignment" "GPIO,DATA10,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x14 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x14 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x14 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x14 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x14 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x14 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x14 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x16 "PCR039,Pad Configuration Register 039"
  bitfld.word 0x16 10.--12.       "PA , Pin assignment" "GPIO,DATA11,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x16 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x16 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x16 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x16 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x16 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x16 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x16 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x18 "PCR040,Pad Configuration Register 040"
  bitfld.word 0x18 10.--12.       "PA , Pin assignment" "GPIO,DATA12,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x18 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x18 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x18 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x18 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x18 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x18 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x18 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x1A "PCR041,Pad Configuration Register 041"
  bitfld.word 0x1A 10.--12.       "PA , Pin assignment" "GPIO,DATA13,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x1A 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x1A 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x1A 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x1A 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x1A 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x1A 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x1A 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x1c "PCR042,Pad Configuration Register 042"
  bitfld.word 0x1c 10.--12.       "PA , Pin assignment" "GPIO,DATA14,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x1c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x1c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x1c 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x1c 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x1c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x1c 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x1c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x1e "PCR043,Pad Configuration Register 043"
  bitfld.word 0x1e 10.--12.       "PA , Pin assignment" "GPIO,DATA15,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x1e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x1e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x1e 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x1e 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x1e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x1e 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x1e 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90078++0x3f "PCR044-PCR059: DATA[16:31] / FEC"
  line.word 0x20 "PCR044,Pad Configuration Register 044"
  bitfld.word 0x20 10.--12.       "PA , Pin assignment" "GPIO,DATA16,TX_CLK,DATA16,res.,res.,res.,res.      "
  bitfld.word 0x20 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x20 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x20 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x20 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x20 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x20 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x20 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x22 "PCR045,Pad Configuration Register 045"
  bitfld.word 0x22 10.--12.       "PA , Pin assignment" "GPIO,DATA17,CRS,res.,res.,res.,res.,res.      "
  bitfld.word 0x22 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x22 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x22 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x22 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x22 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x22 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x22 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x24 "PCR046,Pad Configuration Register 046"
  bitfld.word 0x24 10.--12.       "PA , Pin assignment" "GPIO,DATA18,TX_ER,res.,res.,res.,res.,res.      "
  bitfld.word 0x24 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x24 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x24 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x24 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x24 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x24 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x24 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x26 "PCR047,Pad Configuration Register 047"
  bitfld.word 0x26 10.--12.       "PA , Pin assignment" "GPIO,DATA19,RX_CLK,res.,res.,res.,res.,res.      "
  bitfld.word 0x26 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x26 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x26 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x26 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x26 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x26 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x26 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x28 "PCR048,Pad Configuration Register 048"
  bitfld.word 0x28 10.--12.       "PA , Pin assignment" "GPIO,DATA20,TXD0,res.,res.,res.,res.,res.      "
  bitfld.word 0x28 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x28 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x28 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x28 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x28 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x28 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x28 00.            "  WPS , Weak pull up/down select" "0,1"


  line.word 0x2a "PCR049,Pad Configuration Register 049"
  bitfld.word 0x2a 10.--12.       "PA , Pin assignment" "GPIO,DATA21,RX_ER,DATA21,res.,res.,res.,res.      "
  bitfld.word 0x2a 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x2a 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x2a 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x2a 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x2a 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x2a 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x2a 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x2c "PCR050,Pad Configuration Register 050"
  bitfld.word 0x2c 10.--12.       "PA , Pin assignment" "GPIO,DATA22,RXD0,DATA22,res.,res.,res.,res.      "
  bitfld.word 0x2c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x2c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x2c 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x2c 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x2c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x2c 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x2c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x2e "PCR051,Pad Configuration Register 051"
  bitfld.word 0x2e 10.--12.       "PA , Pin assignment" "GPIO,DATA23,TXD3,DATA23,res.,res.,res.,res.      "
  bitfld.word 0x2e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x2e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x2e 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x2e 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x2e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x2e 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x2e 00.            "  WPS , Weak pull up/down select" "0,1"

TEXTLINE ""
  line.word 0x30 "PCR052,Pad Configuration Register 052"
  bitfld.word 0x30 10.--12.       "PA , Pin assignment" "GPIO,DATA24,COL,DATA24,res.,res.,res.,res.      "
  bitfld.word 0x30 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x30 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x30 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x30 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x30 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x30 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x30 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x32 "PCR053,Pad Configuration Register 053"
  bitfld.word 0x32 10.--12.       "PA , Pin assignment" "GPIO,DATA25,RX_DV,DATA25,res.,res.,res.,res.      "
  bitfld.word 0x32 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x32 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x32 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x32 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x32 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x32 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x32 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x34 "PCR054,Pad Configuration Register 054"
  bitfld.word 0x34 10.--12.       "PA , Pin assignment" "GPIO,DATA26,TX_EN,DATA26,res.,res.,res.,res.      "
  bitfld.word 0x34 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x34 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x34 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x34 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x34 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x34 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x34 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x36 "PCR055,Pad Configuration Register 055"
  bitfld.word 0x36 10.--12.       "PA , Pin assignment" "GPIO,DATA27,TXD2,DATA27,res.,res.,res.,res.      "
  bitfld.word 0x36 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x36 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x36 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x36 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x36 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x36 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x36 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x38 "PCR056,Pad Configuration Register 056"
  bitfld.word 0x38 10.--12.       "PA , Pin assignment" "GPIO,DATA28,TXD1,DATA28,res.,res.,res.,res.      "
  bitfld.word 0x38 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x38 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x38 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x38 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x38 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x38 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x38 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x3a "PCR057,Pad Configuration Register 057"
  bitfld.word 0x3a 10.--12.       "PA , Pin assignment" "GPIO,DATA29,RXD1,DATA29,res.,res.,res.,res.      "
  bitfld.word 0x3a 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x3a 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x3a 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x3a 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x3a 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x3a 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x3a 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x3c "PCR058,Pad Configuration Register 058"
  bitfld.word 0x3c 10.--12.       "PA , Pin assignment" "GPIO,DATA30,RXD2,DATA30,res.,res.,res.,res.      "
  bitfld.word 0x3c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x3c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x3c 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x3c 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x3c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x3c 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x3c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x3e "PCR059,Pad Configuration Register 059"
  bitfld.word 0x3e 10.--12.       "PA , Pin assignment" "GPIO,DATA31,RXD3,DATA31,res.,res.,res.,res.      "
  bitfld.word 0x3e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x3e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x3e 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x3e 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x3e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x3e 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x3e 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900B8++0x03 "PCR060-PCR061: TSIZ[0:1]"
  line.word 0x00 "PCR060,Pad Configuration Register 060"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,TSIZ0,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR061,Pad Configuration Register 061"
  bitfld.word 0x02 10.--12.       "PA , Pin assignment" "GPIO,TSIZ1,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x02 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900BC++0x01 "PCR062: RD/!WR"
  line.word 0x00 "PCR062,Pad Configuration Register 062"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,RD/!WR,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900BE++0x01 "PCR063: !BDIP"
  line.word 0x00 "PCR063,Pad Configuration Register 063"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,!BDIP,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900C0++0x07 "PCR064-067: !WE_BE[0:3]"
  line.word 0x00 "PCR064,Pad Configuration Register 064"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,!WE0_BE0,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR065,Pad Configuration Register 065"
  bitfld.word 0x02 10.--12.       "PA , Pin assignment" "GPIO,!WE1_BE1,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x02 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x04 "PCR066,Pad Configuration Register 066"
  bitfld.word 0x04 10.--12.       "PA , Pin assignment" "GPIO,!WE2_BE2,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x04 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x04 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x04 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x04 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x04 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x04 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x04 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x06 "PCR067,Pad Configuration Register 067"
  bitfld.word 0x06 10.--12.       "PA , Pin assignment" "GPIO,!WE3_BE3,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x06 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x06 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x06 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x06 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x06 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x06 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x06 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900C8++0x01 "PCR068: !OE"
  line.word 0x00 "PCR068,Pad Configuration Register 068"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,!OE,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900CA++0x01 "PCR069: !TS"
  line.word 0x00 "PCR069,Pad Configuration Register 069"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,!TS,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900CC++0x01 "PCR070: !TA"
  line.word 0x00 "PCR070,Pad Configuration Register 070"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,!TA,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900CE++0x01 "PCR071: !TEA"
  line.word 0x00 "PCR071,Pad Configuration Register 071"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,!TEA,res.,!TEA,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900D0++0x01 "PCR072: !BR / MDC"
  line.word 0x00 "PCR072,Pad Configuration Register 072"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,!BR,MDC,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900D2++0x01 "PCR073: !BG / MDIO"
  line.word 0x00 "PCR073,Pad Configuration Register 073"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,!BG,MDIO,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900D4++0x01 "PCR074: !BB"
  line.word 0x00 "PCR073,Pad Configuration Register 073"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,!BB,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900D6++0x0f "PCR075-PCR082: MDO[4:11]"
  line.word 0x00 "PCR075,Pad Configuration Register 075"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO/MDO04,res.,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR076,Pad Configuration Register 076"
  bitfld.word 0x02 10.--12.       "PA , Pin assignment" "GPIO/MDO05,res.,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x02 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x04 "PCR077,Pad Configuration Register 077"
  bitfld.word 0x04 10.--12.       "PA , Pin assignment" "GPIO/MDO06,res.,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x04 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x04 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x04 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x04 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x04 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x04 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x04 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x06 "PCR078,Pad Configuration Register 078"
  bitfld.word 0x06 10.--12.       "PA , Pin assignment" "GPIO/MDO07,res.,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x06 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x06 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x06 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x06 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x06 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x06 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x06 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x08 "PCR079,Pad Configuration Register 079"
  bitfld.word 0x08 10.--12.       "PA , Pin assignment" "GPIO/MDO08,res.,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x08 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x08 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x08 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x08 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x08 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x08 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x08 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0a "PCR080,Pad Configuration Register 080"
  bitfld.word 0x0a 10.--12.       "PA , Pin assignment" "GPIO/MDO09,res.,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x0a 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0a 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0a 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x0a 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x0a 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0a 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0a 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0c "PCR081,Pad Configuration Register 081"
  bitfld.word 0x0c 10.--12.       "PA , Pin assignment" "GPIO/MDO10,res.,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x0c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0c 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x0c 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x0c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0c 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0e "PCR082,Pad Configuration Register 082"
  bitfld.word 0x0e 10.--12.       "PA , Pin assignment" "GPIO/MDO11,res.,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x0e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0e 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x0e 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x0e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0e 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0e 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900E6++0x01 "PCR083: CNTX_A / TXDA"
  line.word 0x00 "PCR083,Pad Configuration Register 083"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,CNTX_A,TXDA,CNTX_A,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900E8++0x01 "PCR084: CNRX_A / RXDA"
  line.word 0x00 "PCR084,Pad Configuration Register 084"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,CNRX_A,RXDA,CNRX_A,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900EA++0x01 "PCR085: CNTX_B / DSPI PCSC3"
  line.word 0x00 "PCR085,Pad Configuration Register 085"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,CNTX_B,PCSC3,CNTX_B,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900EC++0x01 "PCR086: CNRX_B / DSPI PCSC4"
  line.word 0x00 "PCR086,Pad Configuration Register 086"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,CNRX_B,PCSC4,CNRX_B,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900EE++0x01 "PCR087: CNTX_C / DSPI PCSD3"
  line.word 0x00 "PCR087,Pad Configuration Register 087"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,CNTX_C,PCSD3,CNTX_C,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900F0++0x01 "PCR088: CNRX_C / DSPI PCSD4"
  line.word 0x00 "PCR088,Pad Configuration Register 088"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,CNRX_C,PCSD4,CNRX_C,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900F2++0x01 "PCR089: TXD_A"
  line.word 0x00 "PCR089,Pad Configuration Register 089"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,TXD_A,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900F4++0x01 "PCR090: RXD_A"
  line.word 0x00 "PCR090,Pad Configuration Register 090"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,RXD_A,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900F6++0x01 "PCR091: TXD_B / DSPI PCSD1"
  line.word 0x00 "PCR091,Pad Configuration Register 091"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,TXD_B,PCSD1,TXD_B,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900F8++0x01 "PCR092: RXD_B / PCSD5"
  line.word 0x00 "PCR092,Pad Configuration Register 092"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,RXD_B,PCSD5,RXD_B,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900FA++0x01 "PCR093: DSPI SCK_A / DSPI PCSC1"
  line.word 0x00 "PCR093,Pad Configuration Register 093"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,SCK_A,PCSC1,SCK_A,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900FC++0x01 "PCR094: DSPI SIN_A / DSPI PCSC2"
  line.word 0x00 "PCR094,Pad Configuration Register 094"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,SIN_A,PCSC2,SIN_A,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900FE++0x01 "PCR095: DSPI SOUT_A / DSPI PCSC5"
  line.word 0x00 "PCR095,Pad Configuration Register 095"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,SOUT_A,PCSC5,SOUT_A,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90100++0x01 "PCR096: DSPI PCSA0 / DSPI PCSD2"
  line.word 0x00 "PCR096,Pad Configuration Register 096"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,PCSA0,PCSD2,PCSA0,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90102++0x01 "PCR097: DSPI PCSA1 / PCSB2"
  line.word 0x00 "PCR097,Pad Configuration Register 097"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,PCSA1,PCSB2,PCSA1,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90104++0x01 "PCR098: DSPI PCSA2 / DSPI SCKD"
  line.word 0x00 "PCR098,Pad Configuration Register 098"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,PCSA2,SCKD,PCSA2,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90106++0x01 "PCR099: DSPI PCSA3 / DSPI SIN_D"
  line.word 0x00 "PCR099,Pad Configuration Register 099"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,PCSA3,SIN_D,PCSA3,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90108++0x01 "PCR100: DSPI PCSA4 / DSPI SOUTD"
  line.word 0x00 "PCR100,Pad Configuration Register 100"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,PCSA4,SOUTD,PCSA4,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F9010a++0x01 "PCR101: DSPI PCSA5 / DSPI PCSB3"
  line.word 0x00 "PCR101,Pad Configuration Register 101"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,PCSA5,PCSB3,PCSA5,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F9010c++0x01 "PCR102: DSPI SCKB / DSPI PCSC1"
  line.word 0x00 "PCR102,Pad Configuration Register 102"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,SCKB,PCSC1,SCKB,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F9010e++0x01 "PCR103: DSPI SINB / DSPI PCSC2"
  line.word 0x00 "PCR103,Pad Configuration Register 103"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,SINB,PCSC2,SINB,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90110++0x01 "PCR104: DSPI SOUTB / DSPI PCSC5"
  line.word 0x00 "PCR104,Pad Configuration Register 104"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,SOUTB,PCSC5,SOUTB,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90112++0x01 "PCR105: DSPI PCSB0 / DSPI PCSD2"
  line.word 0x00 "PCR105,Pad Configuration Register 105"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,PCSB0,PCSD2,PCSB0,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90114++0x01 "PCR106: DSPI PCSB1 / DSPI PCSD0"
  line.word 0x00 "PCR106,Pad Configuration Register 106"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,PCSB1,PCSD0,PCSB1,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90116++0x01 "PCR107: DSPI PCSB2 / DSPI SOUTC"
  line.word 0x00 "PCR107,Pad Configuration Register 107"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,PCSB2,SOUTC,PCSB2,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90118++0x01 "PCR108: DSPI PCSB3 / DSPI SINC"
  line.word 0x00 "PCR108,Pad Configuration Register 108"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,PCSB3,SINC,PCSB3,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F9011A++0x01 "PCR109: DSPI PCSB4 / DSPI SCKC"
  line.word 0x00 "PCR109,Pad Configuration Register 109"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,PCSB4,SCKC,PCSB4,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F9011C++0x01 "PCR110: DSPI PCSB5 / DSPI PCSC0"
  line.word 0x00 "PCR110,Pad Configuration Register 110"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,PCSB5,PCSC0,PCSB5,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F9011E++0x03 "PCR111-112: ETRIG[0:1]"
  line.word 0x00 "PCR111,Pad Configuration Register 111"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,ETRIG0,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR112,Pad Configuration Register 112"
  bitfld.word 0x02 10.--12.       "PA , Pin assignment" "GPIO,ETRIG1,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x02 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90122++0x01 "PCR113: TCRCLKA / IRQ7"
  line.word 0x00 "PCR113,Pad Configuration Register 113"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,TCRCLKA,IRQ7,TCRCLKA,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90124++0x3F "PCR114-145: ETPUA[0:31] / ETPUA[12:23] / PCSB[1:4] / IRQ[8:15] / PCDC[1:4] / PCSD[1:4]"
  line.word 0x00 "PCR114,Pad Configuration Register 114"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,ETPUA00,ETPUA12,ETPUA00,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR115,Pad Configuration Register 115"
  bitfld.word 0x02 10.--12.       "PA , Pin assignment" "GPIO,ETPUA01,ETPUA13,ETPUA01,res.,res.,res.,res.      "
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x02 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x04 "PCR116,Pad Configuration Register 116"
  bitfld.word 0x04 10.--12.       "PA , Pin assignment" "GPIO,ETPUA02,ETPUA14,ETPUA02,res.,res.,res.,res.      "
  bitfld.word 0x04 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x04 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x04 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x04 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x04 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x04 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x04 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x06 "PCR117,Pad Configuration Register 117"
  bitfld.word 0x06 10.--12.       "PA , Pin assignment" "GPIO,ETPUA03,ETPUA15,ETPUA03,res.,res.,res.,res.      "
  bitfld.word 0x06 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x06 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x06 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x06 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x06 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x06 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x06 00.            "  WPS , Weak pull up/down select" "0,1"


  line.word 0x08 "PCR118,Pad Configuration Register 118"
  bitfld.word 0x08 10.--12.       "PA , Pin assignment" "GPIO,ETPUA04,ETPUA16,ETPUA04,res.,res.,res.,res.      "
  bitfld.word 0x08 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x08 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x08 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x08 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x08 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x08 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x08 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0a "PCR119,Pad Configuration Register 119"
  bitfld.word 0x0a 10.--12.       "PA , Pin assignment" "GPIO,ETPUA05,ETPUA17,ETPUA05,res.,res.,res.,res.      "
  bitfld.word 0x0a 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0a 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0a 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x0a 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0a 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x0a 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0a 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0c "PCR120,Pad Configuration Register 120"
  bitfld.word 0x0c 10.--12.       "PA , Pin assignment" "GPIO,ETPUA06,ETPUA18,ETPUA06,res.,res.,res.,res.      "
  bitfld.word 0x0c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0c 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x0c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0c 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x0c 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0e "PCR121,Pad Configuration Register 121"
  bitfld.word 0x0e 10.--12.       "PA , Pin assignment" "GPIO,ETPUA07,ETPUA19,ETPUA07,res.,res.,res.,res.      "
  bitfld.word 0x0e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0e 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x0e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0e 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x0e 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0e 00.            "  WPS , Weak pull up/down select" "0,1"

TEXTLINE "" 
  line.word 0x10 "PCR122,Pad Configuration Register 122"
  bitfld.word 0x10 10.--12.       "PA , Pin assignment" "GPIO,ETPUA08,ETPUA20,ETPUA08,res.,res.,res.,res.      "
  bitfld.word 0x10 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x10 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x10 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x10 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x10 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x10 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x10 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x12 "PCR123,Pad Configuration Register 123"
  bitfld.word 0x12 10.--12.       "PA , Pin assignment" "GPIO,ETPUA09,ETPUA21,ETPUA09,res.,res.,res.,res.      "
  bitfld.word 0x12 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x12 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x12 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x12 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x12 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x12 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x12 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x14 "PCR124,Pad Configuration Register 124"
  bitfld.word 0x14 10.--12.       "PA , Pin assignment" "GPIO,ETPUA10,ETPUA22,ETPUA10,res.,res.,res.,res.      "
  bitfld.word 0x14 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x14 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x14 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x14 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x14 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x14 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x14 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x16 "PCR125,Pad Configuration Register 125"
  bitfld.word 0x16 10.--12.       "PA , Pin assignment" "GPIO,ETPUA11,ETPUA23,ETPUA11,res.,res.,res.,res.      "
  bitfld.word 0x16 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x16 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x16 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x16 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x16 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x16 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x16 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x18 "PCR126,Pad Configuration Register 126"
  bitfld.word 0x18 10.--12.       "PA , Pin assignment" "GPIO,ETPUA12,PCSB1,ETPUA12,res.,res.,res.,res.      "
  bitfld.word 0x18 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x18 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x18 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x18 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x18 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x18 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x18 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x1A "PCR127,Pad Configuration Register 127"
  bitfld.word 0x1A 10.--12.       "PA , Pin assignment" "GPIO,ETPUA13,PCSB3,ETPUA13,res.,res.,res.,res.      "
  bitfld.word 0x1A 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x1A 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x1A 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x1A 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x1A 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x1A 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x1A 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x1c "PCR128,Pad Configuration Register 128"
  bitfld.word 0x1c 10.--12.       "PA , Pin assignment" "GPIO,ETPUA14,PCSB4,ETPUA14,res.,res.,res.,res.      "
  bitfld.word 0x1c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x1c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x1c 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x1c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x1c 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x1c 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x1c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x1e "PCR129,Pad Configuration Register 129"
  bitfld.word 0x1e 10.--12.       "PA , Pin assignment" "GPIO,ETPUA15,PCSB5,ETPUA15,res.,res.,res.,res.      "
  bitfld.word 0x1e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x1e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x1e 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x1e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x1e 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x1e 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x1e 00.            "  WPS , Weak pull up/down select" "0,1"

TEXTLINE ""
  line.word 0x20 "PCR130,Pad Configuration Register 130"
  bitfld.word 0x20 10.--12.       "PA , Pin assignment" "GPIO,ETPUA16,PCSD1,ETPUA16,res.,res.,res.,res.      "
  bitfld.word 0x20 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x20 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x20 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x20 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x20 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x20 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x20 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x22 "PCR131,Pad Configuration Register 131"
  bitfld.word 0x22 10.--12.       "PA , Pin assignment" "GPIO,ETPUA17,PCSD2,ETPUA17,res.,res.,res.,res.      "
  bitfld.word 0x22 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x22 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x22 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x22 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x22 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x22 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x22 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x24 "PCR132,Pad Configuration Register 132"
  bitfld.word 0x24 10.--12.       "PA , Pin assignment" "GPIO,ETPUA18,PCSD3,ETPUA18,res.,res.,res.,res.      "
  bitfld.word 0x24 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x24 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x24 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x24 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x24 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x24 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x24 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x26 "PCR133,Pad Configuration Register 133"
  bitfld.word 0x26 10.--12.       "PA , Pin assignment" "GPIO,ETPUA19,PCSD4,ETPUA19,res.,res.,res.,res.      "
  bitfld.word 0x26 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x26 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x26 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x26 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x26 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x26 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x26 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x28 "PCR134,Pad Configuration Register 134"
  bitfld.word 0x28 10.--12.       "PA , Pin assignment" "GPIO,ETPUA20,IRQ08,ETPUA20,res.,res.,res.,res.      "
  bitfld.word 0x28 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x28 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x28 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x28 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x28 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x28 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x28 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x2a "PCR135,Pad Configuration Register 135"
  bitfld.word 0x2a 10.--12.       "PA , Pin assignment" "GPIO,ETPUA21,IRQ09,ETPUA21,res.,res.,res.,res.      "
  bitfld.word 0x2a 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x2a 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x2a 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x2a 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x2a 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x2a 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x2a 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x2c "PCR136,Pad Configuration Register 136"
  bitfld.word 0x2c 10.--12.       "PA , Pin assignment" "GPIO,ETPUA22,IRQ10,ETPUA22,res.,res.,res.,res.      "
  bitfld.word 0x2c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x2c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x2c 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x2c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x2c 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x2c 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x2c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x2e "PCR137,Pad Configuration Register 137"
  bitfld.word 0x2e 10.--12.       "PA , Pin assignment" "GPIO,ETPUA23,IRQ11,ETPUA23,res.,res.,res.,res.      "
  bitfld.word 0x2e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x2e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x2e 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x2e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x2e 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x2e 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x2e 00.            "  WPS , Weak pull up/down select" "0,1"

TEXTLINE ""
  line.word 0x30 "PCR138,Pad Configuration Register 138"
  bitfld.word 0x30 10.--12.       "PA , Pin assignment" "GPIO,ETPUA24,IRQ12,ETPUA24,res.,res.,res.,res.      "
  bitfld.word 0x30 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x30 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x30 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x30 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x30 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x30 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x30 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x32 "PCR139,Pad Configuration Register 139"
  bitfld.word 0x32 10.--12.       "PA , Pin assignment" "GPIO,ETPUA25,IRQ13,ETPUA25,res.,res.,res.,res.      "
  bitfld.word 0x32 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x32 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x32 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x32 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x32 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x32 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x32 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x34 "PCR140,Pad Configuration Register 140"
  bitfld.word 0x34 10.--12.       "PA , Pin assignment" "GPIO,ETPUA26,IRQ14,ETPUA26,res.,res.,res.,res.      "
  bitfld.word 0x34 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x34 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x34 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x34 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x34 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x34 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x34 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x36 "PCR141,Pad Configuration Register 141"
  bitfld.word 0x36 10.--12.       "PA , Pin assignment" "GPIO,ETPUA27,IRQ15,ETPUA27,res.,res.,res.,res.      "
  bitfld.word 0x36 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x36 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x36 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x36 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x36 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x36 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x36 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x38 "PCR142,Pad Configuration Register 142"
  bitfld.word 0x38 10.--12.       "PA , Pin assignment" "GPIO,ETPUA28,PCSC1,ETPUA28,res.,res.,res.,res.      "
  bitfld.word 0x38 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x38 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x38 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x38 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x38 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x38 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x38 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x3a "PCR143,Pad Configuration Register 143"
  bitfld.word 0x3a 10.--12.       "PA , Pin assignment" "GPIO,ETPUA29,PCSC2,ETPUA29,res.,res.,res.,res.      "
  bitfld.word 0x3a 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x3a 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x3a 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x3a 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x3a 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x3a 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x3a 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x3c "PCR144,Pad Configuration Register 144"
  bitfld.word 0x3c 10.--12.       "PA , Pin assignment" "GPIO,ETPUA30,PCSC3,ETPUA30,res.,res.,res.,res.      "
  bitfld.word 0x3c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x3c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x3c 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x3c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x3c 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x3c 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x3c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x3e "PCR145,Pad Configuration Register 145"
  bitfld.word 0x3e 10.--12.       "PA , Pin assignment" "GPIO,ETPUA31,PCSC4,ETPUA31,res.,res.,res.,res.      "
  bitfld.word 0x3e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x3e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x3e 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x3e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x3e 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x3e 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x3e 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90164++0x01 "PCR146: TCRCLKB / IRQ6"
  line.word 0x00 "PCR146,Pad Configuration Register 146"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,TCRCLKB,IRQ06,TCRCLKB,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90166++0x3F "PCR147-178: ETPUB[0:31] / ETPUB[16:31] / PCSA[1:4]"
  line.word 0x00 "PCR147,Pad Configuration Register 147"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,ETPUB00,ETPUB16,ETPUB00,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR148,Pad Configuration Register 148"
  bitfld.word 0x02 10.--12.       "PA , Pin assignment" "GPIO,ETPUB01,ETPUB17,ETPUB01,res.,res.,res.,res.      "
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x02 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x04 "PCR149,Pad Configuration Register 149"
  bitfld.word 0x04 10.--12.       "PA , Pin assignment" "GPIO,ETPUB02,ETPUB18,ETPUB02,res.,res.,res.,res.      "
  bitfld.word 0x04 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x04 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x04 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x04 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x04 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x04 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x04 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x06 "PCR150,Pad Configuration Register 150"
  bitfld.word 0x06 10.--12.       "PA , Pin assignment" "GPIO,ETPUB03,ETPUB19,ETPUB03,res.,res.,res.,res.      "
  bitfld.word 0x06 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x06 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x06 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x06 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x06 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x06 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x06 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x08 "PCR151,Pad Configuration Register 151"
  bitfld.word 0x08 10.--12.       "PA , Pin assignment" "GPIO,ETPUB04,ETPUB20,ETPUB04,res.,res.,res.,res.      "
  bitfld.word 0x08 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x08 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x08 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x08 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x08 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x08 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x08 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0a "PCR152,Pad Configuration Register 152"
  bitfld.word 0x0a 10.--12.       "PA , Pin assignment" "GPIO,ETPUB05,ETPUB21,ETPUB05,res.,res.,res.,res.      "
  bitfld.word 0x0a 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0a 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0a 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x0a 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0a 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x0a 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0a 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0c "PCR153,Pad Configuration Register 153"
  bitfld.word 0x0c 10.--12.       "PA , Pin assignment" "GPIO,ETPUB06,ETPUB22,ETPUB06,res.,res.,res.,res.      "
  bitfld.word 0x0c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0c 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x0c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0c 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x0c 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0e "PCR154,Pad Configuration Register 154"
  bitfld.word 0x0e 10.--12.       "PA , Pin assignment" "GPIO,ETPUB07,ETPUB23,ETPUB07,res.,res.,res.,res.      "
  bitfld.word 0x0e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0e 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x0e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0e 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x0e 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0e 00.            "  WPS , Weak pull up/down select" "0,1"

TEXTLINE "" 
  line.word 0x10 "PCR155,Pad Configuration Register 155"
  bitfld.word 0x10 10.--12.       "PA , Pin assignment" "GPIO,ETPUB08,ETPUB24,ETPUB08,res.,res.,res.,res.      "
  bitfld.word 0x10 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x10 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x10 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x10 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x10 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x10 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x10 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x12 "PCR156,Pad Configuration Register 156"
  bitfld.word 0x12 10.--12.       "PA , Pin assignment" "GPIO,ETPUB09,ETPUB25,ETPUB09,res.,res.,res.,res.      "
  bitfld.word 0x12 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x12 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x12 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x12 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x12 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x12 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x12 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x14 "PCR157,Pad Configuration Register 157"
  bitfld.word 0x14 10.--12.       "PA , Pin assignment" "GPIO,ETPUB10,ETPUB26,ETPUB10,res.,res.,res.,res.      "
  bitfld.word 0x14 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x14 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x14 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x14 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x14 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x14 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x14 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x16 "PCR158,Pad Configuration Register 158"
  bitfld.word 0x16 10.--12.       "PA , Pin assignment" "GPIO,ETPUB11,ETPUB27,ETPUB11,res.,res.,res.,res.      "
  bitfld.word 0x16 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x16 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x16 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x16 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x16 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x16 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x16 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x18 "PCR159,Pad Configuration Register 159"
  bitfld.word 0x18 10.--12.       "PA , Pin assignment" "GPIO,ETPUB12,ETPUB28,ETPUB12,res.,res.,res.,res.      "
  bitfld.word 0x18 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x18 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x18 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x18 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x18 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x18 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x18 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x1A "PCR160,Pad Configuration Register 160"
  bitfld.word 0x1A 10.--12.       "PA , Pin assignment" "GPIO,ETPUB13,ETPUB29,ETPUB13,res.,res.,res.,res.      "
  bitfld.word 0x1A 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x1A 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x1A 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x1A 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x1A 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x1A 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x1A 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x1c "PCR161,Pad Configuration Register 161"
  bitfld.word 0x1c 10.--12.       "PA , Pin assignment" "GPIO,ETPUB14,ETPUB30,ETPUB14,res.,res.,res.,res.      "
  bitfld.word 0x1c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x1c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x1c 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x1c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x1c 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x1c 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x1c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x1e "PCR162,Pad Configuration Register 162"
  bitfld.word 0x1e 10.--12.       "PA , Pin assignment" "GPIO,ETPUB15,ETPUB31,ETPUB15,res.,res.,res.,res.      "
  bitfld.word 0x1e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x1e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x1e 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x1e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x1e 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x1e 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x1e 00.            "  WPS , Weak pull up/down select" "0,1"

TEXTLINE ""
  line.word 0x20 "PCR163,Pad Configuration Register 163"
  bitfld.word 0x20 10.--12.       "PA , Pin assignment" "GPIO,ETPUB16,PCSA1,ETPUB16,res.,res.,res.,res.      "
  bitfld.word 0x20 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x20 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x20 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x20 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x20 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x20 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x20 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x22 "PCR164,Pad Configuration Register 164"
  bitfld.word 0x22 10.--12.       "PA , Pin assignment" "GPIO,ETPUB17,PCSA2,ETPUB17,res.,res.,res.,res.      "
  bitfld.word 0x22 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x22 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x22 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x22 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x22 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x22 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x22 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x24 "PCR165,Pad Configuration Register 165"
  bitfld.word 0x24 10.--12.       "PA , Pin assignment" "GPIO,ETPUB18,PCSA3,ETPUB18,res.,res.,res.,res.      "
  bitfld.word 0x24 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x24 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x24 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x24 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x24 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x24 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x24 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x26 "PCR166,Pad Configuration Register 166"
  bitfld.word 0x26 10.--12.       "PA , Pin assignment" "GPIO,ETPUB19,PCSA4,ETPUB19,res.,res.,res.,res.      "
  bitfld.word 0x26 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x26 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x26 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x26 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x26 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x26 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x26 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x28 "PCR167,Pad Configuration Register 167"
  bitfld.word 0x28 10.--12.       "PA , Pin assignment" "GPIO,ETPUB20,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x28 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x28 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x28 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x28 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x28 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x28 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x28 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x2a "PCR168,Pad Configuration Register 168"
  bitfld.word 0x2a 10.--12.       "PA , Pin assignment" "GPIO,ETPUB21,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x2a 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x2a 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x2a 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x2a 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x2a 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x2a 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x2a 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x2c "PCR169,Pad Configuration Register 169"
  bitfld.word 0x2c 10.--12.       "PA , Pin assignment" "GPIO,ETPUB22,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x2c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x2c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x2c 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x2c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x2c 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x2c 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x2c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x2e "PCR170,Pad Configuration Register 170"
  bitfld.word 0x2e 10.--12.       "PA , Pin assignment" "GPIO,ETPUB23,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x2e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x2e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x2e 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x2e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x2e 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x2e 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x2e 00.            "  WPS , Weak pull up/down select" "0,1"

TEXTLINE "" 
  line.word 0x30 "PCR171,Pad Configuration Register 171"
  bitfld.word 0x30 10.--12.       "PA , Pin assignment" "GPIO,ETPUB24,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x30 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x30 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x30 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x30 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x30 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x30 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x30 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x32 "PCR172,Pad Configuration Register 172"
  bitfld.word 0x32 10.--12.       "PA , Pin assignment" "GPIO,ETPUB25,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x32 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x32 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x32 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x32 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x32 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x32 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x32 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x34 "PCR173,Pad Configuration Register 173"
  bitfld.word 0x34 10.--12.       "PA , Pin assignment" "GPIO,ETPUB26,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x34 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x34 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x34 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x34 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x34 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x34 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x34 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x36 "PCR174,Pad Configuration Register 174"
  bitfld.word 0x36 10.--12.       "PA , Pin assignment" "GPIO,ETPUB27,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x36 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x36 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x36 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x36 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x36 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x36 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x36 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x38 "PCR175,Pad Configuration Register 175"
  bitfld.word 0x38 10.--12.       "PA , Pin assignment" "GPIO,ETPUB28,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x38 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x38 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x38 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x38 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x38 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x38 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x38 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x3a "PCR176,Pad Configuration Register 176"
  bitfld.word 0x3a 10.--12.       "PA , Pin assignment" "GPIO,ETPUB29,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x3a 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x3a 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x3a 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x3a 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x3a 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x3a 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x3a 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x3c "PCR177,Pad Configuration Register 177"
  bitfld.word 0x3c 10.--12.       "PA , Pin assignment" "GPIO,ETPUB30,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x3c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x3c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x3c 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x3c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x3c 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x3c 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x3c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x3e "PCR178,Pad Configuration Register 178"
  bitfld.word 0x3e 10.--12.       "PA , Pin assignment" "GPIO,ETPUB31,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x3e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x3e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x3e 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x3e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x3e 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x3e 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x3e 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F901A6++0x31 "PCR179-202: EMIOS[0:23] / ETPUA[0:9] / SOUTC / SOUTD / IRQ[0:1] / ETPUB[0:7]"
  line.word 0x00 "PCR179,Pad Configuration Register 179"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,EMIOS00,ETPUA00,EMIOS00,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR180,Pad Configuration Register 180"
  bitfld.word 0x02 10.--12.       "PA , Pin assignment" "GPIO,EMIOS01,ETPUA01,EMIOS01,res.,res.,res.,res.      "
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x02 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x04 "PCR181,Pad Configuration Register 181"
  bitfld.word 0x04 10.--12.       "PA , Pin assignment" "GPIO,EMIOS02,ETPUA02,EMIOS02,res.,res.,res.,res.      "
  bitfld.word 0x04 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x04 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x04 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x04 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x04 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x04 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x04 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x06 "PCR182,Pad Configuration Register 182"
  bitfld.word 0x06 10.--12.       "PA , Pin assignment" "GPIO,EMIOS03,ETPUA03,EMIOS03,res.,res.,res.,res.      "
  bitfld.word 0x06 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x06 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x06 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x06 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x06 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x06 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x06 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x08 "PCR183,Pad Configuration Register 183"
  bitfld.word 0x08 10.--12.       "PA , Pin assignment" "GPIO,EMIOS04,ETPUA04,EMIOS04,res.,res.,res.,res.      "
  bitfld.word 0x08 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x08 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x08 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x08 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x08 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x08 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x08 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0a "PCR184,Pad Configuration Register 184"
  bitfld.word 0x0a 10.--12.       "PA , Pin assignment" "GPIO,EMIOS05,ETPUA05,EMIOS05,res.,res.,res.,res.      "
  bitfld.word 0x0a 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0a 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0a 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x0a 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0a 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x0a 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0a 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0c "PCR185,Pad Configuration Register 185"
  bitfld.word 0x0c 10.--12.       "PA , Pin assignment" "GPIO,EMIOS06,ETPUA06,EMIOS06,res.,res.,res.,res.      "
  bitfld.word 0x0c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0c 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x0c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0c 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x0c 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0e "PCR186,Pad Configuration Register 186"
  bitfld.word 0x0e 10.--12.       "PA , Pin assignment" "GPIO,EMIOS07,ETPUA07,EMIOS07,res.,res.,res.,res.      "
  bitfld.word 0x0e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0e 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x0e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0e 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x0e 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0e 00.            "  WPS , Weak pull up/down select" "0,1"

TEXTLINE "" 
  line.word 0x10 "PCR187,Pad Configuration Register 187"
  bitfld.word 0x10 10.--12.       "PA , Pin assignment" "GPIO,EMIOS08,ETPUA08,EMIOS08,res.,res.,res.,res.      "
  bitfld.word 0x10 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x10 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x10 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x10 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x10 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x10 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x10 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x12 "PCR188,Pad Configuration Register 188"
  bitfld.word 0x12 10.--12.       "PA , Pin assignment" "GPIO,EMIOS09,ETPUA09,EMIOS09,res.,res.,res.,res.      "
  bitfld.word 0x12 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x12 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x12 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x12 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x12 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x12 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x12 00.            "  WPS , Weak pull up/down select" "0,1"


  line.word 0x14 "PCR189,Pad Configuration Register 189"
  bitfld.word 0x14 10.--12.       "PA , Pin assignment" "GPIO,EMIOS10,PCSD3,EMIOS10,res.,res.,res.,res.      "
  bitfld.word 0x14 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x14 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x14 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x14 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x14 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x14 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x14 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x16 "PCR190,Pad Configuration Register 190"
  bitfld.word 0x16 10.--12.       "PA , Pin assignment" "GPIO,EMIOS11,PCSD4,EMIOS11,res.,res.,res.,res.      "
  bitfld.word 0x16 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x16 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x16 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x16 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x16 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x16 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x16 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x18 "PCR191,Pad Configuration Register 191"
  bitfld.word 0x18 10.--12.       "PA , Pin assignment" "GPIO,EMIOS12,SOUTC,EMIOS12,res.,res.,res.,res.      "
  bitfld.word 0x18 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x18 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x18 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x18 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x18 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x18 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x18 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x1A "PCR192,Pad Configuration Register 192"
  bitfld.word 0x1A 10.--12.       "PA , Pin assignment" "GPIO,EMIOS13,SOUTD,EMIOS13,res.,res.,res.,res.      "
  bitfld.word 0x1A 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x1A 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x1A 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x1A 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x1A 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x1A 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x1A 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x1c "PCR193,Pad Configuration Register 193"
  bitfld.word 0x1c 10.--12.       "PA , Pin assignment" "GPIO,EMIOS14,IRQ00,EMIOS14,res.,res.,res.,res.      "
  bitfld.word 0x1c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x1c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x1c 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x1c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x1c 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x1c 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x1c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x1e "PCR194,Pad Configuration Register 194"
  bitfld.word 0x1e 10.--12.       "PA , Pin assignment" "GPIO,EMIOS15,IRQ01,EMIOS15,res.,res.,res.,res.      "
  bitfld.word 0x1e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x1e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x1e 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x1e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x1e 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x1e 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x1e 00.            "  WPS , Weak pull up/down select" "0,1"

TEXTLINE ""
  line.word 0x20 "PCR195,Pad Configuration Register 195"
  bitfld.word 0x20 10.--12.       "PA , Pin assignment" "GPIO,EMIOS16,res.,EMIOS16,res.,res.,res.,res.      "
  bitfld.word 0x20 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x20 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x20 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x20 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x20 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x20 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x20 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x22 "PCR196,Pad Configuration Register 196"
  bitfld.word 0x22 10.--12.       "PA , Pin assignment" "GPIO,EMIOS17,res.,EMIOS17,res.,res.,res.,res.      "
  bitfld.word 0x22 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x22 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x22 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x22 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x22 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x22 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x22 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x24 "PCR197,Pad Configuration Register 197"
  bitfld.word 0x24 10.--12.       "PA , Pin assignment" "GPIO,EMIOS18,res.,EMIOS18,res.,res.,res.,res.      "
  bitfld.word 0x24 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x24 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x24 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x24 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x24 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x24 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x24 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x26 "PCR198,Pad Configuration Register 198"
  bitfld.word 0x26 10.--12.       "PA , Pin assignment" "GPIO,EMIOS19,res.,EMIOS19,res.,res.,res.,res.      "
  bitfld.word 0x26 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x26 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x26 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x26 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x26 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x26 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x26 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x28 "PCR199,Pad Configuration Register 199"
  bitfld.word 0x28 10.--12.       "PA , Pin assignment" "GPIO,EMIOS20,res.,EMIOS20,res.,res.,res.,res.      "
  bitfld.word 0x28 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x28 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x28 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x28 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x28 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x28 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x28 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x2a "PCR200,Pad Configuration Register 200"
  bitfld.word 0x2a 10.--12.       "PA , Pin assignment" "GPIO,EMIOS21,res.,EMIOS21,res.,res.,res.,res.      "
  bitfld.word 0x2a 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x2a 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x2a 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x2a 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x2a 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x2a 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x2a 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x2c "PCR201,Pad Configuration Register 201"
  bitfld.word 0x2c 10.--12.       "PA , Pin assignment" "GPIO,EMIOS22,res.,EMIOS22,res.,res.,res.,res.      "
  bitfld.word 0x2c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x2c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x2c 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x2c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x2c 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x2c 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x2c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x2e "PCR202,Pad Configuration Register 202"
  bitfld.word 0x2e 10.--12.       "PA , Pin assignment" "GPIO,EMIOS23,res.,EMIOS23,res.,res.,res.,res.      "
  bitfld.word 0x2e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x2e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x2e 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x2e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x2e 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x2e 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x2e 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F901D6++0x09 "PCR203-207: GPIO / EMIOS[14:15]"
  line.word 0x00 "PCR203,Pad Configuration Register 203"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,EMIOS14,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR204,Pad Configuration Register 204"
  bitfld.word 0x02 10.--12.       "PA , Pin assignment" "GPIO,EMIOS15,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x02 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x04 "PCR205,Pad Configuration Register 205"
  bitfld.word 0x04 10.--12.       "PA , Pin assignment" "GPIO,res.,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x04 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x04 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x04 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x04 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x04 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x04 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x04 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x06 "PCR206,Pad Configuration Register 206"
  bitfld.word 0x06 10.--12.       "PA , Pin assignment" "GPIO,res.,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x06 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x06 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x06 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x06 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x06 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x06 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x06 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x08 "PCR207,Pad Configuration Register 207"
  bitfld.word 0x08 10.--12.       "PA , Pin assignment" "GPIO,res.,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x08 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x08 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x08 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x08 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x08 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x08 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x08 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F901E0++0x03 "PCR208-209: PLLCFG[0:1] / IRQ[4:5] / SOUTD"
  line.word 0x00 "PCR208,Pad Configuration Register 208"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,PLLCFG0,IRQ04,PLLCFG0,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR209,Pad Configuration Register 209"
  bitfld.word 0x02 10.--12.       "PA , Pin assignment" "GPIO,PLLCFG1,IRQ05,PLLCFG1,SOUTD,res.,res.,res.      "
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x02 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F901E4++0x01 "PCR210: !RSCFG"
  line.word 0x00 "PCR210,Pad Configuration Register 210"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,!RSCFG,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F901E6++0x03 "PCR211-212: BOOTCFG[0:1] / IRQ[2:3]"
  line.word 0x00 "PCR211,Pad Configuration Register 211"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,BOOTCFG0,IRQ02,BOOTCFG0,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR212,Pad Configuration Register 212"
  bitfld.word 0x02 10.--12.       "PA , Pin assignment" "GPIO,BOOTCFG1,IRQ03,BOOTCFG0,res.,res.,res.,res.      "
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x02 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F901EA++0x01 "PCR213: WKPCFG"
  line.word 0x00 "PCR213,Pad Configuration Register 213"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,WKPCFG,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F901EC++0x01 "PCR214: ENGCLK"
  line.word 0x00 "PCR214,Pad Configuration Register 214"

; bitfld.word 0x00 10.--13.       "PA , Pin assignment" "   0,   1,   2,   3,   4,   5,   6,   7,   8,   9,   A,   B,   C,   D,   E,   F"
  bitfld.word 0x00 09.            "         OBE , Output buffer enable" "0,1"
; bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "         DSC , Drive strength control" "10pF,20pF,30pF,50pF"
; bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
; bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
; bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
; bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
; bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

group 0xC3F901EE++0x01 "PCR215: AN12 / MA0 / !SDS"
  line.word 0x00 "PCR215,Pad Configuration Register 215"

  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "!SDS,res.,MA0,AN12,res.,res.,res.,res.      "
;  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
;  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
; bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
;  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
;  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
;  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F901F0++0x01 "PCR216: AN13 / MA1 / SDO"
  line.word 0x00 "PCR216,Pad Configuration Register 216"

  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "SDO,res.,MA1,AN13,res.,res.,res.,res.      "
;  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
;  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
; bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
;  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
;  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
;  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F901F2++0x01 "PCR217: AN14 / MA2 / SDI"
  line.word 0x00 "PCR217,Pad Configuration Register 217"

  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "SDI,res.,MA2,AN14,res.,res.,res.,res.      "
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F901F4++0x01 "PCR218: AN15 / FCK"
  line.word 0x00 "PCR218,Pad Configuration Register 218"

  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "FCK,AN15,res.,res.,res.,res.,res.,res.      "
;  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
;  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
; bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
;  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
;  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
;  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F901F6++0x01 "PCR219: MCKO"
  line.word 0x00 "PCR219,Pad Configuration Register 219"

;  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "   0,   1,   2,   3,   4,   5,   6,   7,   8,   9,   A,   B,   C,   D,   E,   F"
;  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
;  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "                       DSC , Drive strength control" "10pF,20pF,30pF,50pF"
;  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
;  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
;  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
;  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
;  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

group 0xC3F901F8++0x09 "PCR220-223: MDO[0:3]"
  line.word 0x00 "PCR220,Pad Configuration Register 220"

;  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "   0,   1,   2,   3,   4,   5,   6,   7,   8,   9,   A,   B,   C,   D,   E,   F"
;  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
;  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "                       DSC , Drive strength control" "10pF,20pF,30pF,50pF"
;  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
;  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
;  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
;  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
;  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"
  line.word 0x02 "PCR221,Pad Configuration Register 221"

;  bitfld.word 0x02 10.--13.       "PA , Pin assignment" "   0,   1,   2,   3,   4,   5,   6,   7,   8,   9,   A,   B,   C,   D,   E,   F"
;  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
;  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 06.--07.       "                       DSC , Drive strength control" "10pF,20pF,30pF,50pF"
;  bitfld.word 0x02 05.            "  ODE , Open drain output enable" "0,1"
;  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
;  bitfld.word 0x02 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
;  bitfld.word 0x02 01.            "  WPE , Weak pull up/down enable" "0,1"
;  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"
  line.word 0x04 "PCR222,Pad Configuration Register 222"

;  bitfld.word 0x04 10.--13.       "PA , Pin assignment" "   0,   1,   2,   3,   4,   5,   6,   7,   8,   9,   A,   B,   C,   D,   E,   F"
;  bitfld.word 0x04 09.            "  OBE , Output buffer enable" "0,1"
;  bitfld.word 0x04 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x04 06.--07.       "                       DSC , Drive strength control" "10pF,20pF,30pF,50pF"
;  bitfld.word 0x04 05.            "  ODE , Open drain output enable" "0,1"
;  bitfld.word 0x04 04.            "  HYS , Input hysteresis" "0,1"
;  bitfld.word 0x04 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
;  bitfld.word 0x04 01.            "  WPE , Weak pull up/down enable" "0,1"
;  bitfld.word 0x04 00.            "  WPS , Weak pull up/down select" "0,1"
  line.word 0x06 "PCR223,Pad Configuration Register 223"

;  bitfld.word 0x06 10.--13.       "PA , Pin assignment" "   0,   1,   2,   3,   4,   5,   6,   7,   8,   9,   A,   B,   C,   D,   E,   F"
;  bitfld.word 0x06 09.            "  OBE , Output buffer enable" "0,1"
;  bitfld.word 0x06 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x06 06.--07.       "                       DSC , Drive strength control" "10pF,20pF,30pF,50pF"
;  bitfld.word 0x06 05.            "  ODE , Open drain output enable" "0,1"
;  bitfld.word 0x06 04.            "  HYS , Input hysteresis" "0,1"
;  bitfld.word 0x06 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
;  bitfld.word 0x06 01.            "  WPE , Weak pull up/down enable" "0,1"
;  bitfld.word 0x06 00.            "  WPS , Weak pull up/down select" "0,1"

group 0xC3F90200++0x03 "PCR224-225: !MSEO[0:1]"
  line.word 0x00 "PCR224,Pad Configuration Register 224"

;  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "   0,   1,   2,   3,   4,   5,   6,   7,   8,   9,   A,   B,   C,   D,   E,   F"
;  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
;  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "                       DSC , Drive strength control" "10pF,20pF,30pF,50pF"
;  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
;  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
;  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
;  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
;  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"
  line.word 0x02 "PCR225,Pad Configuration Register 225"

;  bitfld.word 0x02 10.--13.       "PA , Pin assignment" "   0,   1,   2,   3,   4,   5,   6,   7,   8,   9,   A,   B,   C,   D,   E,   F"
;  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
;  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 06.--07.       "                       DSC , Drive strength control" "10pF,20pF,30pF,50pF"
;  bitfld.word 0x02 05.            "  ODE , Open drain output enable" "0,1"
;  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
;  bitfld.word 0x02 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
;  bitfld.word 0x02 01.            "  WPE , Weak pull up/down enable" "0,1"
;  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"

group 0xC3F90204++0x01 "PCR226: !RDY"
  line.word 0x00 "PCR226,Pad Configuration Register 226"

;  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "   0,   1,   2,   3,   4,   5,   6,   7,   8,   9,   A,   B,   C,   D,   E,   F"
;  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
;  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "                       DSC , Drive strength control" "10pF,20pF,30pF,50pF"
;  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
;  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
;  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
;  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
;  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

group 0xC3F90206++0x01 "PCR227: !EVTO"
  line.word 0x00 "PCR227,Pad Configuration Register 227"

;  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "   0,   1,   2,   3,   4,   5,   6,   7,   8,   9,   A,   B,   C,   D,   E,   F"
;  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
;  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "                       DSC , Drive strength control" "10pF,20pF,30pF,50pF"
;  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
;  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
;  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
;  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
;  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

group 0xC3F90208++0x01 "PCR228: TDO"
  line.word 0x00 "PCR228,Pad Configuration Register 228"

;  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "   0,   1,   2,   3,   4,   5,   6,   7,   8,   9,   A,   B,   C,   D,   E,   F"
;  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
;  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "                       DSC , Drive strength control" "10pF,20pF,30pF,50pF"
;  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
;  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
;  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
;  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
;  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

group 0xC3F9020A++0x01 "PCR229: !CLKOUT"
  line.word 0x00 "PCR229,Pad Configuration Register 229"

; bitfld.word 0x00 10.--13.       "PA , Pin assignment" "   0,   1,   2,   3,   4,   5,   6,   7,   8,   9,   A,   B,   C,   D,   E,   F"
  bitfld.word 0x00 09.            "         OBE , Output buffer enable" "0,1"
; bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "         DSC , Drive strength control" "10pF,20pF,30pF,50pF"
; bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
; bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
; bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
; bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
; bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

group 0xC3F9020C++0x01 "PCR230: !RSTOUT"
  line.word 0x00 "PCR230,Pad Configuration Register 230"

;  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "   0,   1,   2,   3,   4,   5,   6,   7,   8,   9,   A,   B,   C,   D,   E,   F"
;  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
;  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
;  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
;  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
;  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "                                               SRC , Slew rate control" "Min,Med,res,Max"
;  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
;  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

;calibration pins

group 0xC3F90240++0x01 "PCR256: CAL_CS0"
  line.word 0x00 "PCR256,Pad Configuration Register 256"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "res.,CAL_CS0,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90242++0x03 "PCR257-258: CAL_CS[2:3] / CAL_ADDR[10:11]"
  line.word 0x00 "PCR257,Pad Configuration Register 257"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "res.,CAL_CS2,CAL_ADDR10,CAL_CS2,res.,res.,res.,res."
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR258,Pad Configuration Register 258"
  bitfld.word 0x02 10.--12.       "PA , Pin assignment" "res.,CAL_CS3,CAL_ADDR11,CAL_CS3,res.,res.,res.,res."
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x02 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90246++0x25 "PCR259-277: CAL_ADDR[12:30]"
  line.word 0x00 "PCR259,Pad Configuration Register 259"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "res.,CAL_ADDR12,res.,CAL_ADDR12,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR260,Pad Configuration Register 260"
  bitfld.word 0x02 10.--12.       "PA , Pin assignment" "res.,CAL_ADDR13,res.,CAL_ADDR13,res.,res.,res.,res.      "
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x02 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x04 "PCR261,Pad Configuration Register 261"
  bitfld.word 0x04 10.--12.       "PA , Pin assignment" "res.,CAL_ADDR14,res.,CAL_ADDR14,res.,res.,res.,res.      "
  bitfld.word 0x04 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x04 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x04 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x04 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x04 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x04 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x04 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x06 "PCR262,Pad Configuration Register 262"
  bitfld.word 0x06 10.--12.       "PA , Pin assignment" "res.,CAL_ADDR15,res.,CAL_ADDR15,res.,res.,res.,res.      "
  bitfld.word 0x06 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x06 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x06 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x06 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x06 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x06 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x06 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x08 "PCR263,Pad Configuration Register 263"
  bitfld.word 0x08 10.--12.       "PA , Pin assignment" "res.,CAL_ADDR16,res.,CAL_ADDR16,res.,res.,res.,res.      "
  bitfld.word 0x08 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x08 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x08 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x08 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x08 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x08 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x08 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0a "PCR264,Pad Configuration Register 264"
  bitfld.word 0x0a 10.--12.       "PA , Pin assignment" "res.,CAL_ADDR17,res.,CAL_ADDR17,res.,res.,res.,res.      "
  bitfld.word 0x0a 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0a 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0a 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x0a 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x0a 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0a 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0a 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0c "PCR265,Pad Configuration Register 265"
  bitfld.word 0x0c 10.--12.       "PA , Pin assignment" "res.,CAL_ADDR18,res.,CAL_ADDR18,res.,res.,res.,res.      "
  bitfld.word 0x0c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0c 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x0c 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x0c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0c 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0e "PCR266,Pad Configuration Register 266"
  bitfld.word 0x0e 10.--12.       "PA , Pin assignment" "res.,CAL_ADDR19,res.,CAL_ADDR19,res.,res.,res.,res.      "
  bitfld.word 0x0e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0e 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x0e 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x0e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0e 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0e 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x10 "PCR267,Pad Configuration Register 267"
  bitfld.word 0x10 10.--12.       "PA , Pin assignment" "res.,CAL_ADDR20,res.,CAL_ADDR20,res.,res.,res.,res.      "
  bitfld.word 0x10 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x10 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x10 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x10 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x10 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x10 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x10 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x12 "PCR268,Pad Configuration Register 268"
  bitfld.word 0x12 10.--12.       "PA , Pin assignment" "res.,CAL_ADDR21,res.,CAL_ADDR21,res.,res.,res.,res.      "
  bitfld.word 0x12 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x12 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x12 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x12 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x12 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x12 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x12 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x14 "PCR269,Pad Configuration Register 269"
  bitfld.word 0x14 10.--12.       "PA , Pin assignment" "res.,CAL_ADDR22,res.,CAL_ADDR22,res.,res.,res.,res.      "
  bitfld.word 0x14 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x14 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x14 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x14 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x14 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x14 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x14 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x16 "PCR270,Pad Configuration Register 270"
  bitfld.word 0x16 10.--12.       "PA , Pin assignment" "res.,CAL_ADDR23,res.,CAL_ADDR23,res.,res.,res.,res.      "
  bitfld.word 0x16 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x16 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x16 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x16 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x16 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x16 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x16 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x18 "PCR271,Pad Configuration Register 271"
  bitfld.word 0x18 10.--12.       "PA , Pin assignment" "res.,CAL_ADDR24,res.,CAL_ADDR24,res.,res.,res.,res.      "
  bitfld.word 0x18 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x18 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x18 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x18 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x18 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x18 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x18 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x1a "PCR272,Pad Configuration Register 272"
  bitfld.word 0x1a 10.--12.       "PA , Pin assignment" "res.,CAL_ADDR25,res.,CAL_ADDR25,res.,res.,res.,res.      "
  bitfld.word 0x1a 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x1a 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x1a 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x1a 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x1a 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x1a 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x1a 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x1c "PCR273,Pad Configuration Register 273"
  bitfld.word 0x1c 10.--12.       "PA , Pin assignment" "res.,CAL_ADDR26,res.,CAL_ADDR26,res.,res.,res.,res.      "
  bitfld.word 0x1c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x1c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x1c 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x1c 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x1c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x1c 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x1c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x1e "PCR274,Pad Configuration Register 274"
  bitfld.word 0x1e 10.--12.       "PA , Pin assignment" "res.,CAL_ADDR27,res.,CAL_ADDR27,res.,res.,res.,res.      "
  bitfld.word 0x1e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x1e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x1e 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x1e 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x1e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x1e 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x1e 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x20 "PCR275,Pad Configuration Register 275"
  bitfld.word 0x20 10.--12.       "PA , Pin assignment" "res.,CAL_ADDR28,res.,CAL_ADDR28,res.,res.,res.,res.      "
  bitfld.word 0x20 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x20 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x20 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x20 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x20 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x20 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x20 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x22 "PCR276,Pad Configuration Register 276"
  bitfld.word 0x22 10.--12.       "PA , Pin assignment" "res.,CAL_ADDR29,res.,CAL_ADDR29,res.,res.,res.,res.      "
  bitfld.word 0x22 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x22 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x22 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x22 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x22 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x22 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x22 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x24 "PCR277,Pad Configuration Register 277"
  bitfld.word 0x24 10.--12.       "PA , Pin assignment" "res.,CAL_ADDR30,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x24 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x24 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x24 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x24 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x24 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x24 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x24 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F9026C++0x1f "PCR278-293: CAL_DATA[0:15]"
  line.word 0x00 "PCR278,Pad Configuration Register 278"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "res.,CAL_DATA00,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR279,Pad Configuration Register 279"
  bitfld.word 0x02 10.--12.       "PA , Pin assignment" "res.,CAL_DATA01,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x02 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x04 "PCR280,Pad Configuration Register 280"
  bitfld.word 0x04 10.--12.       "PA , Pin assignment" "res.,CAL_DATA02,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x04 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x04 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x04 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x04 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x04 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x04 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x04 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x06 "PCR281,Pad Configuration Register 281"
  bitfld.word 0x06 10.--12.       "PA , Pin assignment" "res.,CAL_DATA03,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x06 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x06 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x06 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x06 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x06 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x06 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x06 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x08 "PCR282,Pad Configuration Register 282"
  bitfld.word 0x08 10.--12.       "PA , Pin assignment" "res.,CAL_DATA04,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x08 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x08 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x08 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x08 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x08 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x08 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x08 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0a "PCR283,Pad Configuration Register 283"
  bitfld.word 0x0a 10.--12.       "PA , Pin assignment" "res.,CAL_DATA05,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x0a 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0a 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0a 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x0a 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x0a 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0a 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0a 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0c "PCR284,Pad Configuration Register 284"
  bitfld.word 0x0c 10.--12.       "PA , Pin assignment" "res.,CAL_DATA06,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x0c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0c 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x0c 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x0c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0c 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0e "PCR285,Pad Configuration Register 285"
  bitfld.word 0x0e 10.--12.       "PA , Pin assignment" "res.,CAL_DATA07,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x0e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0e 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x0e 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x0e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0e 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0e 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x10 "PCR286,Pad Configuration Register 286"
  bitfld.word 0x10 10.--12.       "PA , Pin assignment" "res.,CAL_DATA08,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x10 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x10 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x10 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x10 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x10 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x10 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x10 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x12 "PCR287,Pad Configuration Register 287"
  bitfld.word 0x12 10.--12.       "PA , Pin assignment" "res.,CAL_DATA09,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x12 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x12 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x12 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x12 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x12 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x12 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x12 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x14 "PCR288,Pad Configuration Register 288"
  bitfld.word 0x14 10.--12.       "PA , Pin assignment" "res.,CAL_DATA10,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x14 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x14 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x14 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x14 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x14 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x14 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x14 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x16 "PCR289,Pad Configuration Register 289"
  bitfld.word 0x16 10.--12.       "PA , Pin assignment" "res.,CAL_DATA11,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x16 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x16 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x16 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x16 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x16 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x16 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x16 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x18 "PCR290,Pad Configuration Register 290"
  bitfld.word 0x18 10.--12.       "PA , Pin assignment" "res.,CAL_DATA12,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x18 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x18 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x18 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x18 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x18 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x18 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x18 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x1a "PCR291,Pad Configuration Register 291"
  bitfld.word 0x1a 10.--12.       "PA , Pin assignment" "res.,CAL_DATA13,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x1a 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x1a 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x1a 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x1a 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x1a 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x1a 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x1a 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x1c "PCR292,Pad Configuration Register 292"
  bitfld.word 0x1c 10.--12.       "PA , Pin assignment" "res.,CAL_DATA14,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x1c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x1c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x1c 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x1c 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x1c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x1c 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x1c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x1e "PCR293,Pad Configuration Register 293"
  bitfld.word 0x1e 10.--12.       "PA , Pin assignment" "res.,CAL_DATA15,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x1e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x1e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x1e 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x1e 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x1e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x1e 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x1e 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F9028C++0x09 "PCR294-298: CAL_RD_WR, CAL_WE[0:1], CAL_OE, CAL_TS"
  line.word 0x00 "PCR294,Pad Configuration Register 294"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "res.,CAL_RD_WR,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR295,Pad Configuration Register 295"
  bitfld.word 0x02 10.--12.       "PA , Pin assignment" "res.,CAL_WEBE0,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x02 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x04 "PCR296,Pad Configuration Register 296"
  bitfld.word 0x04 10.--12.       "PA , Pin assignment" "res.,CAL_WEBE1,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x04 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x04 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x04 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x04 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x04 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x04 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x04 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x06 "PCR297,Pad Configuration Register 297"
  bitfld.word 0x06 10.--12.       "PA , Pin assignment" "res.,CAL_OE,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x06 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x06 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x06 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x06 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x06 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x06 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x06 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x08 "PCR298,Pad Configuration Register 298"
  bitfld.word 0x08 10.--12.       "PA , Pin assignment" "res.,CAL_TS,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x08 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x08 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x08 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x08 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x08 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x08 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x08 00.            "  WPS , Weak pull up/down select" "0,1"




endif

sif (CPU()=="MPC5567")
group 0xC3F90040++0x07 "PCR000-PCR003: !CS[0:3] / ADDR[8:11]"
  line.word 0x00 "PCR000,Pad Configuration Register 000"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPI0,!CS0,ADDR08,!CS0,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR001,Pad Configuration Register 001"
  bitfld.word 0x02 10.--12.       "PA , Pin assignment" "GPI0,!CS1,ADDR09,!CS1,res.,res.,res.,res.      "
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x02 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x04 "PCR002,Pad Configuration Register 002"
  bitfld.word 0x04 10.--12.       "PA , Pin assignment" "GPI0,!CS2,ADDR10,!CS2,res.,res.,res.,res.      "
  bitfld.word 0x04 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x04 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x04 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x04 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x04 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x04 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x04 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x06 "PCR003,Pad Configuration Register 003"
  bitfld.word 0x06 10.--12.       "PA , Pin assignment" "GPI0,!CS3,ADDR11,!CS3,res.,res.,res.,res.      "
  bitfld.word 0x06 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x06 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x06 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x06 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x06 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x06 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x06 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90048++0x2f "PCR004-PCR011: ADDR[8:15]"
  line.word 0x00 "PCR004,Pad Configuration Register 004"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,ADDR08,res.,ADDR08,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR005,Pad Configuration Register 005"
  bitfld.word 0x02 10.--12.       "PA , Pin assignment" "GPIO,ADDR09,res.,ADDR09,res.,res.,res.,res.      "
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x02 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x04 "PCR006,Pad Configuration Register 006"
  bitfld.word 0x04 10.--12.       "PA , Pin assignment" "GPIO,ADDR10,res.,ADDR10,res.,res.,res.,res.      "
  bitfld.word 0x04 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x04 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x04 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x04 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x04 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x04 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x04 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x06 "PCR007,Pad Configuration Register 007"
  bitfld.word 0x06 10.--12.       "PA , Pin assignment" "GPIO,ADDR11,res.,ADDR11,res.,res.,res.,res.      "
  bitfld.word 0x06 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x06 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x06 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x06 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x06 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x06 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x06 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x08 "PCR008,Pad Configuration Register 008"
  bitfld.word 0x08 10.--12.       "PA , Pin assignment" "GPIO,ADDR12,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x08 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x08 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x08 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x08 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x08 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x08 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x08 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0a "PCR009,Pad Configuration Register 009"
  bitfld.word 0x0a 10.--12.       "PA , Pin assignment" "GPIO,ADDR13,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x0a 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0a 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0a 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x0a 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x0a 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0a 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0a 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0c "PCR010,Pad Configuration Register 010"
  bitfld.word 0x0c 10.--12.       "PA , Pin assignment" "GPIO,ADDR14,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x0c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0c 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x0c 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x0c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0c 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0e "PCR011,Pad Configuration Register 011"
  bitfld.word 0x0e 10.--12.       "PA , Pin assignment" "GPIO,ADDR15,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x0e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0e 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x0e 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x0e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0e 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0e 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90048++0x2f "PCR012-PCR027: ADDR[16:31]"
  line.word 0x10 "PCR012,Pad Configuration Register 012"
  bitfld.word 0x10 10.--12.       "PA , Pin assignment" "GPIO,ADDR16,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x10 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x10 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x10 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x10 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x10 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x10 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x10 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x12 "PCR013,Pad Configuration Register 013"
  bitfld.word 0x12 10.--12.       "PA , Pin assignment" "GPIO,ADDR17,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x12 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x12 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x12 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x12 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x12 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x12 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x12 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x14 "PCR014,Pad Configuration Register 014"
  bitfld.word 0x14 10.--12.       "PA , Pin assignment" "GPIO,ADDR18,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x14 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x14 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x14 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x14 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x14 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x14 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x14 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x16 "PCR015,Pad Configuration Register 015"
  bitfld.word 0x16 10.--12.       "PA , Pin assignment" "GPIO,ADDR19,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x16 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x16 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x16 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x16 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x16 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x16 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x16 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x18 "PCR016,Pad Configuration Register 016"
  bitfld.word 0x18 10.--12.       "PA , Pin assignment" "GPIO,ADDR20,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x18 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x18 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x18 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x18 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x18 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x18 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x18 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x1A "PCR017,Pad Configuration Register 017"
  bitfld.word 0x1A 10.--12.       "PA , Pin assignment" "GPIO,ADDR21,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x1A 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x1A 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x1A 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x1A 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x1A 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x1A 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x1A 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x1C "PCR018,Pad Configuration Register 018"
  bitfld.word 0x1C 10.--12.       "PA , Pin assignment" "GPIO,ADDR22,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x1C 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x1C 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x1C 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x1C 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x1C 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x1C 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x1C 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x1E "PCR019,Pad Configuration Register 019"
  bitfld.word 0x1E 10.--12.       "PA , Pin assignment" "GPIO,ADDR23,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x1E 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x1E 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x1E 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x1E 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x1E 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x1E 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x1E 00.            "  WPS , Weak pull up/down select" "0,1"

TEXTLINE ""
  line.word 0x20 "PCR020,Pad Configuration Register 020"
  bitfld.word 0x20 10.--12.       "PA , Pin assignment" "GPIO,ADDR24,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x20 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x20 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x20 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x20 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x20 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x20 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x20 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x22 "PCR021,Pad Configuration Register 021"
  bitfld.word 0x22 10.--12.       "PA , Pin assignment" "GPIO,ADDR25,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x22 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x22 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x22 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x22 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x22 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x22 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x22 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x24 "PCR022,Pad Configuration Register 022"
  bitfld.word 0x24 10.--12.       "PA , Pin assignment" "GPIO,ADDR26,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x24 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x24 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x24 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x24 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x24 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x24 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x24 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x26 "PCR023,Pad Configuration Register 023"
  bitfld.word 0x26 10.--12.       "PA , Pin assignment" "GPIO,ADDR27,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x26 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x26 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x26 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x26 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x26 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x26 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x26 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x28 "PCR024,Pad Configuration Register 024"
  bitfld.word 0x28 10.--12.       "PA , Pin assignment" "GPIO,ADDR28,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x28 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x28 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x28 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x28 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x28 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x28 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x28 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x2a "PCR025,Pad Configuration Register 025"
  bitfld.word 0x2a 10.--12.       "PA , Pin assignment" "GPIO,ADDR29,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x2a 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x2a 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x2a 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x2a 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x2a 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x2a 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x2a 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x2c "PCR026,Pad Configuration Register 026"
  bitfld.word 0x2c 10.--12.       "PA , Pin assignment" "GPIO,ADDR30,ADDR06,ADDR30,res.,res.,res.,res.      "
  bitfld.word 0x2c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x2c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x2c 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x2c 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x2c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x2c 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x2c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x2e "PCR027,Pad Configuration Register 027"
  bitfld.word 0x2e 10.--12.       "PA , Pin assignment" "GPIO,ADDR31,ADDR07,ADDR31,res.,res.,res.,res.      "
  bitfld.word 0x2e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x2e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x2e 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x2e 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x2e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x2e 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x2e 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90078++0x3f "PCR028-PCR043: DATA[0:15]"
  line.word 0x00 "PCR028,Pad Configuration Register 028"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,DATA00,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR029,Pad Configuration Register 029"
  bitfld.word 0x02 10.--12.       "PA , Pin assignment" "GPIO,DATA01,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x02 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x04 "PCR030,Pad Configuration Register 030"
  bitfld.word 0x04 10.--12.       "PA , Pin assignment" "GPIO,DATA02,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x04 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x04 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x04 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x04 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x04 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x04 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x04 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x06 "PCR031,Pad Configuration Register 031"
  bitfld.word 0x06 10.--12.       "PA , Pin assignment" "GPIO,DATA03,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x06 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x06 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x06 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x06 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x06 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x06 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x06 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x08 "PCR032,Pad Configuration Register 032"
  bitfld.word 0x08 10.--12.       "PA , Pin assignment" "GPIO,DATA04,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x08 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x08 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x08 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x08 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x08 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x08 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x08 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0a "PCR033,Pad Configuration Register 033"
  bitfld.word 0x0a 10.--12.       "PA , Pin assignment" "GPIO,DATA05,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x0a 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0a 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0a 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x0a 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x0a 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0a 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0a 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0c "PCR034,Pad Configuration Register 034"
  bitfld.word 0x0c 10.--12.       "PA , Pin assignment" "GPIO,DATA06,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x0c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0c 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x0c 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x0c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0c 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0e "PCR035,Pad Configuration Register 035"
  bitfld.word 0x0e 10.--12.       "PA , Pin assignment" "GPIO,DATA07,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x0e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0e 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x0e 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x0e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0e 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0e 00.            "  WPS , Weak pull up/down select" "0,1"

TEXTLINE ""
  line.word 0x10 "PCR036,Pad Configuration Register 036"
  bitfld.word 0x10 10.--12.       "PA , Pin assignment" "GPIO,DATA08,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x10 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x10 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x10 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x10 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x10 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x10 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x10 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x12 "PCR037,Pad Configuration Register 037"
  bitfld.word 0x12 10.--12.       "PA , Pin assignment" "GPIO,DATA09,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x12 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x12 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x12 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x12 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x12 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x12 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x12 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x14 "PCR038,Pad Configuration Register 038"
  bitfld.word 0x14 10.--12.       "PA , Pin assignment" "GPIO,DATA10,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x14 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x14 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x14 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x14 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x14 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x14 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x14 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x16 "PCR039,Pad Configuration Register 039"
  bitfld.word 0x16 10.--12.       "PA , Pin assignment" "GPIO,DATA11,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x16 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x16 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x16 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x16 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x16 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x16 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x16 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x18 "PCR040,Pad Configuration Register 040"
  bitfld.word 0x18 10.--12.       "PA , Pin assignment" "GPIO,DATA12,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x18 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x18 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x18 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x18 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x18 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x18 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x18 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x1A "PCR041,Pad Configuration Register 041"
  bitfld.word 0x1A 10.--12.       "PA , Pin assignment" "GPIO,DATA13,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x1A 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x1A 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x1A 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x1A 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x1A 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x1A 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x1A 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x1c "PCR042,Pad Configuration Register 042"
  bitfld.word 0x1c 10.--12.       "PA , Pin assignment" "GPIO,DATA14,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x1c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x1c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x1c 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x1c 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x1c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x1c 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x1c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x1e "PCR043,Pad Configuration Register 043"
  bitfld.word 0x1e 10.--12.       "PA , Pin assignment" "GPIO,DATA15,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x1e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x1e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x1e 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x1e 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x1e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x1e 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x1e 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90078++0x3f "PCR044-PCR059: DATA[16:31] / FR_A / FR_B"
  line.word 0x20 "PCR044,Pad Configuration Register 044"
  bitfld.word 0x20 10.--12.       "PA , Pin assignment" "GPIO,DATA16,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x20 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x20 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x20 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x20 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x20 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x20 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x20 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x22 "PCR045,Pad Configuration Register 045"
  bitfld.word 0x22 10.--12.       "PA , Pin assignment" "GPIO,DATA17,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x22 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x22 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x22 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x22 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x22 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x22 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x22 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x24 "PCR046,Pad Configuration Register 046"
  bitfld.word 0x24 10.--12.       "PA , Pin assignment" "GPIO,DATA18,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x24 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x24 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x24 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x24 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x24 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x24 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x24 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x26 "PCR047,Pad Configuration Register 047"
  bitfld.word 0x26 10.--12.       "PA , Pin assignment" "GPIO,DATA19,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x26 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x26 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x26 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x26 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x26 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x26 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x26 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x28 "PCR048,Pad Configuration Register 048"
  bitfld.word 0x28 10.--12.       "PA , Pin assignment" "GPIO,DATA20,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x28 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x28 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x28 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x28 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x28 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x28 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x28 00.            "  WPS , Weak pull up/down select" "0,1"


  line.word 0x2a "PCR049,Pad Configuration Register 049"
  bitfld.word 0x2a 10.--12.       "PA , Pin assignment" "GPIO,DATA21,FR_A_TX,DATA21,res.,res.,res.,res.      "
  bitfld.word 0x2a 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x2a 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x2a 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x2a 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x2a 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x2a 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x2a 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x2c "PCR050,Pad Configuration Register 050"
  bitfld.word 0x2c 10.--12.       "PA , Pin assignment" "GPIO,DATA22,FR_A_RX,DATA22,res.,res.,res.,res.      "
  bitfld.word 0x2c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x2c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x2c 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x2c 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x2c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x2c 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x2c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x2e "PCR051,Pad Configuration Register 051"
  bitfld.word 0x2e 10.--12.       "PA , Pin assignment" "GPIO,DATA23,FR_A_TXEN,DATA23,res.,res.,res.,res.      "
  bitfld.word 0x2e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x2e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x2e 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x2e 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x2e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x2e 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x2e 00.            "  WPS , Weak pull up/down select" "0,1"

TEXTLINE ""
  line.word 0x30 "PCR052,Pad Configuration Register 052"
  bitfld.word 0x30 10.--12.       "PA , Pin assignment" "GPIO,DATA24,res.,DATA24,res.,res.,res.,res.      "
  bitfld.word 0x30 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x30 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x30 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x30 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x30 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x30 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x30 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x32 "PCR053,Pad Configuration Register 053"
  bitfld.word 0x32 10.--12.       "PA , Pin assignment" "GPIO,DATA25,FR_B_TX,DATA25,res.,res.,res.,res.      "
  bitfld.word 0x32 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x32 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x32 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x32 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x32 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x32 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x32 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x34 "PCR054,Pad Configuration Register 054"
  bitfld.word 0x34 10.--12.       "PA , Pin assignment" "GPIO,DATA26,FR_B_RX,DATA26,res.,res.,res.,res.      "
  bitfld.word 0x34 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x34 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x34 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x34 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x34 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x34 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x34 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x36 "PCR055,Pad Configuration Register 055"
  bitfld.word 0x36 10.--12.       "PA , Pin assignment" "GPIO,DATA27,FR_B_TXEN,DATA27,res.,res.,res.,res.      "
  bitfld.word 0x36 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x36 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x36 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x36 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x36 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x36 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x36 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x38 "PCR056,Pad Configuration Register 056"
  bitfld.word 0x38 10.--12.       "PA , Pin assignment" "GPIO,DATA28,res.,DATA28,res.,res.,res.,res.      "
  bitfld.word 0x38 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x38 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x38 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x38 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x38 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x38 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x38 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x3a "PCR057,Pad Configuration Register 057"
  bitfld.word 0x3a 10.--12.       "PA , Pin assignment" "GPIO,DATA29,res.,DATA29,res.,res.,res.,res.      "
  bitfld.word 0x3a 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x3a 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x3a 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x3a 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x3a 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x3a 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x3a 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x3c "PCR058,Pad Configuration Register 058"
  bitfld.word 0x3c 10.--12.       "PA , Pin assignment" "GPIO,DATA30,res.,DATA30,res.,res.,res.,res.      "
  bitfld.word 0x3c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x3c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x3c 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x3c 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x3c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x3c 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x3c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x3e "PCR059,Pad Configuration Register 059"
  bitfld.word 0x3e 10.--12.       "PA , Pin assignment" "GPIO,DATA31,res.,DATA31,res.,res.,res.,res.      "
  bitfld.word 0x3e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x3e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x3e 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x3e 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x3e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x3e 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x3e 00.            "  WPS , Weak pull up/down select" "0,1"



group 0xC3F900BC++0x01 "PCR062: RD/!WR"
  line.word 0x00 "PCR062,Pad Configuration Register 062"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,RD/!WR,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900BE++0x01 "PCR063: !BDIP"
  line.word 0x00 "PCR063,Pad Configuration Register 063"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,!BDIP,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900C0++0x07 "PCR064-067: !WE_BE[0:3]"
  line.word 0x00 "PCR064,Pad Configuration Register 064"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,!WE0_BE0,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR065,Pad Configuration Register 065"
  bitfld.word 0x02 10.--12.       "PA , Pin assignment" "GPIO,!WE1_BE1,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x02 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x04 "PCR066,Pad Configuration Register 066"
  bitfld.word 0x04 10.--12.       "PA , Pin assignment" "GPIO,!WE2_BE2,res.,!WE2_BE2,res.,res.,res.,res.      "
  bitfld.word 0x04 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x04 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x04 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x04 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x04 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x04 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x04 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x06 "PCR067,Pad Configuration Register 067"
  bitfld.word 0x06 10.--12.       "PA , Pin assignment" "GPIO,!WE3_BE3,res.,!WE3_BE3,res.,res.,res.,res.      "
  bitfld.word 0x06 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x06 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x06 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x06 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x06 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x06 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x06 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900C8++0x01 "PCR068: !OE"
  line.word 0x00 "PCR068,Pad Configuration Register 068"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,!OE,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900CA++0x01 "PCR069: !TS"
  line.word 0x00 "PCR069,Pad Configuration Register 069"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,!TS,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900CC++0x01 "PCR070: !TA"
  line.word 0x00 "PCR070,Pad Configuration Register 070"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,!TA,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900CE++0x01 "PCR071: !TEA"
  line.word 0x00 "PCR071,Pad Configuration Register 071"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,!TEA,res.,!TEA,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900D0++0x01 "PCR072: GPIO"
  line.word 0x00 "PCR072,Pad Configuration Register 072"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,res.,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900D2++0x01 "PCR073: GPIO"
  line.word 0x00 "PCR073,Pad Configuration Register 073"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,res.,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900D6++0x0f "PCR075-PCR082: MDO[4:11]"
  line.word 0x00 "PCR075,Pad Configuration Register 075"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO/MDO04,res.,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR076,Pad Configuration Register 076"
  bitfld.word 0x02 10.--12.       "PA , Pin assignment" "GPIO/MDO05,res.,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x02 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x04 "PCR077,Pad Configuration Register 077"
  bitfld.word 0x04 10.--12.       "PA , Pin assignment" "GPIO/MDO06,res.,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x04 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x04 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x04 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x04 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x04 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x04 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x04 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x06 "PCR078,Pad Configuration Register 078"
  bitfld.word 0x06 10.--12.       "PA , Pin assignment" "GPIO/MDO07,res.,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x06 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x06 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x06 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x06 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x06 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x06 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x06 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x08 "PCR079,Pad Configuration Register 079"
  bitfld.word 0x08 10.--12.       "PA , Pin assignment" "GPIO/MDO08,res.,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x08 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x08 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x08 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x08 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x08 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x08 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x08 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0a "PCR080,Pad Configuration Register 080"
  bitfld.word 0x0a 10.--12.       "PA , Pin assignment" "GPIO/MDO09,res.,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x0a 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0a 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0a 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x0a 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x0a 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0a 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0a 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0c "PCR081,Pad Configuration Register 081"
  bitfld.word 0x0c 10.--12.       "PA , Pin assignment" "GPIO/MDO10,res.,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x0c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0c 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x0c 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x0c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0c 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0e "PCR082,Pad Configuration Register 082"
  bitfld.word 0x0e 10.--12.       "PA , Pin assignment" "GPIO/MDO11,res.,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x0e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0e 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x0e 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x0e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0e 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0e 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900E6++0x01 "PCR083: CNTX_A / TXDA"
  line.word 0x00 "PCR083,Pad Configuration Register 083"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,CNTX_A,TXDA,CNTX_A,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900E8++0x01 "PCR084: CNRX_A / RXDA"
  line.word 0x00 "PCR084,Pad Configuration Register 084"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,CNRX_A,RXDA,CNRX_A,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900EA++0x01 "PCR085: CNTX_B / DSPI PCSC3 / FR_A_TX"
  line.word 0x00 "PCR085,Pad Configuration Register 085"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,CNTX_B,PCSC3,CNTX_B,FR_A_TX,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900EC++0x01 "PCR086: CNRX_B / DSPI PCSC4 / FR_A_RX"
  line.word 0x00 "PCR086,Pad Configuration Register 086"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,CNRX_B,PCSC4,CNRX_B,FR_A_RX,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900EE++0x01 "PCR087: CNTX_C / DSPI PCSD3"
  line.word 0x00 "PCR087,Pad Configuration Register 087"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,CNTX_C,PCSD3,CNTX_C,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900F0++0x01 "PCR088: CNRX_C / DSPI PCSD4"
  line.word 0x00 "PCR088,Pad Configuration Register 088"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,CNRX_C,PCSD4,CNRX_C,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900F2++0x01 "PCR089: TXD_A"
  line.word 0x00 "PCR089,Pad Configuration Register 089"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,TXD_A,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900F4++0x01 "PCR090: RXD_A"
  line.word 0x00 "PCR090,Pad Configuration Register 090"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,RXD_A,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900F6++0x01 "PCR091: TXD_B / DSPI PCSD1"
  line.word 0x00 "PCR091,Pad Configuration Register 091"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,TXD_B,PCSD1,TXD_B,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900F8++0x01 "PCR092: RXD_B / PCSD5"
  line.word 0x00 "PCR092,Pad Configuration Register 092"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,RXD_B,PCSD5,RXD_B,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900FA++0x01 "PCR093: DSPI PCSC1"
  line.word 0x00 "PCR093,Pad Configuration Register 093"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,res.,PCSC1,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900FC++0x01 "PCR094: DSPI PCSC2"
  line.word 0x00 "PCR094,Pad Configuration Register 094"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,res.,PCSC2,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900FE++0x01 "PCR095: DSPI PCSC5"
  line.word 0x00 "PCR095,Pad Configuration Register 095"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,res.,PCSC5,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90100++0x01 "PCR096: DSPI PCSD2"
  line.word 0x00 "PCR096,Pad Configuration Register 096"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,res.,PCSD2,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90102++0x01 "PCR097: PCSB2"
  line.word 0x00 "PCR097,Pad Configuration Register 097"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,res.,PCSB2,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90104++0x01 "PCR098: DSPI SCKD"
  line.word 0x00 "PCR098,Pad Configuration Register 098"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,res.,SCKD,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90106++0x01 "PCR099: DSPI SIN_D"
  line.word 0x00 "PCR099,Pad Configuration Register 099"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,res.,SIN_D,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90108++0x01 "PCR100: DSPI SOUTD"
  line.word 0x00 "PCR100,Pad Configuration Register 100"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,res.,SOUTD,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F9010a++0x01 "PCR101: DSPI PCSB3"
  line.word 0x00 "PCR101,Pad Configuration Register 101"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,res.,PCSB3,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F9010c++0x01 "PCR102: DSPI SCKB / DSPI PCSC1"
  line.word 0x00 "PCR102,Pad Configuration Register 102"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,SCKB,PCSC1,SCKB,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F9010e++0x01 "PCR103: DSPI SINB / DSPI PCSC2"
  line.word 0x00 "PCR103,Pad Configuration Register 103"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,SINB,PCSC2,SINB,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90110++0x01 "PCR104: DSPI SOUTB / DSPI PCSC5"
  line.word 0x00 "PCR104,Pad Configuration Register 104"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,SOUTB,PCSC5,SOUTB,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90112++0x01 "PCR105: DSPI PCSB0 / DSPI PCSD2"
  line.word 0x00 "PCR105,Pad Configuration Register 105"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,PCSB0,PCSD2,PCSB0,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90114++0x01 "PCR106: DSPI PCSB1 / DSPI PCSD0"
  line.word 0x00 "PCR106,Pad Configuration Register 106"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,PCSB1,PCSD0,PCSB1,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90116++0x01 "PCR107: DSPI PCSB2 / DSPI SOUTC"
  line.word 0x00 "PCR107,Pad Configuration Register 107"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,PCSB2,SOUTC,PCSB2,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90118++0x01 "PCR108: DSPI PCSB3 / DSPI SINC"
  line.word 0x00 "PCR108,Pad Configuration Register 108"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,PCSB3,SINC,PCSB3,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F9011A++0x01 "PCR109: DSPI PCSB4 / DSPI SCKC"
  line.word 0x00 "PCR109,Pad Configuration Register 109"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,PCSB4,SCKC,PCSB4,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F9011C++0x01 "PCR110: DSPI PCSB5 / DSPI PCSC0"
  line.word 0x00 "PCR110,Pad Configuration Register 110"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,PCSB5,PCSC0,PCSB5,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F9011E++0x03 "PCR111-112: ETRIG[0:1]"
  line.word 0x00 "PCR111,Pad Configuration Register 111"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,ETRIG0,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR112,Pad Configuration Register 112"
  bitfld.word 0x02 10.--12.       "PA , Pin assignment" "GPIO,ETRIG1,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x02 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90122++0x01 "PCR113: TCRCLKA / IRQ7"
  line.word 0x00 "PCR113,Pad Configuration Register 113"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,TCRCLKA,IRQ7,TCRCLKA,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90124++0x3F "PCR114-145: ETPUA[0:31] / ETPUA[12:23] / PCSB[1:4] / IRQ[8:15] / PCDC[1:4] / PCSD[1:4] / FR"
  line.word 0x00 "PCR114,Pad Configuration Register 114"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,ETPUA00,ETPUA12,ETPUA00,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR115,Pad Configuration Register 115"
  bitfld.word 0x02 10.--12.       "PA , Pin assignment" "GPIO,ETPUA01,ETPUA13,ETPUA01,res.,res.,res.,res.      "
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x02 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x04 "PCR116,Pad Configuration Register 116"
  bitfld.word 0x04 10.--12.       "PA , Pin assignment" "GPIO,ETPUA02,ETPUA14,ETPUA02,res.,res.,res.,res.      "
  bitfld.word 0x04 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x04 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x04 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x04 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x04 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x04 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x04 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x06 "PCR117,Pad Configuration Register 117"
  bitfld.word 0x06 10.--12.       "PA , Pin assignment" "GPIO,ETPUA03,ETPUA15,ETPUA03,res.,res.,res.,res.      "
  bitfld.word 0x06 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x06 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x06 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x06 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x06 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x06 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x06 00.            "  WPS , Weak pull up/down select" "0,1"


  line.word 0x08 "PCR118,Pad Configuration Register 118"
  bitfld.word 0x08 10.--12.       "PA , Pin assignment" "GPIO,ETPUA04,ETPUA16,ETPUA04,FR_B_TX,res.,res.,res.      "
  bitfld.word 0x08 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x08 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x08 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x08 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x08 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x08 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x08 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0a "PCR119,Pad Configuration Register 119"
  bitfld.word 0x0a 10.--12.       "PA , Pin assignment" "GPIO,ETPUA05,ETPUA17,ETPUA05,FR_B_TXEN,res.,res.,res.      "
  bitfld.word 0x0a 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0a 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0a 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x0a 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0a 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x0a 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0a 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0c "PCR120,Pad Configuration Register 120"
  bitfld.word 0x0c 10.--12.       "PA , Pin assignment" "GPIO,ETPUA06,ETPUA18,ETPUA06,FR_B_RX,res.,res.,res.      "
  bitfld.word 0x0c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0c 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x0c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0c 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x0c 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0e "PCR121,Pad Configuration Register 121"
  bitfld.word 0x0e 10.--12.       "PA , Pin assignment" "GPIO,ETPUA07,ETPUA19,ETPUA07,res.,res.,res.,res.      "
  bitfld.word 0x0e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0e 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x0e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0e 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x0e 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0e 00.            "  WPS , Weak pull up/down select" "0,1"

TEXTLINE "" 
  line.word 0x10 "PCR122,Pad Configuration Register 122"
  bitfld.word 0x10 10.--12.       "PA , Pin assignment" "GPIO,ETPUA08,ETPUA20,ETPUA08,res.,res.,res.,res.      "
  bitfld.word 0x10 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x10 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x10 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x10 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x10 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x10 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x10 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x12 "PCR123,Pad Configuration Register 123"
  bitfld.word 0x12 10.--12.       "PA , Pin assignment" "GPIO,ETPUA09,ETPUA21,ETPUA09,res.,res.,res.,res.      "
  bitfld.word 0x12 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x12 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x12 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x12 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x12 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x12 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x12 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x14 "PCR124,Pad Configuration Register 124"
  bitfld.word 0x14 10.--12.       "PA , Pin assignment" "GPIO,ETPUA10,ETPUA22,ETPUA10,res.,res.,res.,res.      "
  bitfld.word 0x14 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x14 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x14 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x14 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x14 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x14 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x14 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x16 "PCR125,Pad Configuration Register 125"
  bitfld.word 0x16 10.--12.       "PA , Pin assignment" "GPIO,ETPUA11,ETPUA23,ETPUA11,res.,res.,res.,res.      "
  bitfld.word 0x16 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x16 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x16 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x16 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x16 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x16 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x16 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x18 "PCR126,Pad Configuration Register 126"
  bitfld.word 0x18 10.--12.       "PA , Pin assignment" "GPIO,ETPUA12,PCSB1,ETPUA12,res.,res.,res.,res.      "
  bitfld.word 0x18 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x18 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x18 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x18 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x18 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x18 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x18 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x1A "PCR127,Pad Configuration Register 127"
  bitfld.word 0x1A 10.--12.       "PA , Pin assignment" "GPIO,ETPUA13,PCSB3,ETPUA13,res.,res.,res.,res.      "
  bitfld.word 0x1A 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x1A 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x1A 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x1A 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x1A 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x1A 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x1A 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x1c "PCR128,Pad Configuration Register 128"
  bitfld.word 0x1c 10.--12.       "PA , Pin assignment" "GPIO,ETPUA14,PCSB4,ETPUA14,res.,res.,res.,res.      "
  bitfld.word 0x1c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x1c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x1c 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x1c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x1c 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x1c 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x1c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x1e "PCR129,Pad Configuration Register 129"
  bitfld.word 0x1e 10.--12.       "PA , Pin assignment" "GPIO,ETPUA15,PCSB5,ETPUA15,res.,res.,res.,res.      "
  bitfld.word 0x1e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x1e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x1e 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x1e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x1e 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x1e 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x1e 00.            "  WPS , Weak pull up/down select" "0,1"

TEXTLINE ""
  line.word 0x20 "PCR130,Pad Configuration Register 130"
  bitfld.word 0x20 10.--12.       "PA , Pin assignment" "GPIO,ETPUA16,PCSD1,ETPUA16,res.,res.,res.,res.      "
  bitfld.word 0x20 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x20 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x20 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x20 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x20 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x20 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x20 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x22 "PCR131,Pad Configuration Register 131"
  bitfld.word 0x22 10.--12.       "PA , Pin assignment" "GPIO,ETPUA17,PCSD2,ETPUA17,res.,res.,res.,res.      "
  bitfld.word 0x22 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x22 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x22 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x22 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x22 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x22 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x22 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x24 "PCR132,Pad Configuration Register 132"
  bitfld.word 0x24 10.--12.       "PA , Pin assignment" "GPIO,ETPUA18,PCSD3,ETPUA18,res.,res.,res.,res.      "
  bitfld.word 0x24 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x24 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x24 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x24 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x24 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x24 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x24 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x26 "PCR133,Pad Configuration Register 133"
  bitfld.word 0x26 10.--12.       "PA , Pin assignment" "GPIO,ETPUA19,PCSD4,ETPUA19,res.,res.,res.,res.      "
  bitfld.word 0x26 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x26 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x26 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x26 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x26 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x26 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x26 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x28 "PCR134,Pad Configuration Register 134"
  bitfld.word 0x28 10.--12.       "PA , Pin assignment" "GPIO,ETPUA20,IRQ08,ETPUA20,FR_A_TX,res.,res.,res.      "
  bitfld.word 0x28 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x28 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x28 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x28 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x28 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x28 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x28 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x2a "PCR135,Pad Configuration Register 135"
  bitfld.word 0x2a 10.--12.       "PA , Pin assignment" "GPIO,ETPUA21,IRQ09,ETPUA21,FR_A_RX,res.,res.,res.      "
  bitfld.word 0x2a 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x2a 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x2a 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x2a 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x2a 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x2a 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x2a 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x2c "PCR136,Pad Configuration Register 136"
  bitfld.word 0x2c 10.--12.       "PA , Pin assignment" "GPIO,ETPUA22,IRQ10,ETPUA22,res.,res.,res.,res.      "
  bitfld.word 0x2c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x2c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x2c 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x2c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x2c 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x2c 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x2c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x2e "PCR137,Pad Configuration Register 137"
  bitfld.word 0x2e 10.--12.       "PA , Pin assignment" "GPIO,ETPUA23,IRQ11,ETPUA23,FR_A_TXEN,res.,res.,res.      "
  bitfld.word 0x2e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x2e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x2e 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x2e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x2e 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x2e 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x2e 00.            "  WPS , Weak pull up/down select" "0,1"

TEXTLINE ""
  line.word 0x30 "PCR138,Pad Configuration Register 138"
  bitfld.word 0x30 10.--12.       "PA , Pin assignment" "GPIO,ETPUA24,IRQ12,ETPUA24,res.,res.,res.,res.      "
  bitfld.word 0x30 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x30 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x30 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x30 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x30 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x30 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x30 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x32 "PCR139,Pad Configuration Register 139"
  bitfld.word 0x32 10.--12.       "PA , Pin assignment" "GPIO,ETPUA25,IRQ13,ETPUA25,res.,res.,res.,res.      "
  bitfld.word 0x32 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x32 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x32 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x32 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x32 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x32 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x32 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x34 "PCR140,Pad Configuration Register 140"
  bitfld.word 0x34 10.--12.       "PA , Pin assignment" "GPIO,ETPUA26,IRQ14,ETPUA26,res.,res.,res.,res.      "
  bitfld.word 0x34 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x34 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x34 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x34 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x34 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x34 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x34 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x36 "PCR141,Pad Configuration Register 141"
  bitfld.word 0x36 10.--12.       "PA , Pin assignment" "GPIO,ETPUA27,IRQ15,ETPUA27,res.,res.,res.,res.      "
  bitfld.word 0x36 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x36 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x36 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x36 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x36 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x36 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x36 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x38 "PCR142,Pad Configuration Register 142"
  bitfld.word 0x38 10.--12.       "PA , Pin assignment" "GPIO,ETPUA28,PCSC1,ETPUA28,res.,res.,res.,res.      "
  bitfld.word 0x38 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x38 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x38 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x38 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x38 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x38 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x38 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x3a "PCR143,Pad Configuration Register 143"
  bitfld.word 0x3a 10.--12.       "PA , Pin assignment" "GPIO,ETPUA29,PCSC2,ETPUA29,res.,res.,res.,res.      "
  bitfld.word 0x3a 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x3a 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x3a 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x3a 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x3a 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x3a 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x3a 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x3c "PCR144,Pad Configuration Register 144"
  bitfld.word 0x3c 10.--12.       "PA , Pin assignment" "GPIO,ETPUA30,PCSC3,ETPUA30,res.,res.,res.,res.      "
  bitfld.word 0x3c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x3c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x3c 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x3c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x3c 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x3c 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x3c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x3e "PCR145,Pad Configuration Register 145"
  bitfld.word 0x3e 10.--12.       "PA , Pin assignment" "GPIO,ETPUA31,PCSC4,ETPUA31,res.,res.,res.,res.      "
  bitfld.word 0x3e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x3e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x3e 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x3e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x3e 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x3e 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x3e 00.            "  WPS , Weak pull up/down select" "0,1"



group 0xC3F901A6++0x31 "PCR179-202: EMIOS[0:23] / ETPUA[0:9] / SOUTC / SOUTD / IRQ[0:1] / ETPUB[0:7]"
  line.word 0x00 "PCR179,Pad Configuration Register 179"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,EMIOS00,ETPUA00,EMIOS00,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR180,Pad Configuration Register 180"
  bitfld.word 0x02 10.--12.       "PA , Pin assignment" "GPIO,EMIOS01,ETPUA01,EMIOS01,res.,res.,res.,res.      "
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x02 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x04 "PCR181,Pad Configuration Register 181"
  bitfld.word 0x04 10.--12.       "PA , Pin assignment" "GPIO,EMIOS02,ETPUA02,EMIOS02,res.,res.,res.,res.      "
  bitfld.word 0x04 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x04 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x04 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x04 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x04 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x04 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x04 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x06 "PCR182,Pad Configuration Register 182"
  bitfld.word 0x06 10.--12.       "PA , Pin assignment" "GPIO,EMIOS03,ETPUA03,EMIOS03,res.,res.,res.,res.      "
  bitfld.word 0x06 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x06 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x06 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x06 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x06 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x06 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x06 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x08 "PCR183,Pad Configuration Register 183"
  bitfld.word 0x08 10.--12.       "PA , Pin assignment" "GPIO,EMIOS04,ETPUA04,EMIOS04,res.,res.,res.,res.      "
  bitfld.word 0x08 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x08 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x08 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x08 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x08 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x08 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x08 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0a "PCR184,Pad Configuration Register 184"
  bitfld.word 0x0a 10.--12.       "PA , Pin assignment" "GPIO,EMIOS05,ETPUA05,EMIOS05,res.,res.,res.,res.      "
  bitfld.word 0x0a 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0a 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0a 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x0a 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0a 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x0a 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0a 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0c "PCR185,Pad Configuration Register 185"
  bitfld.word 0x0c 10.--12.       "PA , Pin assignment" "GPIO,EMIOS06,ETPUA06,EMIOS06,res.,res.,res.,res.      "
  bitfld.word 0x0c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0c 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x0c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0c 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x0c 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0e "PCR186,Pad Configuration Register 186"
  bitfld.word 0x0e 10.--12.       "PA , Pin assignment" "GPIO,EMIOS07,ETPUA07,EMIOS07,res.,res.,res.,res.      "
  bitfld.word 0x0e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0e 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x0e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0e 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x0e 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0e 00.            "  WPS , Weak pull up/down select" "0,1"

TEXTLINE "" 
  line.word 0x10 "PCR187,Pad Configuration Register 187"
  bitfld.word 0x10 10.--12.       "PA , Pin assignment" "GPIO,EMIOS08,ETPUA08,EMIOS08,res.,res.,res.,res.      "
  bitfld.word 0x10 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x10 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x10 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x10 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x10 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x10 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x10 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x12 "PCR188,Pad Configuration Register 188"
  bitfld.word 0x12 10.--12.       "PA , Pin assignment" "GPIO,EMIOS09,ETPUA09,EMIOS09,res.,res.,res.,res.      "
  bitfld.word 0x12 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x12 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x12 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x12 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x12 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x12 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x12 00.            "  WPS , Weak pull up/down select" "0,1"


  line.word 0x14 "PCR189,Pad Configuration Register 189"
  bitfld.word 0x14 10.--12.       "PA , Pin assignment" "GPIO,EMIOS10,PCSD3,EMIOS10,res.,res.,res.,res.      "
  bitfld.word 0x14 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x14 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x14 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x14 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x14 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x14 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x14 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x16 "PCR190,Pad Configuration Register 190"
  bitfld.word 0x16 10.--12.       "PA , Pin assignment" "GPIO,EMIOS11,PCSD4,EMIOS11,res.,res.,res.,res.      "
  bitfld.word 0x16 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x16 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x16 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x16 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x16 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x16 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x16 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x18 "PCR191,Pad Configuration Register 191"
  bitfld.word 0x18 10.--12.       "PA , Pin assignment" "GPIO,EMIOS12,SOUTC,EMIOS12,res.,res.,res.,res.      "
  bitfld.word 0x18 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x18 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x18 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x18 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x18 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x18 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x18 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x1A "PCR192,Pad Configuration Register 192"
  bitfld.word 0x1A 10.--12.       "PA , Pin assignment" "GPIO,EMIOS13,SOUTD,EMIOS13,res.,res.,res.,res.      "
  bitfld.word 0x1A 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x1A 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x1A 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x1A 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x1A 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x1A 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x1A 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x1c "PCR193,Pad Configuration Register 193"
  bitfld.word 0x1c 10.--12.       "PA , Pin assignment" "GPIO,EMIOS14,IRQ00,EMIOS14,res.,res.,res.,res.      "
  bitfld.word 0x1c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x1c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x1c 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x1c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x1c 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x1c 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x1c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x1e "PCR194,Pad Configuration Register 194"
  bitfld.word 0x1e 10.--12.       "PA , Pin assignment" "GPIO,EMIOS15,IRQ01,EMIOS15,res.,res.,res.,res.      "
  bitfld.word 0x1e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x1e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x1e 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x1e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x1e 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x1e 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x1e 00.            "  WPS , Weak pull up/down select" "0,1"

TEXTLINE ""
  line.word 0x20 "PCR195,Pad Configuration Register 195"
  bitfld.word 0x20 10.--12.       "PA , Pin assignment" "GPIO,EMIOS16,FR_DBG0,EMIOS16,res.,res.,res.,res.      "
  bitfld.word 0x20 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x20 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x20 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x20 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x20 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x20 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x20 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x22 "PCR196,Pad Configuration Register 196"
  bitfld.word 0x22 10.--12.       "PA , Pin assignment" "GPIO,EMIOS17,FR_DBG1,EMIOS17,res.,res.,res.,res.      "
  bitfld.word 0x22 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x22 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x22 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x22 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x22 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x22 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x22 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x24 "PCR197,Pad Configuration Register 197"
  bitfld.word 0x24 10.--12.       "PA , Pin assignment" "GPIO,EMIOS18,FR_DBG2,EMIOS18,res.,res.,res.,res.      "
  bitfld.word 0x24 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x24 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x24 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x24 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x24 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x24 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x24 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x26 "PCR198,Pad Configuration Register 198"
  bitfld.word 0x26 10.--12.       "PA , Pin assignment" "GPIO,EMIOS19,FR_DBG3,EMIOS19,res.,res.,res.,res.      "
  bitfld.word 0x26 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x26 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x26 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x26 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x26 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x26 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x26 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x28 "PCR199,Pad Configuration Register 199"
  bitfld.word 0x28 10.--12.       "PA , Pin assignment" "GPIO,EMIOS20,res.,EMIOS20,res.,res.,res.,res.      "
  bitfld.word 0x28 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x28 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x28 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x28 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x28 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x28 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x28 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x2a "PCR200,Pad Configuration Register 200"
  bitfld.word 0x2a 10.--12.       "PA , Pin assignment" "GPIO,EMIOS21,res.,EMIOS21,res.,res.,res.,res.      "
  bitfld.word 0x2a 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x2a 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x2a 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x2a 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x2a 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x2a 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x2a 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x2c "PCR201,Pad Configuration Register 201"
  bitfld.word 0x2c 10.--12.       "PA , Pin assignment" "GPIO,EMIOS22,CNTXE,EMIOS22,res.,res.,res.,res.      "
  bitfld.word 0x2c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x2c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x2c 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x2c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x2c 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x2c 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x2c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x2e "PCR202,Pad Configuration Register 202"
  bitfld.word 0x2e 10.--12.       "PA , Pin assignment" "GPIO,EMIOS23,CNRXE,EMIOS23,res.,res.,res.,res.      "
  bitfld.word 0x2e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x2e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x2e 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x2e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x2e 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x2e 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x2e 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F901D6++0x09 "PCR203-207: GPIO / EMIOS[14:15]"
  line.word 0x00 "PCR203,Pad Configuration Register 203"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,EMIOS14,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR204,Pad Configuration Register 204"
  bitfld.word 0x02 10.--12.       "PA , Pin assignment" "GPIO,EMIOS15,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x02 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x04 "PCR205,Pad Configuration Register 205"
  bitfld.word 0x04 10.--12.       "PA , Pin assignment" "GPIO,res.,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x04 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x04 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x04 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x04 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x04 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x04 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x04 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x06 "PCR206,Pad Configuration Register 206"
  bitfld.word 0x06 10.--12.       "PA , Pin assignment" "GPIO,res.,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x06 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x06 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x06 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x06 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x06 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x06 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x06 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x08 "PCR207,Pad Configuration Register 207"
  bitfld.word 0x08 10.--12.       "PA , Pin assignment" "GPIO,res.,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x08 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x08 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x08 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x08 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x08 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x08 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x08 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F901E0++0x03 "PCR208-209: PLLCFG[0:1] / IRQ[4:5] / SOUTD"
  line.word 0x00 "PCR208,Pad Configuration Register 208"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,PLLCFG0,IRQ04,PLLCFG0,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR209,Pad Configuration Register 209"
  bitfld.word 0x02 10.--12.       "PA , Pin assignment" "GPIO,PLLCFG1,IRQ05,PLLCFG1,SOUTD,res.,res.,res.      "
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x02 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F901E4++0x01 "PCR210: !RSCFG"
  line.word 0x00 "PCR210,Pad Configuration Register 210"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,!RSCFG,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F901E6++0x03 "PCR211-212: BOOTCFG[0:1] / IRQ[2:3]"
  line.word 0x00 "PCR211,Pad Configuration Register 211"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,BOOTCFG0,IRQ02,BOOTCFG0,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR212,Pad Configuration Register 212"
  bitfld.word 0x02 10.--12.       "PA , Pin assignment" "GPIO,BOOTCFG1,IRQ03,BOOTCFG0,res.,res.,res.,res.      "
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x02 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F901EA++0x01 "PCR213: WKPCFG"
  line.word 0x00 "PCR213,Pad Configuration Register 213"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,WKPCFG,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F901EC++0x01 "PCR214: ENGCLK"
  line.word 0x00 "PCR214,Pad Configuration Register 214"

; bitfld.word 0x00 10.--13.       "PA , Pin assignment" "   0,   1,   2,   3,   4,   5,   6,   7,   8,   9,   A,   B,   C,   D,   E,   F"
  bitfld.word 0x00 09.            "         OBE , Output buffer enable" "0,1"
; bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "         DSC , Drive strength control" "10pF,20pF,30pF,50pF"
; bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
; bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
; bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
; bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
; bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

group 0xC3F901EE++0x01 "PCR215: AN12 / MA0 / !SDS"
  line.word 0x00 "PCR215,Pad Configuration Register 215"

  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "!SDS,res.,MA0,AN12,res.,res.,res.,res.      "
;  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
;  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
; bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
;  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
;  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
;  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F901F0++0x01 "PCR216: AN13 / MA1 / SDO"
  line.word 0x00 "PCR216,Pad Configuration Register 216"

  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "SDO,res.,MA1,AN13,res.,res.,res.,res.      "
;  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
;  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
; bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
;  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
;  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
;  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F901F2++0x01 "PCR217: AN14 / MA2 / SDI"
  line.word 0x00 "PCR217,Pad Configuration Register 217"

  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "SDI,res.,MA2,AN14,res.,res.,res.,res.      "
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F901F4++0x01 "PCR218: AN15 / FCK"
  line.word 0x00 "PCR218,Pad Configuration Register 218"

  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "FCK,AN15,res.,res.,res.,res.,res.,res.      "
;  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
;  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
; bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
;  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
;  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
;  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F901F6++0x01 "PCR219: MCKO"
  line.word 0x00 "PCR219,Pad Configuration Register 219"

;  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "   0,   1,   2,   3,   4,   5,   6,   7,   8,   9,   A,   B,   C,   D,   E,   F"
;  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
;  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "                       DSC , Drive strength control" "10pF,20pF,30pF,50pF"
;  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
;  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
;  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
;  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
;  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

group 0xC3F901F8++0x09 "PCR220-223: MDO[0:3]"
  line.word 0x00 "PCR220,Pad Configuration Register 220"

;  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "   0,   1,   2,   3,   4,   5,   6,   7,   8,   9,   A,   B,   C,   D,   E,   F"
;  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
;  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "                       DSC , Drive strength control" "10pF,20pF,30pF,50pF"
;  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
;  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
;  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
;  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
;  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"
  line.word 0x02 "PCR221,Pad Configuration Register 221"

;  bitfld.word 0x02 10.--13.       "PA , Pin assignment" "   0,   1,   2,   3,   4,   5,   6,   7,   8,   9,   A,   B,   C,   D,   E,   F"
;  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
;  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 06.--07.       "                       DSC , Drive strength control" "10pF,20pF,30pF,50pF"
;  bitfld.word 0x02 05.            "  ODE , Open drain output enable" "0,1"
;  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
;  bitfld.word 0x02 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
;  bitfld.word 0x02 01.            "  WPE , Weak pull up/down enable" "0,1"
;  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"
  line.word 0x04 "PCR222,Pad Configuration Register 222"

;  bitfld.word 0x04 10.--13.       "PA , Pin assignment" "   0,   1,   2,   3,   4,   5,   6,   7,   8,   9,   A,   B,   C,   D,   E,   F"
;  bitfld.word 0x04 09.            "  OBE , Output buffer enable" "0,1"
;  bitfld.word 0x04 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x04 06.--07.       "                       DSC , Drive strength control" "10pF,20pF,30pF,50pF"
;  bitfld.word 0x04 05.            "  ODE , Open drain output enable" "0,1"
;  bitfld.word 0x04 04.            "  HYS , Input hysteresis" "0,1"
;  bitfld.word 0x04 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
;  bitfld.word 0x04 01.            "  WPE , Weak pull up/down enable" "0,1"
;  bitfld.word 0x04 00.            "  WPS , Weak pull up/down select" "0,1"
  line.word 0x06 "PCR223,Pad Configuration Register 223"

;  bitfld.word 0x06 10.--13.       "PA , Pin assignment" "   0,   1,   2,   3,   4,   5,   6,   7,   8,   9,   A,   B,   C,   D,   E,   F"
;  bitfld.word 0x06 09.            "  OBE , Output buffer enable" "0,1"
;  bitfld.word 0x06 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x06 06.--07.       "                       DSC , Drive strength control" "10pF,20pF,30pF,50pF"
;  bitfld.word 0x06 05.            "  ODE , Open drain output enable" "0,1"
;  bitfld.word 0x06 04.            "  HYS , Input hysteresis" "0,1"
;  bitfld.word 0x06 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
;  bitfld.word 0x06 01.            "  WPE , Weak pull up/down enable" "0,1"
;  bitfld.word 0x06 00.            "  WPS , Weak pull up/down select" "0,1"

group 0xC3F90200++0x03 "PCR224-225: !MSEO[0:1]"
  line.word 0x00 "PCR224,Pad Configuration Register 224"

;  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "   0,   1,   2,   3,   4,   5,   6,   7,   8,   9,   A,   B,   C,   D,   E,   F"
;  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
;  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "                       DSC , Drive strength control" "10pF,20pF,30pF,50pF"
;  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
;  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
;  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
;  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
;  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"
  line.word 0x02 "PCR225,Pad Configuration Register 225"

;  bitfld.word 0x02 10.--13.       "PA , Pin assignment" "   0,   1,   2,   3,   4,   5,   6,   7,   8,   9,   A,   B,   C,   D,   E,   F"
;  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
;  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 06.--07.       "                       DSC , Drive strength control" "10pF,20pF,30pF,50pF"
;  bitfld.word 0x02 05.            "  ODE , Open drain output enable" "0,1"
;  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
;  bitfld.word 0x02 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
;  bitfld.word 0x02 01.            "  WPE , Weak pull up/down enable" "0,1"
;  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"

group 0xC3F90204++0x01 "PCR226: !RDY"
  line.word 0x00 "PCR226,Pad Configuration Register 226"

;  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "   0,   1,   2,   3,   4,   5,   6,   7,   8,   9,   A,   B,   C,   D,   E,   F"
;  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
;  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "                       DSC , Drive strength control" "10pF,20pF,30pF,50pF"
;  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
;  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
;  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
;  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
;  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

group 0xC3F90206++0x01 "PCR227: !EVTO"
  line.word 0x00 "PCR227,Pad Configuration Register 227"

;  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "   0,   1,   2,   3,   4,   5,   6,   7,   8,   9,   A,   B,   C,   D,   E,   F"
;  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
;  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "                       DSC , Drive strength control" "10pF,20pF,30pF,50pF"
;  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
;  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
;  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
;  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
;  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

group 0xC3F90208++0x01 "PCR228: TDO"
  line.word 0x00 "PCR228,Pad Configuration Register 228"

;  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "   0,   1,   2,   3,   4,   5,   6,   7,   8,   9,   A,   B,   C,   D,   E,   F"
;  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
;  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "                       DSC , Drive strength control" "10pF,20pF,30pF,50pF"
;  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
;  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
;  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
;  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
;  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

group 0xC3F9020A++0x01 "PCR229: !CLKOUT"
  line.word 0x00 "PCR229,Pad Configuration Register 229"

; bitfld.word 0x00 10.--13.       "PA , Pin assignment" "   0,   1,   2,   3,   4,   5,   6,   7,   8,   9,   A,   B,   C,   D,   E,   F"
  bitfld.word 0x00 09.            "         OBE , Output buffer enable" "0,1"
; bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "         DSC , Drive strength control" "10pF,20pF,30pF,50pF"
; bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
; bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
; bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
; bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
; bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

group 0xC3F9020C++0x01 "PCR230: !RSTOUT"
  line.word 0x00 "PCR230,Pad Configuration Register 230"

;  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "   0,   1,   2,   3,   4,   5,   6,   7,   8,   9,   A,   B,   C,   D,   E,   F"
;  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
;  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
;  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
;  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
;  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "                                               SRC , Slew rate control" "Min,Med,res,Max"
;  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
;  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

group 0xC3F90240++0x05 "PCR256-258: !CAL_CS / CAL_ADDR"
  line.word 0x00 "PCR256,Pad Configuration Register 256"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "res.,!CAL_CS0,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR257,Pad Configuration Register 257"
  bitfld.word 0x02 10.--12.       "PA , Pin assignment" "res.,!CAL_CS2,CAL_ADDR10,!CAL_CS2,res.,res.,res.,res.      "
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x02 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x04 "PCR258,Pad Configuration Register 258"
  bitfld.word 0x04 10.--12.       "PA , Pin assignment" "res.,!CAL_CS3,CAL_ADDR11,!CAL_CS3,res.,res.,res.,res.      "
  bitfld.word 0x04 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x04 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x04 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x04 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x04 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x04 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x04 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90246++0x23 "PCR259-276: CAL_ADDR / FEC"
  line.word 0x00 "PCR259,Pad Configuration Register 259"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "res.,CAL_ADDR12,FEC_TX_CLK,CAL_ADDR12,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR260,Pad Configuration Register 260"
  bitfld.word 0x02 10.--12.       "PA , Pin assignment" "res.,CAL_ADDR13,FEC_CRS,CAL_ADDR13,res.,res.,res.,res.      "
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x02 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x04 "PCR261,Pad Configuration Register 261"
  bitfld.word 0x04 10.--12.       "PA , Pin assignment" "res.,CAL_ADDR14,FEC_TX_ER,CAL_ADDR14,res.,res.,res.,res.      "
  bitfld.word 0x04 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x04 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x04 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x04 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x04 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x04 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x04 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x06 "PCR262,Pad Configuration Register 262"
  bitfld.word 0x06 10.--12.       "PA , Pin assignment" "res.,CAL_ADDR15,FEC_RX_CLK,CAL_ADDR15,res.,res.,res.,res.      "
  bitfld.word 0x06 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x06 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x06 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x06 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x06 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x06 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x06 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x08 "PCR263,Pad Configuration Register 263"
  bitfld.word 0x08 10.--12.       "PA , Pin assignment" "res.,CAL_ADDR16,FEC_TXD0,CAL_ADDR16,res.,res.,res.,res.      "
  bitfld.word 0x08 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x08 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x08 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x08 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x08 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x08 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x08 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0a "PCR264,Pad Configuration Register 264"
  bitfld.word 0x0a 10.--12.       "PA , Pin assignment" "res.,CAL_ADDR17,FEC_RX_ER,CAL_ADDR17,res.,res.,res.,res.      "
  bitfld.word 0x0a 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0a 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0a 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x0a 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x0a 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0a 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0a 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0c "PCR265,Pad Configuration Register 265"
  bitfld.word 0x0c 10.--12.       "PA , Pin assignment" "res.,CAL_ADDR18,FEC_RXD0,CAL_ADDR18,res.,res.,res.,res.      "
  bitfld.word 0x0c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0c 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x0c 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x0c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0c 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0e "PCR266,Pad Configuration Register 266"
  bitfld.word 0x0e 10.--12.       "PA , Pin assignment" "res.,CAL_ADDR19,FEC_TXD3,CAL_ADDR19,res.,res.,res.,res.      "
  bitfld.word 0x0e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0e 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x0e 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x0e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0e 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0e 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x10 "PCR267,Pad Configuration Register 267"
  bitfld.word 0x10 10.--12.       "PA , Pin assignment" "res.,CAL_ADDR20,FEC_COL,CAL_ADDR20,res.,res.,res.,res.      "
  bitfld.word 0x10 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x10 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x10 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x10 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x10 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x10 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x10 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x12 "PCR268,Pad Configuration Register 268"
  bitfld.word 0x12 10.--12.       "PA , Pin assignment" "res.,CAL_ADDR21,FEC_RX_DV,CAL_ADDR21,res.,res.,res.,res.      "
  bitfld.word 0x12 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x12 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x12 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x12 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x12 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x12 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x12 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x14 "PCR269,Pad Configuration Register 269"
  bitfld.word 0x14 10.--12.       "PA , Pin assignment" "res.,CAL_ADDR22,FEC_TX_EN,CAL_ADDR22,res.,res.,res.,res.      "
  bitfld.word 0x14 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x14 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x14 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x14 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x14 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x14 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x14 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x16 "PCR270,Pad Configuration Register 270"
  bitfld.word 0x16 10.--12.       "PA , Pin assignment" "res.,CAL_ADDR23,FEC_TXD1,CAL_ADDR23,res.,res.,res.,res.      "
  bitfld.word 0x16 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x16 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x16 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x16 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x16 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x16 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x16 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x18 "PCR271,Pad Configuration Register 271"
  bitfld.word 0x18 10.--12.       "PA , Pin assignment" "res.,CAL_ADDR24,FEC_TXD2,CAL_ADDR24,res.,res.,res.,res.      "
  bitfld.word 0x18 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x18 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x18 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x18 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x18 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x18 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x18 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x1a "PCR272,Pad Configuration Register 272"
  bitfld.word 0x1a 10.--12.       "PA , Pin assignment" "res.,CAL_ADDR25,FEC_RXD1,CAL_ADDR25,res.,res.,res.,res.      "
  bitfld.word 0x1a 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x1a 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x1a 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x1a 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x1a 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x1a 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x1a 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x1c "PCR273,Pad Configuration Register 273"
  bitfld.word 0x1c 10.--12.       "PA , Pin assignment" "res.,CAL_ADDR26,FEC_RXD2,CAL_ADDR26,res.,res.,res.,res.      "
  bitfld.word 0x1c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x1c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x1c 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x1c 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x1c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x1c 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x1c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x1e "PCR274,Pad Configuration Register 274"
  bitfld.word 0x1e 10.--12.       "PA , Pin assignment" "res.,CAL_ADDR27,FEC_RXD3,CAL_ADDR27,res.,res.,res.,res.      "
  bitfld.word 0x1e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x1e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x1e 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x1e 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x1e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x1e 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x1e 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x20 "PCR275,Pad Configuration Register 275"
  bitfld.word 0x20 10.--12.       "PA , Pin assignment" "res.,CAL_ADDR28,FEC_MDC,CAL_ADDR28,res.,res.,res.,res.      "
  bitfld.word 0x20 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x20 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x20 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x20 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x20 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x20 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x20 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x22 "PCR276,Pad Configuration Register 276"
  bitfld.word 0x22 10.--12.       "PA , Pin assignment" "res.,CAL_ADDR28,FEC_MDIO,CAL_ADDR29,res.,res.,res.,res.      "
  bitfld.word 0x22 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x22 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x22 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x22 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x22 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x22 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x22 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F9026A++0x01 "PCR277: CAL_ADDR30"
  line.word 0x00 "PCR277,Pad Configuration Register 277"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "res.,CAL_ADDR30,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F9026C++0x1f "PCR278-293: CAL_DATA[00-15]"
  line.word 0x00 "PCR278,Pad Configuration Register 278"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "res.,CAL_DATA00,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR279,Pad Configuration Register 279"
  bitfld.word 0x02 10.--12.       "PA , Pin assignment" "res.,CAL_DATA01,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x02 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x04 "PCR280,Pad Configuration Register 280"
  bitfld.word 0x04 10.--12.       "PA , Pin assignment" "res.,CAL_DATA02,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x04 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x04 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x04 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x04 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x04 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x04 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x04 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x06 "PCR281,Pad Configuration Register 281"
  bitfld.word 0x06 10.--12.       "PA , Pin assignment" "res.,CAL_DATA03,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x06 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x06 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x06 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x06 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x06 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x06 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x06 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x08 "PCR282,Pad Configuration Register 282"
  bitfld.word 0x08 10.--12.       "PA , Pin assignment" "res.,CAL_DATA04,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x08 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x08 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x08 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x08 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x08 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x08 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x08 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0a "PCR283,Pad Configuration Register 283"
  bitfld.word 0x0a 10.--12.       "PA , Pin assignment" "res.,CAL_DATA05,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x0a 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0a 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0a 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x0a 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x0a 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0a 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0a 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0c "PCR284,Pad Configuration Register 284"
  bitfld.word 0x0c 10.--12.       "PA , Pin assignment" "res.,CAL_DATA06,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x0c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0c 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x0c 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x0c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0c 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0e "PCR285,Pad Configuration Register 285"
  bitfld.word 0x0e 10.--12.       "PA , Pin assignment" "res.,CAL_DATA07,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x0e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0e 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x0e 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x0e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0e 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0e 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x10 "PCR286,Pad Configuration Register 286"
  bitfld.word 0x10 10.--12.       "PA , Pin assignment" "res.,CAL_DATA08,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x10 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x10 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x10 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x10 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x10 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x10 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x10 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x12 "PCR287,Pad Configuration Register 287"
  bitfld.word 0x12 10.--12.       "PA , Pin assignment" "res.,CAL_DATA09,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x12 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x12 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x12 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x12 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x12 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x12 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x12 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x14 "PCR288,Pad Configuration Register 288"
  bitfld.word 0x14 10.--12.       "PA , Pin assignment" "res.,CAL_DATA10,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x14 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x14 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x14 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x14 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x14 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x14 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x14 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x16 "PCR289,Pad Configuration Register 289"
  bitfld.word 0x16 10.--12.       "PA , Pin assignment" "res.,CAL_DATA11,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x16 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x16 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x16 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x16 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x16 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x16 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x16 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x18 "PCR290,Pad Configuration Register 290"
  bitfld.word 0x18 10.--12.       "PA , Pin assignment" "res.,CAL_DATA12,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x18 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x18 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x18 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x18 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x18 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x18 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x18 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x1a "PCR291,Pad Configuration Register 291"
  bitfld.word 0x1a 10.--12.       "PA , Pin assignment" "res.,CAL_DATA13,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x1a 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x1a 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x1a 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x1a 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x1a 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x1a 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x1a 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x1c "PCR292,Pad Configuration Register 292"
  bitfld.word 0x1c 10.--12.       "PA , Pin assignment" "res.,CAL_DATA14,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x1c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x1c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x1c 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x1c 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x1c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x1c 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x1c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x1e "PCR293,Pad Configuration Register 293"
  bitfld.word 0x1e 10.--12.       "PA , Pin assignment" "res.,CAL_DATA15,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x1e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x1e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x1e 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x1e 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x1e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x1e 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x1e 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F9028C++0x09 "PCR294-298: CAL"
  line.word 0x00 "PCR294,Pad Configuration Register 294"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "res.,CAL_RD_!WR,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR295,Pad Configuration Register 295"
  bitfld.word 0x02 10.--12.       "PA , Pin assignment" "res.,CAL_!WEBE0,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x02 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x04 "PCR296,Pad Configuration Register 296"
  bitfld.word 0x04 10.--12.       "PA , Pin assignment" "res.,CAL_!WEBE1,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x04 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x04 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x04 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x04 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x04 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x04 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x04 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x06 "PCR297,Pad Configuration Register 297"
  bitfld.word 0x06 10.--12.       "PA , Pin assignment" "res.,CAL_!OE,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x06 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x06 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x06 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x06 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x06 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x06 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x06 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x08 "PCR298,Pad Configuration Register 298"
  bitfld.word 0x08 10.--12.       "PA , Pin assignment" "res.,CAL_!TS,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x08 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x08 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x08 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x08 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x08 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x08 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x08 00.            "  WPS , Weak pull up/down select" "0,1"

endif

tree.end



tree "GPIO Pin Data Output Registers"

group.long 0xC3F90600++0x03
  line.long    0x00 "000-003,GPIO Pin Data Out Register 000-003"
  bitfld.long  0x00 24.                  "PDO000 ,Pin 000 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO001 ,Pin 001 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO002 ,Pin 002 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO003 ,Pin 003 data out" "L,H"
group.long 0xC3F90604++0x03
  line.long    0x00 "004-007,GPIO Pin Data Out Register 004-007"
  bitfld.long  0x00 24.                  "PDO004 ,Pin 004 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO005 ,Pin 005 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO006 ,Pin 006 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO007 ,Pin 007 data out" "L,H"
group.long 0xC3F90608++0x03
  line.long    0x00 "008-011,GPIO Pin Data Out Register 008-011"
  bitfld.long  0x00 24.                  "PDO008 ,Pin 008 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO009 ,Pin 009 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO010 ,Pin 010 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO011 ,Pin 011 data out" "L,H"
group.long 0xC3F9060c++0x03
  line.long    0x00 "012-015,GPIO Pin Data Out Register 012-015"
  bitfld.long  0x00 24.                  "PDO012 ,Pin 012 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO013 ,Pin 013 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO014 ,Pin 014 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO015 ,Pin 015 data out" "L,H"
group.long 0xC3F90610++0x03
  line.long    0x00 "016-019,GPIO Pin Data Out Register 016-019"
  bitfld.long  0x00 24.                  "PDO016 ,Pin 016 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO017 ,Pin 017 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO018 ,Pin 018 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO019 ,Pin 019 data out" "L,H"
group.long 0xC3F90614++0x03
  line.long    0x00 "020-023,GPIO Pin Data Out Register 020-023"
  bitfld.long  0x00 24.                  "PDO020 ,Pin 020 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO021 ,Pin 021 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO022 ,Pin 022 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO023 ,Pin 023 data out" "L,H"
group.long 0xC3F90618++0x03
  line.long    0x00 "024-027,GPIO Pin Data Out Register 024-027"
  bitfld.long  0x00 24.                  "PDO024 ,Pin 024 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO025 ,Pin 025 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO026 ,Pin 026 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO027 ,Pin 027 data out" "L,H"
group.long 0xC3F9061c++0x03
  line.long    0x00 "028-031,GPIO Pin Data Out Register 028-031"
  bitfld.long  0x00 24.                  "PDO028 ,Pin 028 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO029 ,Pin 029 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO030 ,Pin 030 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO031 ,Pin 031 data out" "L,H"
group.long 0xC3F90620++0x03
  line.long    0x00 "032-035,GPIO Pin Data Out Register 032-035"
  bitfld.long  0x00 24.                  "PDO032 ,Pin 032 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO033 ,Pin 033 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO034 ,Pin 034 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO035 ,Pin 035 data out" "L,H"
group.long 0xC3F90624++0x03
  line.long    0x00 "036-039,GPIO Pin Data Out Register 036-039"
  bitfld.long  0x00 24.                  "PDO036 ,Pin 036 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO037 ,Pin 037 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO038 ,Pin 038 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO039 ,Pin 039 data out" "L,H"
group.long 0xC3F90628++0x03
  line.long    0x00 "040-043,GPIO Pin Data Out Register 040-043"
  bitfld.long  0x00 24.                  "PDO040 ,Pin 040 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO041 ,Pin 041 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO042 ,Pin 042 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO043 ,Pin 043 data out" "L,H"
group.long 0xC3F9062c++0x03
  line.long    0x00 "044-047,GPIO Pin Data Out Register 044-047"
  bitfld.long  0x00 24.                  "PDO044 ,Pin 044 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO045 ,Pin 045 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO046 ,Pin 046 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO047 ,Pin 047 data out" "L,H"
group.long 0xC3F90630++0x03
  line.long    0x00 "048-051,GPIO Pin Data Out Register 048-051"
  bitfld.long  0x00 24.                  "PDO048 ,Pin 048 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO049 ,Pin 049 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO050 ,Pin 050 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO051 ,Pin 051 data out" "L,H"
group.long 0xC3F90634++0x03
  line.long    0x00 "052-055,GPIO Pin Data Out Register 052-055"
  bitfld.long  0x00 24.                  "PDO052 ,Pin 052 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO053 ,Pin 053 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO054 ,Pin 054 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO055 ,Pin 055 data out" "L,H"
group.long 0xC3F90638++0x03
  line.long    0x00 "056-059,GPIO Pin Data Out Register 056-059"
  bitfld.long  0x00 24.                  "PDO056 ,Pin 056 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO057 ,Pin 057 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO058 ,Pin 058 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO059 ,Pin 059 data out" "L,H"
group.long 0xC3F9063c++0x03
  line.long    0x00 "060-063,GPIO Pin Data Out Register 060-063"
  bitfld.long  0x00 24.                  "PDO060 ,Pin 060 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO061 ,Pin 061 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO062 ,Pin 062 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO063 ,Pin 063 data out" "L,H"
group.long 0xC3F90640++0x03
  line.long    0x00 "064-067,GPIO Pin Data Out Register 064-067"
  bitfld.long  0x00 24.                  "PDO064 ,Pin 064 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO065 ,Pin 065 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO066 ,Pin 066 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO067 ,Pin 067 data out" "L,H"
group.long 0xC3F90644++0x03
  line.long    0x00 "068-071,GPIO Pin Data Out Register 068-071"
  bitfld.long  0x00 24.                  "PDO068 ,Pin 068 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO069 ,Pin 069 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO070 ,Pin 070 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO071 ,Pin 071 data out" "L,H"
group.long 0xC3F90648++0x03
  line.long    0x00 "072-075,GPIO Pin Data Out Register 072-075"
  bitfld.long  0x00 24.                  "PDO072 ,Pin 072 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO073 ,Pin 073 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO074 ,Pin 074 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO075 ,Pin 075 data out" "L,H"
group.long 0xC3F9064c++0x03
  line.long    0x00 "076-079,GPIO Pin Data Out Register 076-079"
  bitfld.long  0x00 24.                  "PDO076 ,Pin 076 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO077 ,Pin 077 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO078 ,Pin 078 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO079 ,Pin 079 data out" "L,H"
group.long 0xC3F90650++0x03
  line.long    0x00 "080-083,GPIO Pin Data Out Register 080-083"
  bitfld.long  0x00 24.                  "PDO080 ,Pin 080 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO081 ,Pin 081 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO082 ,Pin 082 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO083 ,Pin 083 data out" "L,H"
group.long 0xC3F90654++0x03
  line.long    0x00 "084-087,GPIO Pin Data Out Register 084-087"
  bitfld.long  0x00 24.                  "PDO084 ,Pin 084 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO085 ,Pin 085 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO086 ,Pin 086 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO087 ,Pin 087 data out" "L,H"
group.long 0xC3F90658++0x03
  line.long    0x00 "088-091,GPIO Pin Data Out Register 088-091"
  bitfld.long  0x00 24.                  "PDO088 ,Pin 088 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO089 ,Pin 089 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO090 ,Pin 090 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO091 ,Pin 091 data out" "L,H"
group.long 0xC3F9065c++0x03
  line.long    0x00 "092-095,GPIO Pin Data Out Register 092-095"
  bitfld.long  0x00 24.                  "PDO092 ,Pin 092 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO093 ,Pin 093 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO094 ,Pin 094 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO095 ,Pin 095 data out" "L,H"
group.long 0xC3F90660++0x03
  line.long    0x00 "096-099,GPIO Pin Data Out Register 096-099"
  bitfld.long  0x00 24.                  "PDO096 ,Pin 096 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO097 ,Pin 097 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO098 ,Pin 098 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO099 ,Pin 099 data out" "L,H"
group.long 0xC3F90664++0x03
  line.long    0x00 "100-103,GPIO Pin Data Out Register 100-103"
  bitfld.long  0x00 24.                  "PDO100 ,Pin 100 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO101 ,Pin 101 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO102 ,Pin 102 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO103 ,Pin 103 data out" "L,H"
group.long 0xC3F90668++0x03
  line.long    0x00 "104-107,GPIO Pin Data Out Register 104-107"
  bitfld.long  0x00 24.                  "PDO104 ,Pin 104 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO105 ,Pin 105 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO106 ,Pin 106 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO107 ,Pin 107 data out" "L,H"
group.long 0xC3F9066c++0x03
  line.long    0x00 "108-111,GPIO Pin Data Out Register 108-111"
  bitfld.long  0x00 24.                  "PDO108 ,Pin 108 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO109 ,Pin 109 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO110 ,Pin 110 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO111 ,Pin 111 data out" "L,H"
group.long 0xC3F90670++0x03
  line.long    0x00 "112-115,GPIO Pin Data Out Register 112-115"
  bitfld.long  0x00 24.                  "PDO112 ,Pin 112 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO113 ,Pin 113 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO114 ,Pin 114 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO115 ,Pin 115 data out" "L,H"
group.long 0xC3F90674++0x03
  line.long    0x00 "116-119,GPIO Pin Data Out Register 116-119"
  bitfld.long  0x00 24.                  "PDO116 ,Pin 116 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO117 ,Pin 117 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO118 ,Pin 118 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO119 ,Pin 119 data out" "L,H"
group.long 0xC3F90678++0x03
  line.long    0x00 "120-123,GPIO Pin Data Out Register 120-123"
  bitfld.long  0x00 24.                  "PDO120 ,Pin 120 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO121 ,Pin 121 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO122 ,Pin 122 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO123 ,Pin 123 data out" "L,H"
group.long 0xC3F9067c++0x03
  line.long    0x00 "124-127,GPIO Pin Data Out Register 124-127"
  bitfld.long  0x00 24.                  "PDO124 ,Pin 124 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO125 ,Pin 125 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO126 ,Pin 126 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO127 ,Pin 127 data out" "L,H"
group.long 0xC3F90680++0x03
  line.long    0x00 "128-131,GPIO Pin Data Out Register 128-131"
  bitfld.long  0x00 24.                  "PDO128 ,Pin 128 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO129 ,Pin 129 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO130 ,Pin 130 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO131 ,Pin 131 data out" "L,H"
group.long 0xC3F90684++0x03
  line.long    0x00 "132-135,GPIO Pin Data Out Register 132-135"
  bitfld.long  0x00 24.                  "PDO132 ,Pin 132 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO133 ,Pin 133 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO134 ,Pin 134 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO135 ,Pin 135 data out" "L,H"
group.long 0xC3F90688++0x03
  line.long    0x00 "136-139,GPIO Pin Data Out Register 136-139"
  bitfld.long  0x00 24.                  "PDO136 ,Pin 136 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO137 ,Pin 137 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO138 ,Pin 138 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO139 ,Pin 139 data out" "L,H"
group.long 0xC3F9068c++0x03
  line.long    0x00 "140-143,GPIO Pin Data Out Register 140-143"
  bitfld.long  0x00 24.                  "PDO140 ,Pin 140 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO141 ,Pin 141 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO142 ,Pin 142 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO143 ,Pin 143 data out" "L,H"
group.long 0xC3F90690++0x03
  line.long    0x00 "144-147,GPIO Pin Data Out Register 144-147"
  bitfld.long  0x00 24.                  "PDO144 ,Pin 144 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO145 ,Pin 145 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO146 ,Pin 146 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO147 ,Pin 147 data out" "L,H"
group.long 0xC3F90694++0x03
  line.long    0x00 "148-151,GPIO Pin Data Out Register 148-151"
  bitfld.long  0x00 24.                  "PDO148 ,Pin 148 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO149 ,Pin 149 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO150 ,Pin 150 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO151 ,Pin 151 data out" "L,H"
group.long 0xC3F90698++0x03
  line.long    0x00 "152-155,GPIO Pin Data Out Register 152-155"
  bitfld.long  0x00 24.                  "PDO152 ,Pin 152 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO153 ,Pin 153 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO154 ,Pin 154 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO155 ,Pin 155 data out" "L,H"
group.long 0xC3F9069c++0x03
  line.long    0x00 "156-159,GPIO Pin Data Out Register 156-159"
  bitfld.long  0x00 24.                  "PDO156 ,Pin 156 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO157 ,Pin 157 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO158 ,Pin 158 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO159 ,Pin 159 data out" "L,H"
group.long 0xC3F906a0++0x03
  line.long    0x00 "160-163,GPIO Pin Data Out Register 160-163"
  bitfld.long  0x00 24.                  "PDO160 ,Pin 160 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO161 ,Pin 161 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO162 ,Pin 162 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO163 ,Pin 163 data out" "L,H"
group.long 0xC3F906a4++0x03
  line.long    0x00 "164-167,GPIO Pin Data Out Register 164-167"
  bitfld.long  0x00 24.                  "PDO164 ,Pin 164 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO165 ,Pin 165 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO166 ,Pin 166 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO167 ,Pin 167 data out" "L,H"
group.long 0xC3F906a8++0x03
  line.long    0x00 "168-171,GPIO Pin Data Out Register 168-171"
  bitfld.long  0x00 24.                  "PDO168 ,Pin 168 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO169 ,Pin 169 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO170 ,Pin 170 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO171 ,Pin 171 data out" "L,H"
group.long 0xC3F906ac++0x03
  line.long    0x00 "172-175,GPIO Pin Data Out Register 172-175"
  bitfld.long  0x00 24.                  "PDO172 ,Pin 172 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO173 ,Pin 173 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO174 ,Pin 174 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO175 ,Pin 175 data out" "L,H"
group.long 0xC3F906b0++0x03
  line.long    0x00 "176-179,GPIO Pin Data Out Register 176-179"
  bitfld.long  0x00 24.                  "PDO176 ,Pin 176 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO177 ,Pin 177 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO178 ,Pin 178 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO179 ,Pin 179 data out" "L,H"
group.long 0xC3F906b4++0x03
  line.long    0x00 "180-183,GPIO Pin Data Out Register 180-183"
  bitfld.long  0x00 24.                  "PDO180 ,Pin 180 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO181 ,Pin 181 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO182 ,Pin 182 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO183 ,Pin 183 data out" "L,H"
group.long 0xC3F906b8++0x03
  line.long    0x00 "184-187,GPIO Pin Data Out Register 184-187"
  bitfld.long  0x00 24.                  "PDO184 ,Pin 184 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO185 ,Pin 185 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO186 ,Pin 186 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO187 ,Pin 187 data out" "L,H"
group.long 0xC3F906bc++0x03
  line.long    0x00 "188-191,GPIO Pin Data Out Register 188-191"
  bitfld.long  0x00 24.                  "PDO188 ,Pin 188 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO189 ,Pin 189 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO190 ,Pin 190 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO191 ,Pin 191 data out" "L,H"
group.long 0xC3F906c0++0x03
  line.long    0x00 "192-195,GPIO Pin Data Out Register 192-195"
  bitfld.long  0x00 24.                  "PDO192 ,Pin 192 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO193 ,Pin 193 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO194 ,Pin 194 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO195 ,Pin 195 data out" "L,H"
group.long 0xC3F906c4++0x03
  line.long    0x00 "196-199,GPIO Pin Data Out Register 196-199"
  bitfld.long  0x00 24.                  "PDO196 ,Pin 196 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO197 ,Pin 197 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO198 ,Pin 198 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO199 ,Pin 199 data out" "L,H"
group.long 0xC3F906c8++0x03
  line.long    0x00 "200-203,GPIO Pin Data Out Register 200-203"
  bitfld.long  0x00 24.                  "PDO200 ,Pin 200 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO201 ,Pin 201 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO202 ,Pin 202 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO203 ,Pin 203 data out" "L,H"
group.long 0xC3F906cc++0x03
  line.long    0x00 "204-207,GPIO Pin Data Out Register 204-207"
  bitfld.long  0x00 24.                  "PDO204 ,Pin 204 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO205 ,Pin 205 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO206 ,Pin 206 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO207 ,Pin 207 data out" "L,H"
group.long 0xC3F906d0++0x03
  line.long    0x00 "208-211,GPIO Pin Data Out Register 208-211"
  bitfld.long  0x00 24.                  "PDO208 ,Pin 208 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO209 ,Pin 209 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO210 ,Pin 210 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO211 ,Pin 211 data out" "L,H"
group.long 0xC3F906d4++0x03
  line.long    0x00 "212-215,GPIO Pin Data Out Register 212-215"
  bitfld.long  0x00 24.                  "PDO212 ,Pin 212 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO213 ,Pin 213 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO214 ,Pin 214 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO215 ,Pin 215 data out" "L,H"

tree.end

tree "GPIO Pin Data Input Registers"
group.long 0xC3F90800++0x03
  line.long    0x00 "000-003,GPIO Pin Data In Register 000-003"
  bitfld.long  0x00 24.                  "PDI000 ,Pin 000 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI001 ,Pin 001 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI002 ,Pin 002 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI003 ,Pin 003 data in" "L,H"
group.long 0xC3F90804++0x03
  line.long    0x00 "004-007,GPIO Pin Data In Register 004-007"
  bitfld.long  0x00 24.                  "PDI004 ,Pin 004 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI005 ,Pin 005 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI006 ,Pin 006 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI007 ,Pin 007 data in" "L,H"
group.long 0xC3F90808++0x03
  line.long    0x00 "008-011,GPIO Pin Data In Register 008-011"
  bitfld.long  0x00 24.                  "PDI008 ,Pin 008 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI009 ,Pin 009 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI010 ,Pin 010 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI011 ,Pin 011 data in" "L,H"
group.long 0xC3F9080c++0x03
  line.long    0x00 "012-015,GPIO Pin Data In Register 012-015"
  bitfld.long  0x00 24.                  "PDI012 ,Pin 012 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI013 ,Pin 013 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI014 ,Pin 014 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI015 ,Pin 015 data in" "L,H"
group.long 0xC3F90810++0x03
  line.long    0x00 "016-019,GPIO Pin Data In Register 016-019"
  bitfld.long  0x00 24.                  "PDI016 ,Pin 016 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI017 ,Pin 017 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI018 ,Pin 018 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI019 ,Pin 019 data in" "L,H"
group.long 0xC3F90814++0x03
  line.long    0x00 "020-023,GPIO Pin Data In Register 020-023"
  bitfld.long  0x00 24.                  "PDI020 ,Pin 020 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI021 ,Pin 021 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI022 ,Pin 022 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI023 ,Pin 023 data in" "L,H"
group.long 0xC3F90818++0x03
  line.long    0x00 "024-027,GPIO Pin Data In Register 024-027"
  bitfld.long  0x00 24.                  "PDI024 ,Pin 024 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI025 ,Pin 025 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI026 ,Pin 026 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI027 ,Pin 027 data in" "L,H"
group.long 0xC3F9081c++0x03
  line.long    0x00 "028-031,GPIO Pin Data In Register 028-031"
  bitfld.long  0x00 24.                  "PDI028 ,Pin 028 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI029 ,Pin 029 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI030 ,Pin 030 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI031 ,Pin 031 data in" "L,H"
group.long 0xC3F90820++0x03
  line.long    0x00 "032-035,GPIO Pin Data In Register 032-035"
  bitfld.long  0x00 24.                  "PDI032 ,Pin 032 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI033 ,Pin 033 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI034 ,Pin 034 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI035 ,Pin 035 data in" "L,H"
group.long 0xC3F90824++0x03
  line.long    0x00 "036-039,GPIO Pin Data In Register 036-039"
  bitfld.long  0x00 24.                  "PDI036 ,Pin 036 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI037 ,Pin 037 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI038 ,Pin 038 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI039 ,Pin 039 data in" "L,H"
group.long 0xC3F90828++0x03
  line.long    0x00 "040-043,GPIO Pin Data In Register 040-043"
  bitfld.long  0x00 24.                  "PDI040 ,Pin 040 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI041 ,Pin 041 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI042 ,Pin 042 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI043 ,Pin 043 data in" "L,H"
group.long 0xC3F9082c++0x03
  line.long    0x00 "044-047,GPIO Pin Data In Register 044-047"
  bitfld.long  0x00 24.                  "PDI044 ,Pin 044 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI045 ,Pin 045 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI046 ,Pin 046 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI047 ,Pin 047 data in" "L,H"
group.long 0xC3F90830++0x03
  line.long    0x00 "048-051,GPIO Pin Data In Register 048-051"
  bitfld.long  0x00 24.                  "PDI048 ,Pin 048 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI049 ,Pin 049 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI050 ,Pin 050 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI051 ,Pin 051 data in" "L,H"
group.long 0xC3F90834++0x03
  line.long    0x00 "052-055,GPIO Pin Data In Register 052-055"
  bitfld.long  0x00 24.                  "PDI052 ,Pin 052 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI053 ,Pin 053 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI054 ,Pin 054 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI055 ,Pin 055 data in" "L,H"
group.long 0xC3F90838++0x03
  line.long    0x00 "056-059,GPIO Pin Data In Register 056-059"
  bitfld.long  0x00 24.                  "PDI056 ,Pin 056 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI057 ,Pin 057 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI058 ,Pin 058 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI059 ,Pin 059 data in" "L,H"
group.long 0xC3F9083c++0x03
  line.long    0x00 "060-063,GPIO Pin Data In Register 060-063"
  bitfld.long  0x00 24.                  "PDI060 ,Pin 060 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI061 ,Pin 061 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI062 ,Pin 062 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI063 ,Pin 063 data in" "L,H"
group.long 0xC3F90840++0x03
  line.long    0x00 "064-067,GPIO Pin Data In Register 064-067"
  bitfld.long  0x00 24.                  "PDI064 ,Pin 064 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI065 ,Pin 065 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI066 ,Pin 066 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI067 ,Pin 067 data in" "L,H"
group.long 0xC3F90844++0x03
  line.long    0x00 "068-071,GPIO Pin Data In Register 068-071"
  bitfld.long  0x00 24.                  "PDI068 ,Pin 068 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI069 ,Pin 069 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI070 ,Pin 070 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI071 ,Pin 071 data in" "L,H"
group.long 0xC3F90848++0x03
  line.long    0x00 "072-075,GPIO Pin Data In Register 072-075"
  bitfld.long  0x00 24.                  "PDI072 ,Pin 072 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI073 ,Pin 073 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI074 ,Pin 074 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI075 ,Pin 075 data in" "L,H"
group.long 0xC3F9084c++0x03
  line.long    0x00 "076-079,GPIO Pin Data In Register 076-079"
  bitfld.long  0x00 24.                  "PDI076 ,Pin 076 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI077 ,Pin 077 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI078 ,Pin 078 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI079 ,Pin 079 data in" "L,H"
group.long 0xC3F90850++0x03
  line.long    0x00 "080-083,GPIO Pin Data In Register 080-083"
  bitfld.long  0x00 24.                  "PDI080 ,Pin 080 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI081 ,Pin 081 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI082 ,Pin 082 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI083 ,Pin 083 data in" "L,H"
group.long 0xC3F90854++0x03
  line.long    0x00 "084-087,GPIO Pin Data In Register 084-087"
  bitfld.long  0x00 24.                  "PDI084 ,Pin 084 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI085 ,Pin 085 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI086 ,Pin 086 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI087 ,Pin 087 data in" "L,H"
group.long 0xC3F90858++0x03
  line.long    0x00 "088-091,GPIO Pin Data In Register 088-091"
  bitfld.long  0x00 24.                  "PDI088 ,Pin 088 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI089 ,Pin 089 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI090 ,Pin 090 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI091 ,Pin 091 data in" "L,H"
group.long 0xC3F9085c++0x03
  line.long    0x00 "092-095,GPIO Pin Data In Register 092-095"
  bitfld.long  0x00 24.                  "PDI092 ,Pin 092 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI093 ,Pin 093 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI094 ,Pin 094 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI095 ,Pin 095 data in" "L,H"
group.long 0xC3F90860++0x03
  line.long    0x00 "096-099,GPIO Pin Data In Register 096-099"
  bitfld.long  0x00 24.                  "PDI096 ,Pin 096 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI097 ,Pin 097 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI098 ,Pin 098 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI099 ,Pin 099 data in" "L,H"
group.long 0xC3F90864++0x03
  line.long    0x00 "100-103,GPIO Pin Data In Register 100-103"
  bitfld.long  0x00 24.                  "PDI100 ,Pin 100 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI101 ,Pin 101 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI102 ,Pin 102 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI103 ,Pin 103 data in" "L,H"
group.long 0xC3F90868++0x03
  line.long    0x00 "104-107,GPIO Pin Data In Register 104-107"
  bitfld.long  0x00 24.                  "PDI104 ,Pin 104 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI105 ,Pin 105 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI106 ,Pin 106 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI107 ,Pin 107 data in" "L,H"
group.long 0xC3F9086c++0x03
  line.long    0x00 "108-111,GPIO Pin Data In Register 108-111"
  bitfld.long  0x00 24.                  "PDI108 ,Pin 108 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI109 ,Pin 109 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI110 ,Pin 110 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI111 ,Pin 111 data in" "L,H"
group.long 0xC3F90870++0x03
  line.long    0x00 "112-115,GPIO Pin Data In Register 112-115"
  bitfld.long  0x00 24.                  "PDI112 ,Pin 112 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI113 ,Pin 113 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI114 ,Pin 114 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI115 ,Pin 115 data in" "L,H"
group.long 0xC3F90874++0x03
  line.long    0x00 "116-119,GPIO Pin Data In Register 116-119"
  bitfld.long  0x00 24.                  "PDI116 ,Pin 116 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI117 ,Pin 117 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI118 ,Pin 118 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI119 ,Pin 119 data in" "L,H"
group.long 0xC3F90878++0x03
  line.long    0x00 "120-123,GPIO Pin Data In Register 120-123"
  bitfld.long  0x00 24.                  "PDI120 ,Pin 120 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI121 ,Pin 121 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI122 ,Pin 122 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI123 ,Pin 123 data in" "L,H"
group.long 0xC3F9087c++0x03
  line.long    0x00 "124-127,GPIO Pin Data In Register 124-127"
  bitfld.long  0x00 24.                  "PDI124 ,Pin 124 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI125 ,Pin 125 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI126 ,Pin 126 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI127 ,Pin 127 data in" "L,H"
group.long 0xC3F90880++0x03
  line.long    0x00 "128-131,GPIO Pin Data In Register 128-131"
  bitfld.long  0x00 24.                  "PDI128 ,Pin 128 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI129 ,Pin 129 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI130 ,Pin 130 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI131 ,Pin 131 data in" "L,H"
group.long 0xC3F90884++0x03
  line.long    0x00 "132-135,GPIO Pin Data In Register 132-135"
  bitfld.long  0x00 24.                  "PDI132 ,Pin 132 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI133 ,Pin 133 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI134 ,Pin 134 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI135 ,Pin 135 data in" "L,H"
group.long 0xC3F90888++0x03
  line.long    0x00 "136-139,GPIO Pin Data In Register 136-139"
  bitfld.long  0x00 24.                  "PDI136 ,Pin 136 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI137 ,Pin 137 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI138 ,Pin 138 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI139 ,Pin 139 data in" "L,H"
group.long 0xC3F9088c++0x03
  line.long    0x00 "140-143,GPIO Pin Data In Register 140-143"
  bitfld.long  0x00 24.                  "PDI140 ,Pin 140 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI141 ,Pin 141 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI142 ,Pin 142 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI143 ,Pin 143 data in" "L,H"
group.long 0xC3F90890++0x03
  line.long    0x00 "144-147,GPIO Pin Data In Register 144-147"
  bitfld.long  0x00 24.                  "PDI144 ,Pin 144 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI145 ,Pin 145 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI146 ,Pin 146 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI147 ,Pin 147 data in" "L,H"
group.long 0xC3F90894++0x03
  line.long    0x00 "148-151,GPIO Pin Data In Register 148-151"
  bitfld.long  0x00 24.                  "PDI148 ,Pin 148 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI149 ,Pin 149 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI150 ,Pin 150 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI151 ,Pin 151 data in" "L,H"
group.long 0xC3F90898++0x03
  line.long    0x00 "152-155,GPIO Pin Data In Register 152-155"
  bitfld.long  0x00 24.                  "PDI152 ,Pin 152 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI153 ,Pin 153 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI154 ,Pin 154 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI155 ,Pin 155 data in" "L,H"
group.long 0xC3F9089c++0x03
  line.long    0x00 "156-159,GPIO Pin Data In Register 156-159"
  bitfld.long  0x00 24.                  "PDI156 ,Pin 156 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI157 ,Pin 157 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI158 ,Pin 158 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI159 ,Pin 159 data in" "L,H"
group.long 0xC3F908a0++0x03
  line.long    0x00 "160-163,GPIO Pin Data In Register 160-163"
  bitfld.long  0x00 24.                  "PDI160 ,Pin 160 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI161 ,Pin 161 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI162 ,Pin 162 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI163 ,Pin 163 data in" "L,H"
group.long 0xC3F908a4++0x03
  line.long    0x00 "164-167,GPIO Pin Data In Register 164-167"
  bitfld.long  0x00 24.                  "PDI164 ,Pin 164 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI165 ,Pin 165 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI166 ,Pin 166 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI167 ,Pin 167 data in" "L,H"
group.long 0xC3F908a8++0x03
  line.long    0x00 "168-171,GPIO Pin Data In Register 168-171"
  bitfld.long  0x00 24.                  "PDI168 ,Pin 168 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI169 ,Pin 169 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI170 ,Pin 170 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI171 ,Pin 171 data in" "L,H"
group.long 0xC3F908ac++0x03
  line.long    0x00 "172-175,GPIO Pin Data In Register 172-175"
  bitfld.long  0x00 24.                  "PDI172 ,Pin 172 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI173 ,Pin 173 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI174 ,Pin 174 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI175 ,Pin 175 data in" "L,H"
group.long 0xC3F908b0++0x03
  line.long    0x00 "176-179,GPIO Pin Data In Register 176-179"
  bitfld.long  0x00 24.                  "PDI176 ,Pin 176 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI177 ,Pin 177 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI178 ,Pin 178 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI179 ,Pin 179 data in" "L,H"
group.long 0xC3F908b4++0x03
  line.long    0x00 "180-183,GPIO Pin Data In Register 180-183"
  bitfld.long  0x00 24.                  "PDI180 ,Pin 180 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI181 ,Pin 181 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI182 ,Pin 182 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI183 ,Pin 183 data in" "L,H"
group.long 0xC3F908b8++0x03
  line.long    0x00 "184-187,GPIO Pin Data In Register 184-187"
  bitfld.long  0x00 24.                  "PDI184 ,Pin 184 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI185 ,Pin 185 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI186 ,Pin 186 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI187 ,Pin 187 data in" "L,H"
group.long 0xC3F908bc++0x03
  line.long    0x00 "188-191,GPIO Pin Data In Register 188-191"
  bitfld.long  0x00 24.                  "PDI188 ,Pin 188 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI189 ,Pin 189 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI190 ,Pin 190 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI191 ,Pin 191 data in" "L,H"
group.long 0xC3F908c0++0x03
  line.long    0x00 "192-195,GPIO Pin Data In Register 192-195"
  bitfld.long  0x00 24.                  "PDI192 ,Pin 192 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI193 ,Pin 193 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI194 ,Pin 194 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI195 ,Pin 195 data in" "L,H"
group.long 0xC3F908c4++0x03
  line.long    0x00 "196-199,GPIO Pin Data In Register 196-199"
  bitfld.long  0x00 24.                  "PDI196 ,Pin 196 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI197 ,Pin 197 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI198 ,Pin 198 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI199 ,Pin 199 data in" "L,H"
group.long 0xC3F908c8++0x03
  line.long    0x00 "200-203,GPIO Pin Data In Register 200-203"
  bitfld.long  0x00 24.                  "PDI200 ,Pin 200 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI201 ,Pin 201 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI202 ,Pin 202 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI203 ,Pin 203 data in" "L,H"
group.long 0xC3F908cc++0x03
  line.long    0x00 "204-207,GPIO Pin Data In Register 204-207"
  bitfld.long  0x00 24.                  "PDI204 ,Pin 204 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI205 ,Pin 205 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI206 ,Pin 206 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI207 ,Pin 207 data in" "L,H"
group.long 0xC3F908d0++0x03
  line.long    0x00 "208-211,GPIO Pin Data In Register 208-211"
  bitfld.long  0x00 24.                  "PDI208 ,Pin 208 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI209 ,Pin 209 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI210 ,Pin 210 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI211 ,Pin 211 data in" "L,H"
group.long 0xC3F908d4++0x03
  line.long    0x00 "212-215,GPIO Pin Data In Register 212-215"
  bitfld.long  0x00 24.                  "PDI212 ,Pin 212 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI213 ,Pin 213 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI214 ,Pin 214 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI215 ,Pin 215 data in" "L,H"
tree.end

tree "IMUX Select Registers"

sif (CPU()=="MPC5554")||(CPU()=="MPC5566")
 group.long 0xC3F90900++0x03
   line.long    0x00 "ETISR,eQADC trigger input select register"
   bitfld.long  0x00 30.--31.             "TSEL5 ,eQADC trigger input select 5"   "GPIO207,ETPUA26 channel,EMIOS12 channel,ETRIG1 pin"
   bitfld.long  0x00 28.--29.             "  TSEL4 ,eQADC trigger input select 4" "GPIO206,ETPUA27 channel,EMIOS13 channel,ETRIG0 pin"
 TEXTLINE "                   "
   bitfld.long  0x00 26.--27.             "  TSEL3 ,eQADC trigger input select 3" "GPIO207,ETPUA28 channel,EMIOS14 channel,ETRIG1 pin"
   bitfld.long  0x00 24.--25.             "  TSEL2 ,eQADC trigger input select 2" "GPIO206,ETPUA29 channel,EMIOS15 channel,ETRIG0 pin"
 TEXTLINE "                   "
   bitfld.long  0x00 22.--23.             "  TSEL1 ,eQADC trigger input select 1" "GPIO207,ETPUA31 channel,EMIOS11 channel,ETRIG1 pin"
   bitfld.long  0x00 20.--21.             "  TSEL0 ,eQADC trigger input select 0" "GPIO206,ETPUA30 channel,EMIOS10 channel,ETRIG0 pin"
 TEXTLINE ""
 group.long 0xC3F90904++0x03
   line.long    0x00 "EIISR,External IRQ input select register"
   bitfld.long  0x00 30.--31.             "ESEL15 ,External IRQ input select 15"   "IRQ15 pin,DSPI_B15,DSPI_C00,DSPI_D01"
   bitfld.long  0x00 28.--29.             "  ESEL14 ,External IRQ input select 14" "IRQ14 pin,DSPI_B14,DSPI_C15,DSPI_D00"
   bitfld.long  0x00 26.--27.             "  ESEL13 ,External IRQ input select 13" "IRQ13 pin,DSPI_B13,DSPI_C14,DSPI_D15"
   bitfld.long  0x00 24.--25.             "  ESEL12 ,External IRQ input select 12" "IRQ12 pin,DSPI_B12,DSPI_C13,DSPI_D14"
 TEXTLINE "                   "
   bitfld.long  0x00 22.--23.             "  ESEL11 ,External IRQ input select 11" "IRQ11 pin,DSPI_B11,DSPI_C12,DSPI_D13"
   bitfld.long  0x00 20.--21.             "  ESEL10 ,External IRQ input select 10" "IRQ10 pin,DSPI_B10,DSPI_C11,DSPI_D12"
   bitfld.long  0x00 18.--19.             "  ESEL09 ,External IRQ input select 09" "IRQ09 pin,DSPI_B09,DSPI_C10,DSPI_D11"
   bitfld.long  0x00 16.--17.             "  ESEL08 ,External IRQ input select 08" "IRQ08 pin,DSPI_B08,DSPI_C09,DSPI_D10"
 TEXTLINE "                   "
   bitfld.long  0x00 14.--15.             "  ESEL07 ,External IRQ input select 07" "IRQ07 pin,DSPI_B07,DSPI_C08,DSPI_D09"
   bitfld.long  0x00 12.--13.             "  ESEL06 ,External IRQ input select 06" "IRQ06 pin,DSPI_B06,DSPI_C07,DSPI_D08"
   bitfld.long  0x00 10.--11.             "  ESEL05 ,External IRQ input select 05" "IRQ05 pin,DSPI_B05,DSPI_C06,DSPI_D07"
   bitfld.long  0x00 08.--09.             "  ESEL04 ,External IRQ input select 04" "IRQ04 pin,DSPI_B04,DSPI_C05,DSPI_D06"
 TEXTLINE "                   "
   bitfld.long  0x00 06.--07.             "  ESEL03 ,External IRQ input select 03" "IRQ03 pin,DSPI_B03,DSPI_C04,DSPI_D05"
   bitfld.long  0x00 04.--05.             "  ESEL02 ,External IRQ input select 02" "IRQ02 pin,DSPI_B02,DSPI_C03,DSPI_D04"
   bitfld.long  0x00 02.--03.             "  ESEL01 ,External IRQ input select 01" "IRQ01 pin,DSPI_B01,DSPI_C02,EMIOS_15"
   bitfld.long  0x00 00.--01.             "  ESEL00 ,External IRQ input select 00" "IRQ00 pin,DSPI_B00,DSPI_C01,EMIOS_14"
 TEXTLINE ""
 group.long 0xC3F90908++0x03
   line.long    0x00 "DISR,DSPI input select register"
   bitfld.long  0x00 30.--31.             "SINSELA ,DSPI_A data input select" "SINA_GPIO94 pin       ,SOUTB,SOUTC,SOUTD"
   bitfld.long  0x00 28.--29.             "  SSSELA ,DSPI_A slave select input select" "PCSA0_GPIO96 pin       ,PCSB0,PCSC0,PCSD0"
   bitfld.long  0x00 26.--27.             "  SCKSELA ,DSPI_A clock input select" "SCKA_GPIO93 pin       ,SCKB,SCKC,SCKD"
   bitfld.long  0x00 24.--25.             "  TRIGSELA ,DSPI_A trigger input select" "res.,PCSB4,PCSC4,PCSD4"
 TEXTLINE "                   "
   bitfld.long  0x00 22.--23.             "  SINSELB ,DSPI_B data input select" "SINB_PCSC2_GPIO103 pin,SOUTA,SOUTC,SOUTD"
   bitfld.long  0x00 20.--21.             "  SSSELB ,DSPI_B slave select input select" "PCSB0_PCSD2_GPIO105 pin,PCSA0,PCSC0,PCSD0"
   bitfld.long  0x00 18.--19.             "  SCKSELB ,DSPI_B clock input select" "SCKB_PCSC1_GPIO102 pin,SCKA,SCKC,SCKD"
   bitfld.long  0x00 16.--17.             "  TRIGSELB ,DSPI_B trigger input select" "res.,PCSA4,PCSC4,PCSD4"
 TEXTLINE "                   "
   bitfld.long  0x00 14.--15.             "  SINSELC ,DSPI_C data input select" "PCSA2_SINC_GPIO108 pin,SOUTA,SOUTB,SOUTD"
   bitfld.long  0x00 12.--13.             "  SSSELC ,DSPI_C slave select input select" "PCSB5_PCSC0_GPIO110 pin,PCSA0,PCSB0,PCSD0"
    bitfld.long  0x00 10.--11.             "  SCKSELC ,DSPI_C clock input select" "PCSB4_SCKC_GPIO109 pin,SCKA,SCKB,SCKD"
   bitfld.long  0x00 08.--09.             "  TRIGSELC ,DSPI_C trigger input select" "res.,PCSA4,PCSB4,PCSD4"
 TEXTLINE "                   "
   bitfld.long  0x00 06.--07.             "  SINSELD ,DSPI_D data input select"  "PCSA3_SIND_GPIO99 pin ,SOUTA,SOUTB,SOUTC"
   bitfld.long  0x00 04.--05.             "  SSSELD ,DSPI_D slave select input select" "PCSB1_PCSD0_GPIO106 pin,PCSA0,PCSB0,PCSC0"
   bitfld.long  0x00 02.--03.             "  SCKSELD ,DSPI_D clock input select" "PCSA2_SCKD_GPIO98 pin ,SCKA,SCKB,SCKC"
   bitfld.long  0x00 00.--01.             "  TRIGSELD ,DSPI_D trigger input select" "res.,PCSA4,PCSB4,PCSC4"
elif (CPU()=="MPC5553")||(CPU()=="MPC5565")
 group.long 0xC3F90900++0x03
   line.long    0x00 "ETISR,eQADC trigger input select register"
   bitfld.long  0x00 30.--31.             "TSEL5 ,eQADC trigger input select 5"   "GPIO207,ETPUA26 channel,EMIOS12 channel,ETRIG1 pin"
   bitfld.long  0x00 28.--29.             "  TSEL4 ,eQADC trigger input select 4" "GPIO206,ETPUA27 channel,EMIOS13 channel,ETRIG0 pin"
 TEXTLINE "                   "
   bitfld.long  0x00 26.--27.             "  TSEL3 ,eQADC trigger input select 3" "GPIO207,ETPUA28 channel,EMIOS14 channel,ETRIG1 pin"
   bitfld.long  0x00 24.--25.             "  TSEL2 ,eQADC trigger input select 2" "GPIO206,ETPUA29 channel,EMIOS15 channel,ETRIG0 pin"
 TEXTLINE "                   "
   bitfld.long  0x00 22.--23.             "  TSEL1 ,eQADC trigger input select 1" "GPIO207,ETPUA31 channel,EMIOS11 channel,ETRIG1 pin"
   bitfld.long  0x00 20.--21.             "  TSEL0 ,eQADC trigger input select 0" "GPIO206,ETPUA30 channel,EMIOS10 channel,ETRIG0 pin"
 TEXTLINE ""
 group.long 0xC3F90904++0x03
   line.long    0x00 "EIISR,External IRQ input select register"
   bitfld.long  0x00 30.--31.             "ESEL15 ,External IRQ input select 15"   "IRQ15 pin,DSPI_B15,DSPI_C00,DSPI_D01"
   bitfld.long  0x00 28.--29.             "  ESEL14 ,External IRQ input select 14" "IRQ14 pin,DSPI_B14,DSPI_C15,DSPI_D00"
   bitfld.long  0x00 26.--27.             "  ESEL13 ,External IRQ input select 13" "IRQ13 pin,DSPI_B13,DSPI_C14,DSPI_D15"
   bitfld.long  0x00 24.--25.             "  ESEL12 ,External IRQ input select 12" "IRQ12 pin,DSPI_B12,DSPI_C13,DSPI_D14"
 TEXTLINE "                   "
   bitfld.long  0x00 22.--23.             "  ESEL11 ,External IRQ input select 11" "IRQ11 pin,DSPI_B11,DSPI_C12,DSPI_D13"
   bitfld.long  0x00 20.--21.             "  ESEL10 ,External IRQ input select 10" "IRQ10 pin,DSPI_B10,DSPI_C11,DSPI_D12"
   bitfld.long  0x00 18.--19.             "  ESEL09 ,External IRQ input select 09" "IRQ09 pin,DSPI_B09,DSPI_C10,DSPI_D11"
   bitfld.long  0x00 16.--17.             "  ESEL08 ,External IRQ input select 08" "IRQ08 pin,DSPI_B08,DSPI_C09,DSPI_D10"
 TEXTLINE "                   "
   bitfld.long  0x00 14.--15.             "  ESEL07 ,External IRQ input select 07" "IRQ07 pin,DSPI_B07,DSPI_C08,DSPI_D09"
   bitfld.long  0x00 12.--13.             "  ESEL06 ,External IRQ input select 06" "IRQ06 pin,DSPI_B06,DSPI_C07,DSPI_D08"
   bitfld.long  0x00 10.--11.             "  ESEL05 ,External IRQ input select 05" "IRQ05 pin,DSPI_B05,DSPI_C06,DSPI_D07"
   bitfld.long  0x00 08.--09.             "  ESEL04 ,External IRQ input select 04" "IRQ04 pin,DSPI_B04,DSPI_C05,DSPI_D06"
 TEXTLINE "                   "
   bitfld.long  0x00 06.--07.             "  ESEL03 ,External IRQ input select 03" "IRQ03 pin,DSPI_B03,DSPI_C04,DSPI_D05"
   bitfld.long  0x00 04.--05.             "  ESEL02 ,External IRQ input select 02" "IRQ02 pin,DSPI_B02,DSPI_C03,DSPI_D04"
   bitfld.long  0x00 02.--03.             "  ESEL01 ,External IRQ input select 01" "IRQ01 pin,DSPI_B01,DSPI_C02,EMIOS_15"
   bitfld.long  0x00 00.--01.             "  ESEL00 ,External IRQ input select 00" "IRQ00 pin,DSPI_B00,DSPI_C01,EMIOS_14"
 TEXTLINE ""
 group.long 0xC3F90908++0x03
   line.long    0x00 "DISR,DSPI input select register"
   bitfld.long  0x00 22.--23.               "SINSELB ,DSPI_B data input select" "SINB_PCSC2_GPIO103 pin,res.,SOUTC,SOUTD"
   bitfld.long  0x00 20.--21.             "  SSSELB ,DSPI_B slave select input select" "PCSB0_PCSD2_GPIO105 pin,res.,PCSC0,PCSD0"
   bitfld.long  0x00 18.--19.             "  SCKSELB ,DSPI_B clock input select" "SCKB_PCSC1_GPIO102 pin,res.,SCKC,SCKD"
   bitfld.long  0x00 16.--17.             "  TRIGSELB ,DSPI_B trigger input select" "res.,res.,PCSC4,PCSD4"
 TEXTLINE "                   "
   bitfld.long  0x00 14.--15.             "  SINSELC ,DSPI_C data input select" "res.,res.,SOUTB,SOUTD"
   bitfld.long  0x00 12.--13.             "  SSSELC ,DSPI_C slave select input select" "PCSB5_PCSC0_GPIO110 pin,res.,PCSB0,PCSD0"
    bitfld.long  0x00 10.--11.             "  SCKSELC ,DSPI_C clock input select" "PCSB4_SCKC_GPIO109 pin,res.,SCKB,SCKD"
   bitfld.long  0x00 08.--09.             "  TRIGSELC ,DSPI_C trigger input select" "res.,res.,PCSB4,PCSD4"
 TEXTLINE "                   "
   bitfld.long  0x00 06.--07.             "  SINSELD ,DSPI_D data input select"  "res.,res.,SOUTB,SOUTC"
   bitfld.long  0x00 04.--05.             "  SSSELD ,DSPI_D slave select input select" "PCSB1_PCSD0_GPIO106 pin,res.,PCSB0,PCSC0"
   bitfld.long  0x00 02.--03.             "  SCKSELD ,DSPI_D clock input select" "res.,res.,SCKB,SCKC"
   bitfld.long  0x00 00.--01.             "  TRIGSELD ,DSPI_D trigger input select" "res.,res.,PCSB4,PCSC4"
elif (CPU()=="MPC5533")||(CPU()=="MPC5534")
 group.long 0xC3F90900++0x03
   line.long    0x00 "ETISR,eQADC trigger input select register"
   bitfld.long  0x00 30.--31.             "TSEL5 ,eQADC trigger input select 5"   "GPIO207,ETPUA26 channel,EMIOS12 channel,ETRIG1 pin"
   bitfld.long  0x00 28.--29.             "  TSEL4 ,eQADC trigger input select 4" "GPIO206,ETPUA27 channel,EMIOS13 channel,ETRIG0 pin"
 TEXTLINE "                   "
   bitfld.long  0x00 26.--27.             "  TSEL3 ,eQADC trigger input select 3" "GPIO207,ETPUA28 channel,EMIOS14 channel,ETRIG1 pin"
   bitfld.long  0x00 24.--25.             "  TSEL2 ,eQADC trigger input select 2" "GPIO206,ETPUA29 channel,EMIOS15 channel,ETRIG0 pin"
 TEXTLINE "                   "
   bitfld.long  0x00 22.--23.             "  TSEL1 ,eQADC trigger input select 1" "GPIO207,ETPUA31 channel,EMIOS11 channel,ETRIG1 pin"
   bitfld.long  0x00 20.--21.             "  TSEL0 ,eQADC trigger input select 0" "GPIO206,ETPUA30 channel,EMIOS10 channel,ETRIG0 pin"
 TEXTLINE ""
 group.long 0xC3F90904++0x03
   line.long    0x00 "EIISR,External IRQ input select register"
   bitfld.long  0x00 30.--31.             "ESEL15 ,External IRQ input select 15"   "IRQ15 pin,DSPI_B15,DSPI_C00,DSPI_D01"
   bitfld.long  0x00 28.--29.             "  ESEL14 ,External IRQ input select 14" "IRQ14 pin,DSPI_B14,DSPI_C15,DSPI_D00"
   bitfld.long  0x00 26.--27.             "  ESEL13 ,External IRQ input select 13" "IRQ13 pin,DSPI_B13,DSPI_C14,DSPI_D15"
   bitfld.long  0x00 24.--25.             "  ESEL12 ,External IRQ input select 12" "IRQ12 pin,DSPI_B12,DSPI_C13,DSPI_D14"
 TEXTLINE "                   "
   bitfld.long  0x00 22.--23.             "  ESEL11 ,External IRQ input select 11" "IRQ11 pin,DSPI_B11,DSPI_C12,DSPI_D13"
   bitfld.long  0x00 20.--21.             "  ESEL10 ,External IRQ input select 10" "IRQ10 pin,DSPI_B10,DSPI_C11,DSPI_D12"
   bitfld.long  0x00 18.--19.             "  ESEL09 ,External IRQ input select 09" "IRQ09 pin,DSPI_B09,DSPI_C10,DSPI_D11"
   bitfld.long  0x00 16.--17.             "  ESEL08 ,External IRQ input select 08" "IRQ08 pin,DSPI_B08,DSPI_C09,DSPI_D10"
 TEXTLINE "                   "
   bitfld.long  0x00 14.--15.             "  ESEL07 ,External IRQ input select 07" "IRQ07 pin,DSPI_B07,DSPI_C08,DSPI_D09"
   bitfld.long  0x00 12.--13.             "  ESEL06 ,External IRQ input select 06" "IRQ06 pin,DSPI_B06,DSPI_C07,DSPI_D08"
   bitfld.long  0x00 10.--11.             "  ESEL05 ,External IRQ input select 05" "IRQ05 pin,DSPI_B05,DSPI_C06,DSPI_D07"
   bitfld.long  0x00 08.--09.             "  ESEL04 ,External IRQ input select 04" "IRQ04 pin,DSPI_B04,DSPI_C05,DSPI_D06"
 TEXTLINE "                   "
   bitfld.long  0x00 06.--07.             "  ESEL03 ,External IRQ input select 03" "IRQ03 pin,DSPI_B03,DSPI_C04,DSPI_D05"
   bitfld.long  0x00 04.--05.             "  ESEL02 ,External IRQ input select 02" "IRQ02 pin,DSPI_B02,DSPI_C03,DSPI_D04"
   bitfld.long  0x00 02.--03.             "  ESEL01 ,External IRQ input select 01" "IRQ01 pin,DSPI_B01,DSPI_C02,EMIOS_15"
   bitfld.long  0x00 00.--01.             "  ESEL00 ,External IRQ input select 00" "IRQ00 pin,DSPI_B00,DSPI_C01,EMIOS_14"
 TEXTLINE ""
 group.long 0xC3F90908++0x03
   line.long    0x00 "DISR,DSPI input select register"
   bitfld.long  0x00 22.--23.               "SINSELB ,DSPI_B data input select" "SINB_PCSC2_GPIO103 pin,res.,SOUTC,SOUTD"
   bitfld.long  0x00 20.--21.             "  SSSELB ,DSPI_B slave select input select" "PCSB0_PCSD2_GPIO105 pin,res.,PCSC0,PCSD0"
   bitfld.long  0x00 18.--19.             "  SCKSELB ,DSPI_B clock input select" "SCKB_PCSC1_GPIO102 pin,res.,SCKC,SCKD"
   bitfld.long  0x00 16.--17.             "  TRIGSELB ,DSPI_B trigger input select" "res.,res.,PCSC4,PCSD4"
 TEXTLINE "                   "
   bitfld.long  0x00 14.--15.             "  SINSELC ,DSPI_C data input select" "res.,res.,SOUTB,SOUTD"
   bitfld.long  0x00 12.--13.             "  SSSELC ,DSPI_C slave select input select" "PCSB5_PCSC0_GPIO110 pin,res.,PCSB0,PCSD0"
   bitfld.long  0x00 10.--11.             "  SCKSELC ,DSPI_C clock input select" "PCSB4_SCKC_GPIO109 pin,res.,SCKB,SCKD"
   bitfld.long  0x00 08.--09.             "  TRIGSELC ,DSPI_C trigger input select" "res.,res.,PCSB4,PCSD4"
 TEXTLINE "                   "
   bitfld.long  0x00 06.--07.             "  SINSELD ,DSPI_D data input select"  "PCSA3_SIND_GPIO99 pin,res.,SOUTB,SOUTC"
   bitfld.long  0x00 04.--05.             "  SSSELD ,DSPI_D slave select input select" "PCSB1_PCSD0_GPIO106 pin,res.,PCSB0,PCSC0"
   bitfld.long  0x00 02.--03.             "  SCKSELD ,DSPI_D clock input select" "res.,res.,SCKB,SCKC"
   bitfld.long  0x00 00.--01.             "  TRIGSELD ,DSPI_D trigger input select" "res.,res.,PCSB4,PCSC4"
elif (CPU()=="MPC5561")
 group.long 0xC3F90900++0x03
   line.long    0x00 "ETISR,eQADC trigger input select register"
   bitfld.long  0x00 30.--31.             "TSEL5 ,eQADC trigger input select 5"   "GPIO207,res.,EMIOS12 channel,ETRIG1 pin"
   bitfld.long  0x00 28.--29.             "  TSEL4 ,eQADC trigger input select 4" "GPIO206,res.,EMIOS13 channel,ETRIG0 pin"
 TEXTLINE "                   "
   bitfld.long  0x00 26.--27.             "  TSEL3 ,eQADC trigger input select 3" "GPIO207,res.,EMIOS14 channel,ETRIG1 pin"
   bitfld.long  0x00 24.--25.             "  TSEL2 ,eQADC trigger input select 2" "GPIO206,res.,EMIOS15 channel,ETRIG0 pin"
 TEXTLINE "                   "
   bitfld.long  0x00 22.--23.             "  TSEL1 ,eQADC trigger input select 1" "GPIO207,res.,EMIOS11 channel,ETRIG1 pin"
   bitfld.long  0x00 20.--21.             "  TSEL0 ,eQADC trigger input select 0" "GPIO206,res.,EMIOS10 channel,ETRIG0 pin"
 TEXTLINE ""
 group.long 0xC3F90904++0x03
   line.long    0x00 "EIISR,External IRQ input select register"
   bitfld.long  0x00 30.--31.             "ESEL15 ,External IRQ input select 15"   "IRQ15 pin,DSPI_B15,DSPI_C00,res."
   bitfld.long  0x00 28.--29.             "  ESEL14 ,External IRQ input select 14" "IRQ14 pin,DSPI_B14,DSPI_C15,res."
   bitfld.long  0x00 26.--27.             "  ESEL13 ,External IRQ input select 13" "IRQ13 pin,DSPI_B13,DSPI_C14,res."
   bitfld.long  0x00 24.--25.             "  ESEL12 ,External IRQ input select 12" "IRQ12 pin,DSPI_B12,DSPI_C13,res."
 TEXTLINE "                   "
   bitfld.long  0x00 22.--23.             "  ESEL11 ,External IRQ input select 11" "IRQ11 pin,DSPI_B11,DSPI_C12,res."
   bitfld.long  0x00 20.--21.             "  ESEL10 ,External IRQ input select 10" "IRQ10 pin,DSPI_B10,DSPI_C11,res."
   bitfld.long  0x00 18.--19.             "  ESEL09 ,External IRQ input select 09" "IRQ09 pin,DSPI_B09,DSPI_C10,res."
   bitfld.long  0x00 16.--17.             "  ESEL08 ,External IRQ input select 08" "IRQ08 pin,DSPI_B08,DSPI_C09,res."
 TEXTLINE "                   "
   bitfld.long  0x00 14.--15.             "  ESEL07 ,External IRQ input select 07" "IRQ07 pin,DSPI_B07,DSPI_C08,res."
   bitfld.long  0x00 12.--13.             "  ESEL06 ,External IRQ input select 06" "IRQ06 pin,DSPI_B06,DSPI_C07,res."
   bitfld.long  0x00 10.--11.             "  ESEL05 ,External IRQ input select 05" "IRQ05 pin,DSPI_B05,DSPI_C06,res."
   bitfld.long  0x00 08.--09.             "  ESEL04 ,External IRQ input select 04" "IRQ04 pin,DSPI_B04,DSPI_C05,res."
 TEXTLINE "                   "
   bitfld.long  0x00 06.--07.             "  ESEL03 ,External IRQ input select 03" "IRQ03 pin,DSPI_B03,DSPI_C04,res."
   bitfld.long  0x00 04.--05.             "  ESEL02 ,External IRQ input select 02" "IRQ02 pin,DSPI_B02,DSPI_C03,res."
   bitfld.long  0x00 02.--03.             "  ESEL01 ,External IRQ input select 01" "IRQ01 pin,DSPI_B01,DSPI_C02,res."
   bitfld.long  0x00 00.--01.             "  ESEL00 ,External IRQ input select 00" "IRQ00 pin,DSPI_B00,DSPI_C01,res."
 TEXTLINE ""
 group.long 0xC3F90908++0x03
   line.long    0x00 "DISR,DSPI input select register"
   bitfld.long  0x00 22.--23.               "SINSELB ,DSPI_B data input select" "SINB_PCSC2_GPIO103 pin,Reserved,Reserved,Reserved"
   bitfld.long  0x00 20.--21.             "  SSSELB ,DSPI_B slave select input select" "PCSB0_PCSD2_GPIO105 pin,Reserved,Reserved,Reserved"
   bitfld.long  0x00 18.--19.             "  SCKSELB ,DSPI_B clock input select" "SCKB_PCSC1_GPIO102 pin,Reserved,Reserved,Reserved"
   bitfld.long  0x00 16.--17.             "  TRIGSELB ,DSPI_B trigger input select" "Reserved,Reserved,Reserved,Reserved"
 TEXTLINE "                   "
   bitfld.long  0x00 14.--15.             "  SINSELC ,DSPI_C data input select" "PCSA2_SINC_GPIO108 pin,Reserved,Reserved,Reserved"
   bitfld.long  0x00 12.--13.             "  SSSELC ,DSPI_C slave select input select" "PCSB5_PCSC0_GPIO110 pin,Reserved,Reserved,Reserved"
   bitfld.long  0x00 10.--11.             "  SCKSELC ,DSPI_C clock input select" "PCSB4_SCKC_GPIO109 pin,Reserved,Reserved,Reserved"
   bitfld.long  0x00 08.--09.             "  TRIGSELC ,DSPI_C trigger input select" "Reserved,Reserved,Reserved,Reserved"
elif (CPU()=="MPC5567")
 group.long 0xC3F90900++0x03
   line.long    0x00 "ETISR,eQADC trigger input select register"
   bitfld.long  0x00 30.--31.             "TSEL5 ,eQADC trigger input select 5"   "GPIO207,ETPUA26 channel,EMIOS12 channel,ETRIG1 pin"
   bitfld.long  0x00 28.--29.             "  TSEL4 ,eQADC trigger input select 4" "GPIO206,ETPUA27 channel,EMIOS13 channel,ETRIG0 pin"
 TEXTLINE "                   "
   bitfld.long  0x00 26.--27.             "  TSEL3 ,eQADC trigger input select 3" "GPIO207,ETPUA28 channel,EMIOS14 channel,ETRIG1 pin"
   bitfld.long  0x00 24.--25.             "  TSEL2 ,eQADC trigger input select 2" "GPIO206,ETPUA29 channel,EMIOS15 channel,ETRIG0 pin"
 TEXTLINE "                   "
   bitfld.long  0x00 22.--23.             "  TSEL1 ,eQADC trigger input select 1" "GPIO207,ETPUA31 channel,EMIOS11 channel,ETRIG1 pin"
   bitfld.long  0x00 20.--21.             "  TSEL0 ,eQADC trigger input select 0" "GPIO206,ETPUA30 channel,EMIOS10 channel,ETRIG0 pin"
 TEXTLINE ""
 group.long 0xC3F90904++0x03
   line.long    0x00 "EIISR,External IRQ input select register"
   bitfld.long  0x00 30.--31.             "ESEL15 ,External IRQ input select 15"   "IRQ15 pin,DSPI_B15,DSPI_C00,DSPI_D01"
   bitfld.long  0x00 28.--29.             "  ESEL14 ,External IRQ input select 14" "IRQ14 pin,DSPI_B14,DSPI_C15,DSPI_D00"
   bitfld.long  0x00 26.--27.             "  ESEL13 ,External IRQ input select 13" "IRQ13 pin,DSPI_B13,DSPI_C14,DSPI_D15"
   bitfld.long  0x00 24.--25.             "  ESEL12 ,External IRQ input select 12" "IRQ12 pin,DSPI_B12,DSPI_C13,DSPI_D14"
 TEXTLINE "                   "
   bitfld.long  0x00 22.--23.             "  ESEL11 ,External IRQ input select 11" "IRQ11 pin,DSPI_B11,DSPI_C12,DSPI_D13"
   bitfld.long  0x00 20.--21.             "  ESEL10 ,External IRQ input select 10" "IRQ10 pin,DSPI_B10,DSPI_C11,DSPI_D12"
   bitfld.long  0x00 18.--19.             "  ESEL09 ,External IRQ input select 09" "IRQ09 pin,DSPI_B09,DSPI_C10,DSPI_D11"
   bitfld.long  0x00 16.--17.             "  ESEL08 ,External IRQ input select 08" "IRQ08 pin,DSPI_B08,DSPI_C09,DSPI_D10"
 TEXTLINE "                   "
   bitfld.long  0x00 14.--15.             "  ESEL07 ,External IRQ input select 07" "IRQ07 pin,DSPI_B07,DSPI_C08,DSPI_D09"
   bitfld.long  0x00 12.--13.             "  ESEL06 ,External IRQ input select 06" "IRQ06 pin,DSPI_B06,DSPI_C07,DSPI_D08"
   bitfld.long  0x00 10.--11.             "  ESEL05 ,External IRQ input select 05" "IRQ05 pin,DSPI_B05,DSPI_C06,DSPI_D07"
   bitfld.long  0x00 08.--09.             "  ESEL04 ,External IRQ input select 04" "IRQ04 pin,DSPI_B04,DSPI_C05,DSPI_D06"
 TEXTLINE "                   "
   bitfld.long  0x00 06.--07.             "  ESEL03 ,External IRQ input select 03" "IRQ03 pin,DSPI_B03,DSPI_C04,DSPI_D05"
   bitfld.long  0x00 04.--05.             "  ESEL02 ,External IRQ input select 02" "IRQ02 pin,DSPI_B02,DSPI_C03,DSPI_D04"
   bitfld.long  0x00 02.--03.             "  ESEL01 ,External IRQ input select 01" "IRQ01 pin,DSPI_B01,DSPI_C02,EMIOS_15"
   bitfld.long  0x00 00.--01.             "  ESEL00 ,External IRQ input select 00" "IRQ00 pin,DSPI_B00,DSPI_C01,EMIOS_14"
 TEXTLINE ""
 group.long 0xC3F90908++0x03
   line.long    0x00 "DISR,DSPI input select register"
   bitfld.long  0x00 22.--23.               "SINSELB ,DSPI_B data input select" "SINB_PCSC2_GPIO103 pin,res.,SOUTC,SOUTD"
   bitfld.long  0x00 20.--21.             "  SSSELB ,DSPI_B slave select input select" "PCSB0_PCSD2_GPIO105 pin,res.,PCSC0,PCSD0"
   bitfld.long  0x00 18.--19.             "  SCKSELB ,DSPI_B clock input select" "SCKB_PCSC1_GPIO102 pin,res.,SCKC,SCKD"
   bitfld.long  0x00 16.--17.             "  TRIGSELB ,DSPI_B trigger input select" "res.,res.,PCSC4,PCSD4"
 TEXTLINE "                   "
   bitfld.long  0x00 14.--15.             "  SINSELC ,DSPI_C data input select" "PCSA2_SINC_GPIO108 pin,res.,SOUTB,SOUTD"
   bitfld.long  0x00 12.--13.             "  SSSELC ,DSPI_C slave select input select" "PCSB5_PCSC0_GPIO110 pin,res.,PCSB0,PCSD0"
    bitfld.long  0x00 10.--11.             "  SCKSELC ,DSPI_C clock input select" "PCSB4_SCKC_GPIO109 pin,res.,SCKB,SCKD"
   bitfld.long  0x00 08.--09.             "  TRIGSELC ,DSPI_C trigger input select" "res.,res.,PCSB4,PCSD4"
 TEXTLINE "                   "
   bitfld.long  0x00 06.--07.             "  SINSELD ,DSPI_D data input select"  "PCSA3_SIND_GPIO99 pin ,res.,SOUTB,SOUTC"
   bitfld.long  0x00 04.--05.             "  SSSELD ,DSPI_D slave select input select" "PCSB1_PCSD0_GPIO106 pin,res.,PCSB0,PCSC0"
   bitfld.long  0x00 02.--03.             "  SCKSELD ,DSPI_D clock input select" "PCSA2_SCKD_GPIO98 pin ,res.,SCKB,SCKC"
   bitfld.long  0x00 00.--01.             "  TRIGSELD ,DSPI_D trigger input select" "res.,res.,PCSB4,PCSC4"
endif 

tree.end
 
tree.end

width 9.
endif

sif ((cpu()=="MPC5632M")||(cpu()=="MPC5633M")||(cpu()=="MPC5634M")||(cpu()=="SPC563M54")||(cpu()=="SPC563M60")||(cpu()=="SPC563M64"))

tree "Miscellaneous Control Module (MCM)"

group.word 0xFFF40000++0x01
  line.word    0 "PCT,Processor Core Type Register"

group.word 0xFFF40002++0x01
  line.word    0 "PLREV,SoC-defined Platform Revision"
TEXTLINE ""

group.word 0xFFF40004++0x01
  line.word    0 "PLAMC,Platform AXBS Master Configuration"
  bitfld.word  0 07.                      "    AMC7   ,a bus master connection to AXBS input port 7 is present" "0,1"
  bitfld.word  0 06.                    "  AMC6   ,a bus master connection to AXBS input port 6 is present" "0,1"
  bitfld.word  0 05.                    "  AMC5   ,a bus master connection to AXBS input port 5 is present" "0,1"
  bitfld.word  0 04.                    "  AMC4   ,a bus master connection to AXBS input port 4 is present" "0,1"
TEXTLINE "                "
  bitfld.word  0 03.                    "  AMC3   ,a bus master connection to AXBS input port 3 is present" "0,1"
  bitfld.word  0 02.                    "  AMC2   ,a bus master connection to AXBS input port 2 is present" "0,1"
  bitfld.word  0 01.                    "  AMC1   ,a bus master connection to AXBS input port 1 is present" "0,1"
  bitfld.word  0 00.                    "  AMC0   ,a bus master connection to AXBS input port 0 is present" "0,1"
TEXTLINE ""

group.word 0xFFF40006++0x01
  line.word    0 "PLASC,Platform AXBS Slave Configuration"
  bitfld.word  0 15.                      "    DP64   ,DP64 = 1 - the platform datapath width is 64 bits" "0,1"
TEXTLINE "                "
  bitfld.word  0 07.                    "  ASC7   ,a bus slave connection to AXBS input port 7 is present" "0,1"
  bitfld.word  0 06.                    "  ASC6   ,a bus slave connection to AXBS input port 6 is present" "0,1"
  bitfld.word  0 05.                    "  ASC5   ,a bus slave connection to AXBS input port 5 is present" "0,1"
  bitfld.word  0 04.                    "  ASC4   ,a bus slave connection to AXBS input port 4 is present" "0,1"
TEXTLINE "                "
  bitfld.word  0 03.                    "  ASC3   ,a bus slave connection to AXBS input port 3 is present" "0,1"
  bitfld.word  0 02.                    "  ASC2   ,a bus slave connection to AXBS input port 2 is present" "0,1"
  bitfld.word  0 01.                    "  ASC1   ,a bus slave connection to AXBS input port 1 is present" "0,1"
  bitfld.word  0 00.                    "  ASC0   ,a bus slave connection to AXBS input port 0 is present" "0,1"
TEXTLINE ""

group.long 0xFFF40008++0x03
  line.long    0 "IOPMC,IPS On-Platform Module Configuration"
  bitfld.long  0 31.                    "PMC00-03 ,an IPS module connection to decoded slot 0 is present" "0,1"
  bitfld.long  0 30.                    ",an IPS module connection to decoded slot 1 is present" "0,1"
  bitfld.long  0 29.                    ",an IPS module connection to decoded slot 2 is present" "0,1"
  bitfld.long  0 28.                    ",an IPS module connection to decoded slot 3 is present" "0,1"

  bitfld.long  0 27.                    "  PMC04-07 ,an IPS module connection to decoded slot 4 is present" "0,1"
  bitfld.long  0 26.                    ",an IPS module connection to decoded slot 5 is present" "0,1"
  bitfld.long  0 25.                    ",an IPS module connection to decoded slot 6 is present" "0,1"
  bitfld.long  0 24.                    ",an IPS module connection to decoded slot 7 is present" "0,1"

  bitfld.long  0 23.                    "  PMC08-11 ,an IPS module connection to decoded slot 8 is present" "0,1"
  bitfld.long  0 22.                    ",an IPS module connection to decoded slot 9 is present" "0,1"
  bitfld.long  0 21.                    ",an IPS module connection to decoded slot 10 is present" "0,1"
  bitfld.long  0 20.                    ",an IPS module connection to decoded slot 11 is present" "0,1"

  bitfld.long  0 19.                    "  PMC12-15 ,an IPS module connection to decoded slot 12 is present" "0,1"
  bitfld.long  0 18.                    ",an IPS module connection to decoded slot 13 is present" "0,1"
  bitfld.long  0 17.                    ",an IPS module connection to decoded slot 14 is present" "0,1"
  bitfld.long  0 16.                    ",an IPS module connection to decoded slot 15 is present" "0,1"
TEXTLINE "                  "
  bitfld.long  0 15.                    "PMC16-19 ,an IPS module connection to decoded slot 16 is present" "0,1"
  bitfld.long  0 14.                    ",an IPS module connection to decoded slot 17 is present" "0,1"
  bitfld.long  0 13.                    ",an IPS module connection to decoded slot 18 is present" "0,1"
  bitfld.long  0 12.                    ",an IPS module connection to decoded slot 19 is present" "0,1"
 
  bitfld.long  0 11.                    "  PMC20-23 ,an IPS module connection to decoded slot 20 is present" "0,1"
  bitfld.long  0 10.                    ",an IPS module connection to decoded slot 21 is present" "0,1"
  bitfld.long  0 09.                    ",an IPS module connection to decoded slot 22 is present" "0,1"
  bitfld.long  0 08.                    ",an IPS module connection to decoded slot 23 is present" "0,1"

  bitfld.long  0 07.                    "  PMC24-27 ,an IPS module connection to decoded slot 24 is present" "0,1"
  bitfld.long  0 06.                    ",an IPS module connection to decoded slot 25 is present" "0,1"
  bitfld.long  0 05.                    ",an IPS module connection to decoded slot 26 is present" "0,1"
  bitfld.long  0 04.                    ",an IPS module connection to decoded slot 27 is present" "0,1"

  bitfld.long  0 03.                    "  PMC28-31 ,an IPS module connection to decoded slot 28 is present" "0,1"
  bitfld.long  0 02.                    ",an IPS module connection to decoded slot 29 is present" "0,1"
  bitfld.long  0 01.                    ",an IPS module connection to decoded slot 30 is present" "0,1"
  bitfld.long  0 00.                    ",an IPS module connection to decoded slot 31 is present" "0,1"
TEXTLINE ""

group.byte 0xFFF4000f++0x00
  line.byte    0 "MRSR,Miscellaneous Reset Status Register"
  bitfld.byte  0 7.                      "POR   ,power-on reset" "0,1"
  bitfld.byte  0 6.                    "  OFPLR ,OFPL reset" "0,1"
  bitfld.byte  0 5.                    "  SWTR  ,software watchdog timer reset" "0,1"

group.byte 0xFFF40013++0x00
  line.byte    0 "MWCR,Miscellaneous Wakeup Control Register"
  bitfld.byte  0 7.                      "ENBWCR   ," "0,1"
  bitfld.byte  0 0.--3.                  "  PRILVL   ," "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

tree "Platform ECC Registers"

group.byte 0xFFF40043++0x00
  line.byte    0 "ECR,ECC Configuration Register"
  bitfld.byte  0 01.                    "ERNCR ,Enable RAM Non-Correctable Reporting" "0,1"
  bitfld.byte  0 00.                  "  EFNCR ,Enable Flash Non-Correctable Reporting" "0,1"

group.byte 0xFFF40047++0x00
  line.byte    0 "ESR,ECC Status Register"
  bitfld.byte  0 01.                    "RNCE  ,RAM Non-Correctable Error" "0,1"
  bitfld.byte  0 00.                  "  FNCE  ,Flash Non-Correctable Error" "0,1"
  
group.word 0xFFF4004A++0x01
  line.word    0 "EEGR,ECC Error Generation Register"
  bitfld.word  0 09.                    "FRCNCI  ,Force RAM Continuous Noncorrectable Data Inversions" "0,1"
  bitfld.word  0 08.                  "  FR1NCI  ,Force RAM One Noncorrectable Data Inversions" "0,1"
  hexmask.word 0 00.--07. 1. 0.       "  ERRBIT  ,Error Bit Position"

TEXTLINE ""

group.long 0xFFF40050++0x03
  line.long    0 "PFEAR,Platform Flash ECC Address Register"

group.byte 0xFFF40056++0x00
  line.byte    0 "PFEMR,Platform Flash ECC Master Number Register"

group.byte 0xFFF40057++0x00
  line.byte    0 "PFEAT,Platform Flash ECC Attributes Register"
  bitfld.byte  0 07.                    "Write  ,Access mode" "0,1"
  bitfld.byte  0 04.--06.             "  Size   ,Access size" "8-bit,16-bit,32-bit,64-bit,res.,res.,res.,res."
  bitfld.byte  0 03.                  "  Cachable  ,protection mode" "0,1"
  bitfld.byte  0 02.                  "  Bufferable  ,protection mode" "0,1"
  bitfld.byte  0 01.                  "  Mode  ,protection mode" "USER,SUPERVISOR"
  bitfld.byte  0 00.                  "  Access  ,protection mode" "I-Fetch,Data"

group.long 0xFFF40058++0x03
  line.long    0 "PFEDRH,Platform Flash ECC Data Register High"

group.long 0xFFF4005C++0x03
  line.long    0 "PFEDRL,Platform Flash ECC Data Register Low"

TEXTLINE ""

group.long 0xFFF40060++0x03
  line.long    0 "PREAR,Platform Ram ECC Address Register"

group.byte 0xFFF40066++0x00
  line.byte    0 "PREMR,Platform Ram ECC Master Number Register"

group.byte 0xFFF40067++0x00
  line.byte    0 "PREAT,Platform Ram ECC Attributes Register"
  bitfld.byte  0 07.                    "Write  ,Access mode" "0,1"
  bitfld.byte  0 04.--06.             "  Size   ,Access size" "8-bit,16-bit,32-bit,64-bit,res.,res.,res.,res."
  bitfld.byte  0 03.                  "  Cachable  ,protection mode" "0,1"
  bitfld.byte  0 02.                  "  Bufferable  ,protection mode" "0,1"
  bitfld.byte  0 01.                  "  Mode  ,protection mode" "USER,SUPERVISOR"
  bitfld.byte  0 00.                  "  Access  ,protection mode" "I-Fetch,Data"

group.long 0xFFF40068++0x03
  line.long    0 "PREDRH,Platform Ram ECC Data Register High"

group.long 0xFFF4006C++0x03
  line.long    0 "PREDRL,Platform Ram ECC Data Register Low"

tree.end

tree.end

else
tree "Error Correction Status Module (ECSM)"

group.word 0xfff40016++0x01
  line.word    0x00 "SWTCR,Software watchdog timer control register"

wgroup.byte 0xfff4001b++0x00
  hide.byte    0x00 "SWTSR,Software watchdog timer service register"
  in

group.byte 0xfff4001f++0x00
  line.byte    0x00 "SWTIR,Software watchdog timer interrupt register"

TEXTLINE ""

group.byte 0xfff40043++0x00
  line.byte    0x00 "ECR,ECC Configuration Register"
  bitfld.byte  0x00 01.                  "      ERNCR  ,Enable RAM non-correctable reporting" "0,1"
  bitfld.byte  0x00 00.                  "  EFNCR  ,Enable Flash non-correctable reporting" "0,1"

group.byte 0xfff40047++0x00
  line.byte    0x00 "ESR,ECC Status Register"
  eventfld.byte  0x00 01.                  "      RNCE   ,RAM non-correctable error" "0,1"
  eventfld.byte  0x00 00.                  "  FNCE   ,Flash non-correctable error" "0,1"

group.word 0xfff4004a++0x01
  line.word    0x00 "EEGR,ECC Error Generation Register"
  bitfld.word  0x00 09.                  "      FRCNCI ,Force RAM continuous noncorrectable data inversions" "0,1"
  bitfld.word  0x00 08.                  "  FR1NCI ,Force RAM one noncorrectable data inversions" "0,1"
  hexmask.byte 0x01 00.--06. 1.          "  ERRBIT ,Error Bit Position"

group.long 0xfff40050++0x03
  line.long    0x00 "FEAR,Flash ECC Address Register"

group.byte 0xfff40056++0x00
  line.byte    0x00 "FEMR,Flash ECC Master Number Register"
  hexmask.byte 0x00 00.--03. 1.          "      FEMR  ,flash ECC master number"

group.byte 0xfff40057++0x00
  line.byte    0x00 "FEAT,Flash ECC Attributes Register"
  bitfld.byte  0x00 07.                  "      WRITE  ,Write access" "0,1"
  bitfld.byte  0x00 04.--06.             "  SIZE  ,Size" "8 bit,16 bit,32 bit,64 bit,res.,res.,res.,res."
  bitfld.byte  0x00 03.                  "  P[C]  ,Cacheable" "0,1"
  bitfld.byte  0x00 02.                  "  P[B]  ,Bufferable" "0,1"
  bitfld.byte  0x00 01.                  "  P[M]  ,Supervisor Mode" "U,S"
  bitfld.byte  0x00 00.                  "  P[T]  ,I-Fetch/Data" "I,D"

group.long 0xfff40058++0x03
  line.long    0x00 "FEDRH,Flash ECC Data Register"

group.long 0xfff4005C++0x03
  line.long    0x00 "FEDRL,Flash ECC Data Register"

group.long 0xfff40060++0x03
  line.long    0x00 "REAR,RAM ECC Address Register"

group.byte 0xfff40066++0x00
  line.byte    0x00 "REMR,RAM ECC Master Number"
  hexmask.byte 0x00 00.--03. 1.          "      REMR  ,flash ECC master number"

group.byte 0xfff40067++0x00
  line.byte    0x00 "REAT,RAM ECC Attributes Register"
  bitfld.byte  0x00 07.                  "      WRITE  ,Write access" "0,1"
  bitfld.byte  0x00 04.--06.             "  SIZE  ,Size" "8 bit,16 bit,32 bit,64 bit,res.,res.,res.,res."
  bitfld.byte  0x00 03.                  "  P[C]  ,Cacheable" "0,1"
  bitfld.byte  0x00 02.                  "  P[B]  ,Bufferable" "0,1"
  bitfld.byte  0x00 01.                  "  P[M]  ,Supervisor Mode" "U,S"
  bitfld.byte  0x00 00.                  "  P[T]  ,I-Fetch/Data" "I,D"

group.long 0xfff40068++0x03
  line.long    0x00 "REDRH,RAM ECC Data Register"

group.long 0xfff4006C++0x03
  line.long    0x00 "REDRL,RAM ECC Data Register"


tree.end

endif



sif ((cpu()=="MPC5554")||(cpu()=="MPC5566"))
tree "Enhanced Direct Memory Access (eDMA)  "


group.long (0xfff44000+0x0000)++0x03
  line.long 0x00 "CR,eDMA Control Register"
  bitfld.long  0x00 14.--15.              "GRP3PRI ,Channel group 3 priority." "0,1,2,3"
  bitfld.long  0x00 12.--13.              "  GRP2PRI ,Channel group 2 priority." "0,1,2,3"
  bitfld.long  0x00 10.--11.              "  GRP1PRI ,Channel group 1 priority." "0,1,2,3"
  bitfld.long  0x00 08.--09.              "  GRP0PRI ,Channel group 0 priority." "0,1,2,3"
  TEXTLINE "                "
  bitfld.long  0x00 03.                   "  ERGA    ,Enable round robin group arbitration" "0,1"
  bitfld.long  0x00 02.                   "  ERCA    ,Enable round robin channel arbitration" "0,1"
  bitfld.long  0x00 01.                   "  EDBG    ,Enable debug" "0,1"
;  bitfld.long  0x00 00.                   "  EBW     ,Enable buffered writes" "0,1"

TEXTLINE ""

group.long (0xfff44000+0x0004)++0x03
  line.long 0x00 "ESR,eDMA Error Status Register"
  bitfld.long  0x00 31.              "VLD ,Logical OR of all EDMA_ERRH and EDMA_ERRL status bits" "0,1"
  bitfld.long  0x00 15.              "  GPE ,Group priority error" "0,1"
  bitfld.long  0x00 14.              "  CPE ,Channel priority error" "0,1"
  hexmask.long 0x00 08.--13.  1.     "  ERRCHN ,Error channel number"
  TEXTLINE "                "
  bitfld.long  0x00 07.              "  SAE ,Source address error" "0,1"
  bitfld.long  0x00 06.              "  SOE ,Source offset error" "0,1"
  bitfld.long  0x00 05.              "  DAE ,Destination address error" "0,1"
  bitfld.long  0x00 04.              "  DOE ,Destination offset error" "0,1"
  bitfld.long  0x00 03.              "  NCE ,Nbytes/CITER configuration error" "0,1"
  bitfld.long  0x00 02.              "  SGE ,Scatter/gather configuration error" "0,1"
  bitfld.long  0x00 01.              "  SBE ,Source bus error" "0,1"
  bitfld.long  0x00 00.              "  DBE ,Destination bus error" "0,1"
  
TEXTLINE ""
  
group.long (0xfff44000+0x0008)++0x03
  line.long 0x00 "ERQRH,eDMA Enable Request Register H"
  bitfld.long  0x00 31.              "ERQ63-60 ,Enable DMA Request 63" "0,1"
  bitfld.long  0x00 30.              ",Enable DMA Request 62" "0,1"
  bitfld.long  0x00 29.              ",Enable DMA Request 61" "0,1"
  bitfld.long  0x00 28.              ",Enable DMA Request 60" "0,1"
  
  bitfld.long  0x00 27.              "  ERQ59-56 ,Enable DMA Request 59" "0,1"
  bitfld.long  0x00 26.              ",Enable DMA Request 58" "0,1"
  bitfld.long  0x00 25.              ",Enable DMA Request 57" "0,1"
  bitfld.long  0x00 24.              ",Enable DMA Request 56" "0,1"
  
  bitfld.long  0x00 23.              "  ERQ55-52 ,Enable DMA Request 55" "0,1"
  bitfld.long  0x00 22.              ",Enable DMA Request 54" "0,1"
  bitfld.long  0x00 21.              ",Enable DMA Request 53" "0,1"
  bitfld.long  0x00 20.              ",Enable DMA Request 52" "0,1"
  
  bitfld.long  0x00 19.              "  ERQ51-48 ,Enable DMA Request 51" "0,1"
  bitfld.long  0x00 18.              ",Enable DMA Request 50" "0,1"
  bitfld.long  0x00 17.              ",Enable DMA Request 49" "0,1"
  bitfld.long  0x00 16.              ",Enable DMA Request 48" "0,1"
  TEXTLINE "                  "
  bitfld.long  0x00 15.              "ERQ47-44 ,Enable DMA Request 47" "0,1"
  bitfld.long  0x00 14.              ",Enable DMA Request 46" "0,1"
  bitfld.long  0x00 13.              ",Enable DMA Request 45" "0,1"
  bitfld.long  0x00 12.              ",Enable DMA Request 44" "0,1"
  
  bitfld.long  0x00 11.              "  ERQ43-40 ,Enable DMA Request 43" "0,1"
  bitfld.long  0x00 10.              ",Enable DMA Request 42" "0,1"
  bitfld.long  0x00 09.              ",Enable DMA Request 41" "0,1"
  bitfld.long  0x00 08.              ",Enable DMA Request 40" "0,1"
  
  bitfld.long  0x00 07.              "  ERQ39-36 ,Enable DMA Request 39" "0,1"
  bitfld.long  0x00 06.              ",Enable DMA Request 38" "0,1"
  bitfld.long  0x00 05.              ",Enable DMA Request 37" "0,1"
  bitfld.long  0x00 04.              ",Enable DMA Request 36" "0,1"
  
  bitfld.long  0x00 03.              "  ERQ35-32 ,Enable DMA Request 35" "0,1"
  bitfld.long  0x00 02.              ",Enable DMA Request 34" "0,1"
  bitfld.long  0x00 01.              ",Enable DMA Request 33" "0,1"
  bitfld.long  0x00 00.              ",Enable DMA Request 32" "0,1"

  
group.long (0xfff44000+0x000C)++0x03
  line.long 0x00 "ERQRL,eDMA Enable Request Register L"
  bitfld.long  0x00 31.              "ERQ31-28 ,Enable DMA Request 31" "0,1"
  bitfld.long  0x00 30.              ",Enable DMA Request 30" "0,1"
  bitfld.long  0x00 29.              ",Enable DMA Request 29" "0,1"
  bitfld.long  0x00 28.              ",Enable DMA Request 28" "0,1"
  
  bitfld.long  0x00 27.              "  ERQ27-24 ,Enable DMA Request 27" "0,1"
  bitfld.long  0x00 26.              ",Enable DMA Request 26" "0,1"
  bitfld.long  0x00 25.              ",Enable DMA Request 25" "0,1"
  bitfld.long  0x00 24.              ",Enable DMA Request 24" "0,1"
  
  bitfld.long  0x00 23.              "  ERQ23-20 ,Enable DMA Request 23" "0,1"
  bitfld.long  0x00 22.              ",Enable DMA Request 22" "0,1"
  bitfld.long  0x00 21.              ",Enable DMA Request 21" "0,1"
  bitfld.long  0x00 20.              ",Enable DMA Request 20" "0,1"
  
  bitfld.long  0x00 19.              "  ERQ19-16 ,Enable DMA Request 19" "0,1"
  bitfld.long  0x00 18.              ",Enable DMA Request 18" "0,1"
  bitfld.long  0x00 17.              ",Enable DMA Request 17" "0,1"
  bitfld.long  0x00 16.              ",Enable DMA Request 16" "0,1"
  TEXTLINE "                  "
  bitfld.long  0x00 15.              "ERQ15-12 ,Enable DMA Request 15" "0,1"
  bitfld.long  0x00 14.              ",Enable DMA Request 14" "0,1"
  bitfld.long  0x00 13.              ",Enable DMA Request 13" "0,1"
  bitfld.long  0x00 12.              ",Enable DMA Request 12" "0,1"
  
  bitfld.long  0x00 11.              "  ERQ11-08 ,Enable DMA Request 11" "0,1"
  bitfld.long  0x00 10.              ",Enable DMA Request 10" "0,1"
  bitfld.long  0x00 09.              ",Enable DMA Request 09" "0,1"
  bitfld.long  0x00 08.              ",Enable DMA Request 08" "0,1"
  
  bitfld.long  0x00 07.              "  ERQ07-04 ,Enable DMA Request 07" "0,1"
  bitfld.long  0x00 06.              ",Enable DMA Request 06" "0,1"
  bitfld.long  0x00 05.              ",Enable DMA Request 05" "0,1"
  bitfld.long  0x00 04.              ",Enable DMA Request 04" "0,1"
  
  bitfld.long  0x00 03.              "  ERQ03-00 ,Enable DMA Request 03" "0,1"
  bitfld.long  0x00 02.              ",Enable DMA Request 02" "0,1"
  bitfld.long  0x00 01.              ",Enable DMA Request 01" "0,1"
  bitfld.long  0x00 00.              ",Enable DMA Request 00" "0,1"

  
TEXTLINE ""
  
group.long (0xfff44000+0x0010)++0x03
  line.long 0x00 "EEIRH,eDMA Enable Error Interrupt Register H"
  bitfld.long  0x00 31.              "EEI63-60 ,Enable error interrupt 63" "0,1"
  bitfld.long  0x00 30.              ",Enable error interrupt 62" "0,1"
  bitfld.long  0x00 29.              ",Enable error interrupt 61" "0,1"
  bitfld.long  0x00 28.              ",Enable error interrupt 60" "0,1"
  
  bitfld.long  0x00 27.              "  EEI59-56 ,Enable error interrupt 59" "0,1"
  bitfld.long  0x00 26.              ",Enable error interrupt 58" "0,1"
  bitfld.long  0x00 25.              ",Enable error interrupt 57" "0,1"
  bitfld.long  0x00 24.              ",Enable error interrupt 56" "0,1"
  
  bitfld.long  0x00 23.              "  EEI55-52 ,Enable error interrupt 55" "0,1"
  bitfld.long  0x00 22.              ",Enable error interrupt 54" "0,1"
  bitfld.long  0x00 21.              ",Enable error interrupt 53" "0,1"
  bitfld.long  0x00 20.              ",Enable error interrupt 52" "0,1"
  
  bitfld.long  0x00 19.              "  EEI51-48 ,Enable error interrupt 51" "0,1"
  bitfld.long  0x00 18.              ",Enable error interrupt 50" "0,1"
  bitfld.long  0x00 17.              ",Enable error interrupt 49" "0,1"
  bitfld.long  0x00 16.              ",Enable error interrupt 48" "0,1"
  TEXTLINE "                  "
  bitfld.long  0x00 15.              "EEI47-44 ,Enable error interrupt 47" "0,1"
  bitfld.long  0x00 14.              ",Enable error interrupt 46" "0,1"
  bitfld.long  0x00 13.              ",Enable error interrupt 45" "0,1"
  bitfld.long  0x00 12.              ",Enable error interrupt 44" "0,1"
  
  bitfld.long  0x00 11.              "  EEI43-40 ,Enable error interrupt 43" "0,1"
  bitfld.long  0x00 10.              ",Enable error interrupt 42" "0,1"
  bitfld.long  0x00 09.              ",Enable error interrupt 41" "0,1"
  bitfld.long  0x00 08.              ",Enable error interrupt 40" "0,1"
  
  bitfld.long  0x00 07.              "  EEI39-36 ,Enable error interrupt 39" "0,1"
  bitfld.long  0x00 06.              ",Enable error interrupt 38" "0,1"
  bitfld.long  0x00 05.              ",Enable error interrupt 37" "0,1"
  bitfld.long  0x00 04.              ",Enable error interrupt 36" "0,1"
  
  bitfld.long  0x00 03.              "  EEI35-32 ,Enable error interrupt 35" "0,1"
  bitfld.long  0x00 02.              ",Enable error interrupt 34" "0,1"
  bitfld.long  0x00 01.              ",Enable error interrupt 33" "0,1"
  bitfld.long  0x00 00.              ",Enable error interrupt 32" "0,1"

  
group.long (0xfff44000+0x0014)++0x03
  line.long 0x00 "EEIRL,eDMA Enable Error Interrupt Register L"
  bitfld.long  0x00 31.              "EEI31-28 ,Enable error interrupt 31" "0,1"
  bitfld.long  0x00 30.              ",Enable error interrupt 30" "0,1"
  bitfld.long  0x00 29.              ",Enable error interrupt 29" "0,1"
  bitfld.long  0x00 28.              ",Enable error interrupt 28" "0,1"
  
  bitfld.long  0x00 27.              "  EEI27-24 ,Enable error interrupt 27" "0,1"
  bitfld.long  0x00 26.              ",Enable error interrupt 26" "0,1"
  bitfld.long  0x00 25.              ",Enable error interrupt 25" "0,1"
  bitfld.long  0x00 24.              ",Enable error interrupt 24" "0,1"
  
  bitfld.long  0x00 23.              "  EEI23-20 ,Enable error interrupt 23" "0,1"
  bitfld.long  0x00 22.              ",Enable error interrupt 22" "0,1"
  bitfld.long  0x00 21.              ",Enable error interrupt 21" "0,1"
  bitfld.long  0x00 20.              ",Enable error interrupt 20" "0,1"
  
  bitfld.long  0x00 19.              "  EEI19-16 ,Enable error interrupt 19" "0,1"
  bitfld.long  0x00 18.              ",Enable error interrupt 18" "0,1"
  bitfld.long  0x00 17.              ",Enable error interrupt 17" "0,1"
  bitfld.long  0x00 16.              ",Enable error interrupt 16" "0,1"
  TEXTLINE "                  "
  bitfld.long  0x00 15.              "EEI15-12 ,Enable error interrupt 15" "0,1"
  bitfld.long  0x00 14.              ",Enable error interrupt 14" "0,1"
  bitfld.long  0x00 13.              ",Enable error interrupt 13" "0,1"
  bitfld.long  0x00 12.              ",Enable error interrupt 12" "0,1"
  
  bitfld.long  0x00 11.              "  EEI11-08 ,Enable error interrupt 11" "0,1"
  bitfld.long  0x00 10.              ",Enable error interrupt 10" "0,1"
  bitfld.long  0x00 09.              ",Enable error interrupt 09" "0,1"
  bitfld.long  0x00 08.              ",Enable error interrupt 08" "0,1"
  
  bitfld.long  0x00 07.              "  EEI07-04 ,Enable error interrupt 07" "0,1"
  bitfld.long  0x00 06.              ",Enable error interrupt 06" "0,1"
  bitfld.long  0x00 05.              ",Enable error interrupt 05" "0,1"
  bitfld.long  0x00 04.              ",Enable error interrupt 04" "0,1"
  
  bitfld.long  0x00 03.              "  EEI03-00 ,Enable error interrupt 03" "0,1"
  bitfld.long  0x00 02.              ",Enable error interrupt 02" "0,1"
  bitfld.long  0x00 01.              ",Enable error interrupt 01" "0,1"
  bitfld.long  0x00 00.              ",Enable error interrupt 00" "0,1"

TEXTLINE ""

group.byte (0xfff44000+0x0018)++0x03
  line.byte 0x00 "SERQR,eDMA Set Enable Request Register"
  hexmask.byte 0x00 00.--06.  1.     "    SERQ ,Set Enable Request"
  
group.byte (0xfff44000+0x0019)++0x03
  line.byte 0x00 "CERQR,eDMA Clear Enable Request Register"
  hexmask.byte 0x00 00.--06.  1.     "    CERQ ,Clear Enable Request"
  
group.byte (0xfff44000+0x001A)++0x03
  line.byte 0x00 "SEEIR,eDMA Set Enable Error Interrupt Register"
  hexmask.byte 0x00 00.--06.  1.     "    SEEI ,Set enable error interrupt"
  
group.byte (0xfff44000+0x001B)++0x03
  line.byte 0x00 "CEEIR,eDMA Clear Enable Error Interrupt Register"
  hexmask.byte 0x00 00.--06.  1.     "    CEEI ,eDMA Clear Enable Error Interrupt Register"
  
group.byte (0xfff44000+0x001C)++0x03
  line.byte 0x00 "CIRQR,eDMA Clear Interrupt Request Register"
  hexmask.byte 0x00 00.--06.  1.     "    CINT ,Clear interrupt request"
  
group.byte (0xfff44000+0x001D)++0x03
  line.byte 0x00 "CER,eDMA Clear Error Register"
  hexmask.byte 0x00 00.--06.  1.     "    CERR ,Clear error indicator"
  
group.byte (0xfff44000+0x001E)++0x03
  line.byte 0x00 "SSBR,eDMA Set START Bit Register"
  hexmask.byte 0x00 00.--06.  1.     "    SSB  ,Set START bit"
  
group.byte (0xfff44000+0x001F)++0x03
  line.byte 0x00 "CDSBR,eDMA Clear DONE Status Bit Register"
  hexmask.byte 0x00 00.--06.  1.     "    CDSB ,Clear DONE status bit"
  
  
TEXTLINE ""
  
group.long (0xfff44000+0x0020)++0x03
  line.long 0x00 "IRQRH,eDMA Interrupt Request Register H"
  bitfld.long  0x00 31.              "INT63-60 ,eDMA interrupt request 63" "0,1"
  bitfld.long  0x00 30.              ",eDMA interrupt request 62" "0,1"
  bitfld.long  0x00 29.              ",eDMA interrupt request 61" "0,1"
  bitfld.long  0x00 28.              ",eDMA interrupt request 60" "0,1"
  
  bitfld.long  0x00 27.              "  INT59-56 ,eDMA interrupt request 59" "0,1"
  bitfld.long  0x00 26.              ",eDMA interrupt request 58" "0,1"
  bitfld.long  0x00 25.              ",eDMA interrupt request 57" "0,1"
  bitfld.long  0x00 24.              ",eDMA interrupt request 56" "0,1"
  
  bitfld.long  0x00 23.              "  INT55-52 ,eDMA interrupt request 55" "0,1"
  bitfld.long  0x00 22.              ",eDMA interrupt request 54" "0,1"
  bitfld.long  0x00 21.              ",eDMA interrupt request 53" "0,1"
  bitfld.long  0x00 20.              ",eDMA interrupt request 52" "0,1"
  
  bitfld.long  0x00 19.              "  INT51-48 ,eDMA interrupt request 51" "0,1"
  bitfld.long  0x00 18.              ",eDMA interrupt request 50" "0,1"
  bitfld.long  0x00 17.              ",eDMA interrupt request 49" "0,1"
  bitfld.long  0x00 16.              ",eDMA interrupt request 48" "0,1"
  TEXTLINE "                  "
  bitfld.long  0x00 15.              "INT47-44 ,eDMA interrupt request 47" "0,1"
  bitfld.long  0x00 14.              ",eDMA interrupt request 46" "0,1"
  bitfld.long  0x00 13.              ",eDMA interrupt request 45" "0,1"
  bitfld.long  0x00 12.              ",eDMA interrupt request 44" "0,1"
  
  bitfld.long  0x00 11.              "  INT43-40 ,eDMA interrupt request 43" "0,1"
  bitfld.long  0x00 10.              ",eDMA interrupt request 42" "0,1"
  bitfld.long  0x00 09.              ",eDMA interrupt request 41" "0,1"
  bitfld.long  0x00 08.              ",eDMA interrupt request 40" "0,1"
  
  bitfld.long  0x00 07.              "  INT39-36 ,eDMA interrupt request 39" "0,1"
  bitfld.long  0x00 06.              ",eDMA interrupt request 38" "0,1"
  bitfld.long  0x00 05.              ",eDMA interrupt request 37" "0,1"
  bitfld.long  0x00 04.              ",eDMA interrupt request 36" "0,1"
  
  bitfld.long  0x00 03.              "  INT35-32 ,eDMA interrupt request 35" "0,1"
  bitfld.long  0x00 02.              ",eDMA interrupt request 34" "0,1"
  bitfld.long  0x00 01.              ",eDMA interrupt request 33" "0,1"
  bitfld.long  0x00 00.              ",eDMA interrupt request 32" "0,1"

  
group.long (0xfff44000+0x0024)++0x03
  line.long 0x00 "IRQRL,eDMA Interrupt Request Register L"
  bitfld.long  0x00 31.              "INT31-28 ,eDMA interrupt request 31" "0,1"
  bitfld.long  0x00 30.              ",eDMA interrupt request 30" "0,1"
  bitfld.long  0x00 29.              ",eDMA interrupt request 29" "0,1"
  bitfld.long  0x00 28.              ",eDMA interrupt request 28" "0,1"
  
  bitfld.long  0x00 27.              "  INT27-24 ,eDMA interrupt request 27" "0,1"
  bitfld.long  0x00 26.              ",eDMA interrupt request 26" "0,1"
  bitfld.long  0x00 25.              ",eDMA interrupt request 25" "0,1"
  bitfld.long  0x00 24.              ",eDMA interrupt request 24" "0,1"
  
  bitfld.long  0x00 23.              "  INT23-20 ,eDMA interrupt request 23" "0,1"
  bitfld.long  0x00 22.              ",eDMA interrupt request 22" "0,1"
  bitfld.long  0x00 21.              ",eDMA interrupt request 21" "0,1"
  bitfld.long  0x00 20.              ",eDMA interrupt request 20" "0,1"
  
  bitfld.long  0x00 19.              "  INT19-16 ,eDMA interrupt request 19" "0,1"
  bitfld.long  0x00 18.              ",eDMA interrupt request 18" "0,1"
  bitfld.long  0x00 17.              ",eDMA interrupt request 17" "0,1"
  bitfld.long  0x00 16.              ",eDMA interrupt request 16" "0,1"
  TEXTLINE "                  "
  bitfld.long  0x00 15.              "INT15-12 ,eDMA interrupt request 15" "0,1"
  bitfld.long  0x00 14.              ",eDMA interrupt request 14" "0,1"
  bitfld.long  0x00 13.              ",eDMA interrupt request 13" "0,1"
  bitfld.long  0x00 12.              ",eDMA interrupt request 12" "0,1"
  
  bitfld.long  0x00 11.              "  INT11-08 ,eDMA interrupt request 11" "0,1"
  bitfld.long  0x00 10.              ",eDMA interrupt request 10" "0,1"
  bitfld.long  0x00 09.              ",eDMA interrupt request 09" "0,1"
  bitfld.long  0x00 08.              ",eDMA interrupt request 08" "0,1"
  
  bitfld.long  0x00 07.              "  INT07-04 ,eDMA interrupt request 07" "0,1"
  bitfld.long  0x00 06.              ",eDMA interrupt request 06" "0,1"
  bitfld.long  0x00 05.              ",eDMA interrupt request 05" "0,1"
  bitfld.long  0x00 04.              ",eDMA interrupt request 04" "0,1"
  
  bitfld.long  0x00 03.              "  INT03-00 ,eDMA interrupt request 03" "0,1"
  bitfld.long  0x00 02.              ",eDMA interrupt request 02" "0,1"
  bitfld.long  0x00 01.              ",eDMA interrupt request 01" "0,1"
  bitfld.long  0x00 00.              ",eDMA interrupt request 00" "0,1"


TEXTLINE ""
  
group.long (0xfff44000+0x0028)++0x03
  line.long 0x00 "ERH,eDMA Error Register H"
  bitfld.long  0x00 31.              "ERR63-60 ,eDMA Error 63" "0,1"
  bitfld.long  0x00 30.              ",eDMA Error 62" "0,1"
  bitfld.long  0x00 29.              ",eDMA Error 61" "0,1"
  bitfld.long  0x00 28.              ",eDMA Error 60" "0,1"
  
  bitfld.long  0x00 27.              "  ERR59-56 ,eDMA Error 59" "0,1"
  bitfld.long  0x00 26.              ",eDMA Error 58" "0,1"
  bitfld.long  0x00 25.              ",eDMA Error 57" "0,1"
  bitfld.long  0x00 24.              ",eDMA Error 56" "0,1"
  
  bitfld.long  0x00 23.              "  ERR55-52 ,eDMA Error 55" "0,1"
  bitfld.long  0x00 22.              ",eDMA Error 54" "0,1"
  bitfld.long  0x00 21.              ",eDMA Error 53" "0,1"
  bitfld.long  0x00 20.              ",eDMA Error 52" "0,1"
  
  bitfld.long  0x00 19.              "  ERR51-48 ,eDMA Error 51" "0,1"
  bitfld.long  0x00 18.              ",eDMA Error 50" "0,1"
  bitfld.long  0x00 17.              ",eDMA Error 49" "0,1"
  bitfld.long  0x00 16.              ",eDMA Error 48" "0,1"
  TEXTLINE "                  "
  bitfld.long  0x00 15.              "ERR47-44 ,eDMA Error 47" "0,1"
  bitfld.long  0x00 14.              ",eDMA Error 46" "0,1"
  bitfld.long  0x00 13.              ",eDMA Error 45" "0,1"
  bitfld.long  0x00 12.              ",eDMA Error 44" "0,1"
  
  bitfld.long  0x00 11.              "  ERR43-40 ,eDMA Error 43" "0,1"
  bitfld.long  0x00 10.              ",eDMA Error 42" "0,1"
  bitfld.long  0x00 09.              ",eDMA Error 41" "0,1"
  bitfld.long  0x00 08.              ",eDMA Error 40" "0,1"
  
  bitfld.long  0x00 07.              "  ERR39-36 ,eDMA Error 39" "0,1"
  bitfld.long  0x00 06.              ",eDMA Error 38" "0,1"
  bitfld.long  0x00 05.              ",eDMA Error 37" "0,1"
  bitfld.long  0x00 04.              ",eDMA Error 36" "0,1"
  
  bitfld.long  0x00 03.              "  ERR35-32 ,eDMA Error 35" "0,1"
  bitfld.long  0x00 02.              ",eDMA Error 34" "0,1"
  bitfld.long  0x00 01.              ",eDMA Error 33" "0,1"
  bitfld.long  0x00 00.              ",eDMA Error 32" "0,1"

  
group.long (0xfff44000+0x002C)++0x03
  line.long 0x00 "ERL,eDMA Error Register L"
  bitfld.long  0x00 31.              "ERR31-28 ,eDMA Error 31" "0,1"
  bitfld.long  0x00 30.              ",eDMA Error 30" "0,1"
  bitfld.long  0x00 29.              ",eDMA Error 29" "0,1"
  bitfld.long  0x00 28.              ",eDMA Error 28" "0,1"
  
  bitfld.long  0x00 27.              "  ERR27-24 ,eDMA Error 27" "0,1"
  bitfld.long  0x00 26.              ",eDMA Error 26" "0,1"
  bitfld.long  0x00 25.              ",eDMA Error 25" "0,1"
  bitfld.long  0x00 24.              ",eDMA Error 24" "0,1"
  
  bitfld.long  0x00 23.              "  ERR23-20 ,eDMA Error 23" "0,1"
  bitfld.long  0x00 22.              ",eDMA Error 22" "0,1"
  bitfld.long  0x00 21.              ",eDMA Error 21" "0,1"
  bitfld.long  0x00 20.              ",eDMA Error 20" "0,1"
  
  bitfld.long  0x00 19.              "  ERR19-16 ,eDMA Error 19" "0,1"
  bitfld.long  0x00 18.              ",eDMA Error 18" "0,1"
  bitfld.long  0x00 17.              ",eDMA Error 17" "0,1"
  bitfld.long  0x00 16.              ",eDMA Error 16" "0,1"
  TEXTLINE "                  "
  bitfld.long  0x00 15.              "ERR15-12 ,eDMA Error 15" "0,1"
  bitfld.long  0x00 14.              ",eDMA Error 14" "0,1"
  bitfld.long  0x00 13.              ",eDMA Error 13" "0,1"
  bitfld.long  0x00 12.              ",eDMA Error 12" "0,1"
  
  bitfld.long  0x00 11.              "  ERR11-08 ,eDMA Error 11" "0,1"
  bitfld.long  0x00 10.              ",eDMA Error 10" "0,1"
  bitfld.long  0x00 09.              ",eDMA Error 09" "0,1"
  bitfld.long  0x00 08.              ",eDMA Error 08" "0,1"
  
  bitfld.long  0x00 07.              "  ERR07-04 ,eDMA Error 07" "0,1"
  bitfld.long  0x00 06.              ",eDMA Error 06" "0,1"
  bitfld.long  0x00 05.              ",eDMA Error 05" "0,1"
  bitfld.long  0x00 04.              ",eDMA Error 04" "0,1"
  
  bitfld.long  0x00 03.              "  ERR03-00 ,eDMA Error 03" "0,1"
  bitfld.long  0x00 02.              ",eDMA Error 02" "0,1"
  bitfld.long  0x00 01.              ",eDMA Error 01" "0,1"
  bitfld.long  0x00 00.              ",eDMA Error 00" "0,1"

tree "eDMA Channel Priority Registers"
group.byte (0xfff44000+0x100+00.)++0x00
  line.byte    0x00 "CPR00,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 00 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 00 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 00 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+01.)++0x00
  line.byte    0x00 "CPR01,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 01 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 01 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 01 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+02.)++0x00
  line.byte    0x00 "CPR02,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 02 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 02 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 02 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+03.)++0x00
  line.byte    0x00 "CPR03,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 03 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 03 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 03 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+04.)++0x00
  line.byte    0x00 "CPR04,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 04 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 04 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 04 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+05.)++0x00
  line.byte    0x00 "CPR05,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 05 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 05 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 05 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+06.)++0x00
  line.byte    0x00 "CPR06,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 06 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 06 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 06 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+07.)++0x00
  line.byte    0x00 "CPR07,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 07 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 07 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 07 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+08.)++0x00
  line.byte    0x00 "CPR08,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 08 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 08 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 08 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+09.)++0x00
  line.byte    0x00 "CPR09,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 09 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 09 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 09 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+10.)++0x00
  line.byte    0x00 "CPR10,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 10 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 10 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 10 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+11.)++0x00
  line.byte    0x00 "CPR11,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 11 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 11 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 11 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+12.)++0x00
  line.byte    0x00 "CPR12,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 12 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 12 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 12 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+13.)++0x00
  line.byte    0x00 "CPR13,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 13 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 13 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 13 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+14.)++0x00
  line.byte    0x00 "CPR14,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 14 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 14 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 14 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+15.)++0x00
  line.byte    0x00 "CPR15,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 15 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 15 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 15 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+16.)++0x00
  line.byte    0x00 "CPR16,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 16 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 16 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 16 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+17.)++0x00
  line.byte    0x00 "CPR17,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 17 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 17 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 17 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+18.)++0x00
  line.byte    0x00 "CPR18,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 18 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 18 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 18 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+19.)++0x00
  line.byte    0x00 "CPR19,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 19 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 19 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 19 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+20.)++0x00
  line.byte    0x00 "CPR20,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 20 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 20 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 20 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+21.)++0x00
  line.byte    0x00 "CPR21,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 21 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 21 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 21 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+22.)++0x00
  line.byte    0x00 "CPR22,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 22 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 22 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 22 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+23.)++0x00
  line.byte    0x00 "CPR23,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 23 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 23 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 23 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+24.)++0x00
  line.byte    0x00 "CPR24,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 24 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 24 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 24 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+25.)++0x00
  line.byte    0x00 "CPR25,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 25 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 25 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 25 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+26.)++0x00
  line.byte    0x00 "CPR26,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 26 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 26 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 26 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+27.)++0x00
  line.byte    0x00 "CPR27,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 27 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 27 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 27 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+28.)++0x00
  line.byte    0x00 "CPR28,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 28 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 28 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 28 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+29.)++0x00
  line.byte    0x00 "CPR29,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 29 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 29 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 29 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+30.)++0x00
  line.byte    0x00 "CPR30,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 30 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 30 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 30 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+31.)++0x00
  line.byte    0x00 "CPR31,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 31 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 31 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 31 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+32.)++0x00
  line.byte    0x00 "CPR32,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 32 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 32 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 32 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+33.)++0x00
  line.byte    0x00 "CPR33,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 33 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 33 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 33 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+34.)++0x00
  line.byte    0x00 "CPR34,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 34 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 34 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 34 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+35.)++0x00
  line.byte    0x00 "CPR35,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 35 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 35 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 35 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+36.)++0x00
  line.byte    0x00 "CPR36,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 36 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 36 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 36 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+37.)++0x00
  line.byte    0x00 "CPR37,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 37 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 37 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 37 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+38.)++0x00
  line.byte    0x00 "CPR38,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 38 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 38 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 38 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+39.)++0x00
  line.byte    0x00 "CPR39,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 39 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 39 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 39 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+40.)++0x00
  line.byte    0x00 "CPR40,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 40 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 40 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 40 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+41.)++0x00
  line.byte    0x00 "CPR41,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 41 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 41 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 41 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+42.)++0x00
  line.byte    0x00 "CPR42,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 42 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 42 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 42 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+43.)++0x00
  line.byte    0x00 "CPR43,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 43 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 43 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 43 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+44.)++0x00
  line.byte    0x00 "CPR44,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 44 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 44 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 44 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+45.)++0x00
  line.byte    0x00 "CPR45,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 45 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 45 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 45 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+46.)++0x00
  line.byte    0x00 "CPR46,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 46 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 46 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 46 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+47.)++0x00
  line.byte    0x00 "CPR47,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 47 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 47 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 47 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+48.)++0x00
  line.byte    0x00 "CPR48,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 48 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 48 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 48 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+49.)++0x00
  line.byte    0x00 "CPR49,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 49 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 49 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 49 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+50.)++0x00
  line.byte    0x00 "CPR50,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 50 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 50 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 50 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+51.)++0x00
  line.byte    0x00 "CPR51,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 51 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 51 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 51 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+52.)++0x00
  line.byte    0x00 "CPR52,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 52 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 52 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 52 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+53.)++0x00
  line.byte    0x00 "CPR53,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 53 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 53 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 53 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+54.)++0x00
  line.byte    0x00 "CPR54,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 54 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 54 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 54 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+55.)++0x00
  line.byte    0x00 "CPR55,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 55 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 55 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 55 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+56.)++0x00
  line.byte    0x00 "CPR56,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 56 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 56 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 56 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+57.)++0x00
  line.byte    0x00 "CPR57,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 57 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 57 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 57 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+58.)++0x00
  line.byte    0x00 "CPR58,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 58 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 58 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 58 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+59.)++0x00
  line.byte    0x00 "CPR59,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 59 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 59 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 59 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+60.)++0x00
  line.byte    0x00 "CPR60,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 60 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 60 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 60 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+61.)++0x00
  line.byte    0x00 "CPR61,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 61 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 61 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 61 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+62.)++0x00
  line.byte    0x00 "CPR62,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 62 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 62 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 62 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+63.)++0x00
  line.byte    0x00 "CPR63,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 63 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 63 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 63 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

tree.end

tree "eDMA Transfer Control Descriptors"
group.long (0xfff44000+0x1000+(00.)*0x20)++0x1F
  TEXTLINE "Channel 00 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(00.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(00.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(00.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(00.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(00.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(00.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(00.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(00.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(00.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(00.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(00.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(00.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(00.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(01.)*0x20)++0x1F
  TEXTLINE "Channel 01 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(01.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(01.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(01.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(01.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(01.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(01.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(01.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(01.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(01.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(01.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(01.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(01.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(01.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(02.)*0x20)++0x1F
  TEXTLINE "Channel 02 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(02.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(02.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(02.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(02.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(02.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(02.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(02.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(02.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(02.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(02.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(02.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(02.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(02.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(03.)*0x20)++0x1F
  TEXTLINE "Channel 03 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(03.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(03.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(03.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(03.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(03.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(03.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(03.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(03.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(03.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(03.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(03.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(03.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(03.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(04.)*0x20)++0x1F
  TEXTLINE "Channel 04 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(04.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(04.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(04.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(04.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(04.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(04.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(04.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(04.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(04.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(04.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(04.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(04.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(04.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(05.)*0x20)++0x1F
  TEXTLINE "Channel 05 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(05.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(05.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(05.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(05.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(05.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(05.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(05.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(05.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(05.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(05.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(05.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(05.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(05.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(06.)*0x20)++0x1F
  TEXTLINE "Channel 06 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(06.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(06.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(06.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(06.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(06.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(06.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(06.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(06.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(06.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(06.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(06.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(06.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(06.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(07.)*0x20)++0x1F
  TEXTLINE "Channel 07 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(07.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(07.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(07.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(07.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(07.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(07.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(07.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(07.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(07.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(07.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(07.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(07.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(07.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(08.)*0x20)++0x1F
  TEXTLINE "Channel 08 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(08.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(08.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(08.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(08.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(08.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(08.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(08.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(08.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(08.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(08.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(08.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(08.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(08.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(09.)*0x20)++0x1F
  TEXTLINE "Channel 09 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(09.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(09.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(09.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(09.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(09.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(09.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
