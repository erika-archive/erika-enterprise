; @(#) Feb 03 2014
; $LastChangedDate: 2014-02-03 17:23:25 +0100 $
; $LastChangedRevision: 4943 $
; $LastChangedBy: rweiss $
                                                                       
; MPC555X/MPC556X/MPC553X, MPC563xM/SPC563Mxx (Monaco), MPC5674
; --------------------------------------------------
; Core          : e200
; Manufacturer  : Freescale
;
; Author        : REI
; Status        : released
; --------------------------------------------------
; MPC55XX @(#)

base a:0

width 9.
config 9. 8.



tree "Core Registers"

tree "General Registers"

group.long SPR:0x8000++0
line.long   0x00 "CR,Condition Register"
bitfld.long 0x00 31.        "CR0:  LT ,Negative (LT)" "0,1"
bitfld.long 0x00 30.        "  GT ,Positive (GT)" "0,1"
bitfld.long 0x00 29.        "  EQ ,Zero (EQ)" "0,1"
bitfld.long 0x00 28.        "  SO ,Summary overflow (SO)" "0,1"
TEXTLINE "                "
bitfld.long 0x00 27.        "  CR1:  LT ,Negative (LT)" "0,1"
bitfld.long 0x00 26.        "  GT ,Positive (GT)" "0,1"
bitfld.long 0x00 25.        "  EQ ,Zero (EQ)" "0,1"
bitfld.long 0x00 24.        "  SO ,Summary overflow (SO)" "0,1"
TEXTLINE "                "
bitfld.long 0x00 23.        "  CR2:  LT ,Negative (LT)" "0,1"
bitfld.long 0x00 22.        "  GT ,Positive (GT)" "0,1"
bitfld.long 0x00 21.        "  EQ ,Zero (EQ)" "0,1"
bitfld.long 0x00 20.        "  SO ,Summary overflow (SO)" "0,1"
TEXTLINE "                "
bitfld.long 0x00 19.        "  CR3:  LT ,Negative (LT)" "0,1"
bitfld.long 0x00 18.        "  GT ,Positive (GT)" "0,1"
bitfld.long 0x00 17.        "  EQ ,Zero (EQ)" "0,1"
bitfld.long 0x00 16.        "  SO ,Summary overflow (SO)" "0,1"
TEXTLINE "                "
bitfld.long 0x00 15.        "  CR4:  LT ,Negative (LT)" "0,1"
bitfld.long 0x00 14.        "  GT ,Positive (GT)" "0,1"
bitfld.long 0x00 13.        "  EQ ,Zero (EQ)" "0,1"
bitfld.long 0x00 12.        "  SO ,Summary overflow (SO)" "0,1"
TEXTLINE "                "
bitfld.long 0x00 11.        "  CR5:  LT ,Negative (LT)" "0,1"
bitfld.long 0x00 10.        "  GT ,Positive (GT)" "0,1"
bitfld.long 0x00 09.        "  EQ ,Zero (EQ)" "0,1"
bitfld.long 0x00 08.        "  SO ,Summary overflow (SO)" "0,1"
TEXTLINE "                "
bitfld.long 0x00 07.        "  CR6:  LT ,Negative (LT)" "0,1"
bitfld.long 0x00 06.        "  GT ,Positive (GT)" "0,1"
bitfld.long 0x00 05.        "  EQ ,Zero (EQ)" "0,1"
bitfld.long 0x00 04.        "  SO ,Summary overflow (SO)" "0,1"
TEXTLINE "                "
bitfld.long 0x00 03.        "  CR7:  LT ,Negative (LT)" "0,1"
bitfld.long 0x00 02.        "  GT ,Positive (GT)" "0,1"
bitfld.long 0x00 01.        "  EQ ,Zero (EQ)" "0,1"
bitfld.long 0x00 00.        "  SO ,Summary overflow (SO)" "0,1"

TEXTLINE ""

group.long SPR:1.++0
line.long   0x00 "XER,Integer Exception Register"
bitfld.long 0x00 31.        "SO ,Summary Overflow (per Book E)" "0,1"
bitfld.long 0x00 30.        "  OV ,Overflow (per Book E)" "0,1"
bitfld.long 0x00 29.        "  CA ,Carry (per Book E)" "0,1"
hexmask.long.byte 0 00.--06. 1 "  BYTECOUNT ,This field specifies the number of bytes to be transferred by a lswx or stswx instruction"

tree.end

tree "Processor Control Registers"

rgroup.long SPR:286.++0
line.long   0x00 "PIR,Processor ID Register"
hexmask.byte 3. 00.--07. 1. "PID ,These bit are a reflection of the values provided on the p_cpuid[0:7] input signals"


group.long SPR:1008.++0
line.long   0x00 "HID0,Hardware Implementation Dependent Register 0"
bitfld.long 0x00 31.        "EMCP    ,Enable machine check pin" "0,1"
bitfld.long 0x00 24.--25. "  BPRED   ,Branch prediction (acceleration) control" "enabled,disabled for backward branches,disabled for forward branches,disabled for both branch directions "
TEXTLINE "                "
bitfld.long 0x00 23.      "  DOZE    ,Configure for doze power management mode" "0,1" 
bitfld.long 0x00 22.      "  NAP     ,Configure for nap power management mode" "0,1"
bitfld.long 0x00 21.      "  SLEEP   ,Configure for sleep power management mode" "0,1"

bitfld.long 0x00 17.      "  ICR     ,Interrupt inputs clear reservation" "0,1"
bitfld.long 0x00 16.      "  NHR     ,Not hardware reset" "0,1"

TEXTLINE "                "

bitfld.long 0x00 14.      "  TBEN    ,Timebase enable" "0,1"
bitfld.long 0x00 13.      "  SL_TBCK ,Select timebase clock" "0,1"
bitfld.long 0x00 12.      "  DCLREE  ,Debug interrupt clears MSR[EE]" "0,1"
bitfld.long 0x00 11.      "  DCLRCE  ,Debug Interrupt Clears MSR[CE]" "0,1"
bitfld.long 0x00 10.      "  CICLRDE ,Critical Interrupt Clears MSR[DE]" "0,1"
bitfld.long 0x00 09.      "  MCCLRDE ,Machine check interrupt clears MSR[DE]" "0,1"
bitfld.long 0x00 08.      "  DAPUEN  ,Debug APU enable" "0,1"

TEXTLINE ""

group.long SPR:1009.++0
line.long   0x00 "HID1,Hardware Implementation Dependent Register 1"
bitfld.long 0x00 07.        "ATS     ,Atomic status (read-only)" "0,1"

TEXTLINE ""

group.long SPR:1023.++0
line.long   0x00 "SVR,System Version Register"

tree.end

tree "Exception Handling/Control Registers"
group.long SPR:62.++0
line.long   0x00 "ESR,Exception Syndrome Register"
bitfld.long 0x00 27.        "PIL   ,Illegal instruction exception" "0,1"
bitfld.long 0x00 26.      "  PPR   ,Privileged instruction exception" "0,1"
bitfld.long 0x00 25.      "  PTR   ,Trap exception" "0,1"
bitfld.long 0x00 24.      "  FP    ,Floating-point operation" "0,1"
bitfld.long 0x00 23.      "  ST    ,Store operation" "0,1"
TEXTLINE "                "

bitfld.long 0x00 21.      "  DLK   ,Data cache locking" "0,1"
bitfld.long 0x00 20.      "  ILK   ,Instruction cache locking" "0,1"
bitfld.long 0x00 19.      "  AP    ,Auxiliary processor operation" "0,1"
bitfld.long 0x00 18.      "  PUO   ,Unimplemented operation exception" "0,1"
bitfld.long 0x00 17.      "  BO    ,Byte Ordering exception" "0,1"
bitfld.long 0x00 16.      "  PIE   ,Program Imprecise exception" "0,1"
TEXTLINE "                "

bitfld.long 0x00 07.      "  SPE   ,SPE APU Operation" "0,1"

bitfld.long 0x00 00.      "  XTE   ,External termination error (Precise)" "0,1"


TEXTLINE ""

sif (CPU()=="MPC5633M")||(CPU()=="MPC5634M")||(cpu()=="SPC563M60")||(cpu()=="SPC563M64")||(CPUIS("MPC5674*"))

sif (CPUIS("MPC5674*"))

  group.long SPR:572.++0
  line.long   0x00 "MCSR,Machine Check Syndrome Register"
  eventfld.long 0x00 31.          "MCP       ,Machine check input pin" "0,1"
  TEXTLINE "                "
  eventfld.long 0x00 30.        "  IC_DPERR  ,Instruction Cache data array parity error" "0,1"
  eventfld.long 0x00 29.        "  CP_PERR   ,Data Cache push parity error" "0,1"
  eventfld.long 0x00 28.        "  DC_DPERR  ,Data Cache data array parity error" "0,1"
  eventfld.long 0x00 27.        "  EXCP_ERR  ,ISI/ITLB or Bus Error on first instruction fetch for an exception handler" "0,1"
  TEXTLINE "                "
  eventfld.long 0x00 26.        "  IC_TPERR  ,Instruction Cache Tag parity error" "0,1"
  eventfld.long 0x00 25.        "  DC_TPERR  ,Data Cache Tag parity error" "0,1"
  TEXTLINE "                "
  eventfld.long 0x00 19.        "  MAV       ,MCAR Address Valid" "0,1"
  eventfld.long 0x00 18.        "  MEA       ,MCAR holds Effective Address" "0,1"
  TEXTLINE "                "
  eventfld.long 0x00 16.        "  IF        ,Instruction Fetch Error Report" "0,1"
  eventfld.long 0x00 15.        "  LD        ,Load type instruction Error Report" "0,1"
  eventfld.long 0x00 14.        "  ST        ,Store type instruction Error Report" "0,1"
  eventfld.long 0x00 04.        "  BUS_IRERR ,Read bus error on instruction fetch" "0,1"
  eventfld.long 0x00 03.        "  BUS_DRERR ,Read bus error on data load" "0,1"
  eventfld.long 0x00 02.        "  BUS_WRERR ,Write bus error on buffered store or cache line push" "0,1"
TEXTLINE ""

  group.long SPR:573.++0
  line.long   0x00 "MCAR,Machine Check Address Register"


else

  group.long SPR:572.++0
  line.long   0x00 "MCSR,Machine Check Syndrome Register"
  eventfld.long 0x00 31.          "MCP       ,Machine check input pin" "0,1"
  eventfld.long 0x00 29.        "  CP_PERR   ,Cache push parity error" "0,1"
  eventfld.long 0x00 28.        "  CPERR     ,Cache parity error" "0,1"
  eventfld.long 0x00 27.        "  EXCP_ERR  ,ISI/ITLB or Bus Error on first instruction fetch for an exception handler" "0,1"
  TEXTLINE "                "
  eventfld.long 0x00 20.        "  NMI       ,non-maskable interrupt" "0,1"
  eventfld.long 0x00 04.        "  BUS_IRERR ,Read bus error on instruction fetch" "0,1"
  eventfld.long 0x00 03.        "  BUS_DRERR ,Read bus error on data load" "0,1"
  eventfld.long 0x00 02.        "  BUS_WRERR ,Write bus error on buffered store or cache line push" "0,1"

endif
 
else

  group.long SPR:572.++0
  line.long   0x00 "MCSR,Machine Check Syndrome Register"
  eventfld.long 0x00 31.          "MCP       ,Machine check input pin" "0,1"
  eventfld.long 0x00 29.        "  CP_PERR   ,Cache push parity error" "0,1"
  eventfld.long 0x00 28.        "  CPERR     ,Cache parity error" "0,1"
  eventfld.long 0x00 27.        "  EXCP_ERR  ,ISI/ITLB or Bus Error on first instruction fetch for an exception handler" "0,1"
  TEXTLINE "                "
  eventfld.long 0x00 02.        "  BUS_WRERR ,Write bus error on buffered store or cache line push" "0,1"

endif

sif (CPUIS("MPC5674*"))
TEXTLINE ""
  group.long SPR:570.++0
  line.long   0x00 "MCSRR0,Machine check save/restore register 0"

  group.long SPR:571.++0
  line.long   0x00 "MCSRR1,Machine check save/restore register 1"
endif


tree.end

tree "Interrupt Vector Registers"

group.long SPR:63.++0
line.long 0. "IVPR,Interrupt Vector Prefix Register"


TEXTLINE ""

group.long SPR:400.++0
line.long 0. "IVOR0,Interrupt Vector Offset Register 0"
textfld      "Critical Input"

group.long SPR:401.++0
line.long 0. "IVOR1,Interrupt Vector Offset Register 1"
textfld      "Machine Check"

group.long SPR:402.++0
line.long 0. "IVOR2,Interrupt Vector Offset Register 2"
textfld      "Data Storage"

group.long SPR:403.++0
line.long 0. "IVOR3,Interrupt Vector Offset Register 3"
textfld      "Instruction Storage"
 
group.long SPR:404.++0
line.long 0. "IVOR4,Interrupt Vector Offset Register 4"
textfld      "External Input"

group.long SPR:405.++0
line.long 0. "IVOR5,Interrupt Vector Offset Register 5"
textfld      "Alignment"

group.long SPR:406.++0
line.long 0. "IVOR6,Interrupt Vector Offset Register 6"
textfld      "Program"

group.long SPR:407.++0
line.long 0. "IVOR7,Interrupt Vector Offset Register 7"
textfld      "Floating-Point Unavailable"

group.long SPR:408.++0
line.long 0. "IVOR8,Interrupt Vector Offset Register 8"
textfld      "System Call"

group.long SPR:409.++0
line.long 0. "IVOR9,Interrupt Vector Offset Register 9"
textfld      "Auxiliary Processor Unavailable"

group.long SPR:410.++0
line.long 0. "IVOR10,Interrupt Vector Offset Register 10"
textfld      "Decrementer"

group.long SPR:411.++0
line.long 0. "IVOR11,Interrupt Vector Offset Register 11"
textfld      "Fixed Interval Timer"

group.long SPR:412.++0
line.long 0. "IVOR12,Interrupt Vector Offset Register 12"
textfld      "Watchdog"

group.long SPR:413.++0
line.long 0. "IVOR13,Interrupt Vector Offset Register 13"
textfld      "Data TLB Error"

group.long SPR:414.++0
line.long 0. "IVOR14,Interrupt Vector Offset Register 14"
textfld      "Instruction TLB Error"

group.long SPR:415.++0
line.long 0. "IVOR15,Interrupt Vector Offset Register 15"
textfld      "Debug"

TEXTLINE ""



group.long SPR:528.++0
line.long 0. "IVOR32,Interrupt Vector Offset Register 32"
textfld      "SPE APU unavailable"

group.long SPR:529.++0
line.long 0. "IVOR33,Interrupt Vector Offset Register 33"
textfld      "SPE Floating-point Data"

group.long SPR:530.++0
line.long 0. "IVOR34,Interrupt Vector Offset Register 34"
textfld      "SPE Floating-point Round"

;group.long SPR:531.++0
;line.long 0. "IVOR35,Interrupt Vector Offset Register 35"
;textfld      "Performance monitor"


tree.end

tree "Branch Target Buffer Registers"

group.long SPR:1013.++0
  line.long 0. "BUCSR,Branch Unit Control and Status Register"
  bitfld.long  0. 09.            "BBFI   ,Branch buffer flash invalidate"       "0,1"

sif CPUIS("MPC5674*")
  textline "                "
  bitfld.long  0. 04.--05.     "  BALLOC ,Branch Target Buffer Allocation Control"  "both enabled,forward only,backward only,both disabled"
  textline "                "
  bitfld.long  0. 01.--02.     "  BPRED  ,Branch Prediction Control (static)"       "both enabled,forward only,backward only,both disabled"
  textline "                "
endif

  bitfld.long  0. 00.          "  BPEN   ,Branch prediction enable"             "0,1"
tree.end

tree "Timer Registers"
  group spr:340.++0
    line.long 0x0 "TCR,Timer Control Register"
      bitfld.long   0x0 30.--31.       "WP  ,Watchdog timer period" "0,1,2,3"
      bitfld.long   0x0 28.--29.     "  WRC ,Watchdog timer reset control" "disabled,checkstop,!RSTOUT,res."
      bitfld.long   0x0 27.          "  WIE ,Watchdog timer interrupt enable" "0,1"
      bitfld.long   0x0 26.          "  DIE ,Decrementer interrupt enable" "0,1"
      bitfld.long   0x0 24.--25.     "  FP  ,Fixed-interval timer period" "0,1,2,3"
      bitfld.long   0x0 23.          "  FIE ,Fixed-interval timer interrupt enable" "0,1"
      bitfld.long   0x0 22.          "  ARE ,Auto-reload enable" "0,1"
      bitfld.long   0x0 17.--20.     "  WPEXT ,Watchdog timer period extention" "WP,WP+4,WP+8,WP+12,WP+16,WP+20,WP+24,WP+28,WP+32,WP+36,WP+40,WP+44,WP+48,WP+52,WP+56,WP+60"
      bitfld.long   0x0 13.--16.     "  FPEXT ,Fixed-interval timer extention" "FP,FP+4,FP+8,FP+12,FP+16,FP+20,FP+24,FP+28,FP+32,FP+36,FP+40,FP+44,FP+48,FP+52,FP+56,FP+60"

  group spr:336.++0
    line.long 0x0 "TSR,Timer Status Register"
      eventfld.long   0x0 31.          "ENW ,Enable next watchdog" "0,1"
      eventfld.long   0x0 30.          "  WIS ,Watchdog timer interrupt status" "0,1"
      eventfld.long   0x0 28.--29.     "  WRS ,Watchdog timer reset status" "none,checkstop,!RSTOUT,res."
      eventfld.long   0x0 27.          "  DIS ,Decrementer timer interrupt status" "0,1"
      eventfld.long   0x0 26.          "  FIS ,Fixed-interval timer interrupt status" "0,1"

  TEXTLINE ""

  group spr:285.++0
    line.long 0x0 "TBU,Upper Time Base Register"

  group spr:284.++0
    line.long 0x0 "TBL,Lower Time Base Register"

  TEXTLINE ""

  group spr:22.++0
    line.long 0x0 "DEC,Decrementer Register"

  group spr:54.++0
    line.long 0x0 "DECAR,Decrementer Auto-Reload Register"

tree.end

sif (cpu()=="MPC5534")

tree "Parallel Signature Unit Registers"
  group dcr:272.++0
    line.long 0x0 "PSCR,Parallel Signature Control Register"
      bitfld.long   0x0 5.          "CNTEN  ,Counter enable" "0,1"
      bitfld.long   0x0 2.          "  RDEN ,Read enable" "0,1"
      bitfld.long   0x0 1.          "  WREN ,Write enable" "0,1"
      bitfld.long   0x0 0.          "  INIT ,Initialize rgeisters" "0,1"
  group dcr:273.++0
    line.long 0x0 "PSSR,Parallel Signature Status Register"
      bitfld.long   0x0 0.          "TERR   ,Transfer error status" "0,1"
  group dcr:274.++0
    line.long 0x0 "PSHR,Parallel Signature High Register"
  group dcr:275.++0
    line.long 0x0 "PSLR,Parallel Signature Low Register"
  group dcr:276.++0
    line.long 0x0 "PSCTR,Parallel Signature Counter Register"
  wgroup dcr:277.++0
    line.long 0x0 "PSUHR,Parallel Signature Update High Register"
  wgroup dcr:278.++0
    line.long 0x0 "PSULR,Parallel Signature Update Low Register"

tree.end

endif


tree "Debug Facilities"
  group spr:0x134++0
    line.long 0x0 "DBCR0,Debug Control Register 0"
      bitfld.long   0x0 31.          "EDM   ,External Debug Mode" "0,1"
      bitfld.long   0x0 30.          "  IDM   ,Internal Debug Mode" "0,1"
      bitfld.long   0x0 28.--29.     "  RST   ,Reset" "no,core,chip,sys"
      bitfld.long   0x0 27.          "  ICMP  ,Instruction Completion Debug Event" "0,1"
      bitfld.long   0x0 26.          "  BRT  ,Branch Taken Debug Event" "0,1"
      bitfld.long   0x0 25.          "  IRPT ,Interrupt Debug Event" "0,1"
      bitfld.long   0x0 24.          "  TRAP ,Trap Debug Event" "0,1"
      textline "                "
      bitfld.long   0x0 23.          "  IAC1  ,Instruction Address Compare (IAC) 1 Debug Event" "0,1"
      bitfld.long   0x0 22.          "  IAC2  ,IAC 2 Debug Event" "0,1"
      bitfld.long   0x0 21.          "  IAC3  ,IAC 3 Debug Event" "0,1"
      bitfld.long   0x0 20.          "  IAC4  ,IAC 4 Debug Event" "0,1"
      textline "                "
      bitfld.long   0x0 19.          "  DAC1R ,Data Address Compare (DAC) 1 Read Debug Event" "0,1"
      bitfld.long   0x0 18.          "  DAC1W ,DAC 1 Write Debug Event" "0,1"
      bitfld.long   0x0 17.          "  DAC2R ,DAC 2 Read Debug Event" "0,1"
      bitfld.long   0x0 16.          "  DAC2W ,DAC 2 Write Debug Event" "0,1"
      textline "                "
      bitfld.long   0x0 15.          "  RET   ,Return Debug Event" "0,1"
      bitfld.long   0x0 10.          "  DEVT1 ,External debug event 1 enable" "0,1"
      bitfld.long   0x0 09.          "  DEVT2 ,External debug event 2 enable" "0,1"
      bitfld.long   0x0 08.          "  DCNT1 ,Debug counter 1 debug event enable" "0,1"
      bitfld.long   0x0 07.          "  DCNT2 ,Debug counter 1 debug event enable" "0,1"
      textline "                "
      bitfld.long   0x0 06.          "  CIRPT ,Critical interrupt taken debug event enable" "0,1"
      bitfld.long   0x0 05.          "  CRET  ,Critical return debug event enable" "0,1"
      bitfld.long   0x0  0.          "  FT    ,Freeze timers on debug event" "0,1"
textline ""

sif (CPU()=="MPC5633M")||(CPU()=="MPC5634M")||(cpu()=="SPC563M60")||(cpu()=="SPC563M64")
  group spr:569.++0
    line.long 0x0 "DBERC0,Debug External Resource Control Register"
      bitfld.long   0x0 30.            "IDM   ,Internal Debug Mode" "0,1"
      bitfld.long   0x0 29.          "  RST   ,Reset" "0,1"
      bitfld.long   0x0 28.          "  UDE   ,Unconditional Debug Event" "0,1"
      TEXTLINE "                "
      bitfld.long   0x0 27.          "  ICMP  ,Instruction Completion Debug Event" "0,1"
      bitfld.long   0x0 26.          "  BRT   ,Branch Taken Debug Event" "0,1"
      bitfld.long   0x0 25.          "  IRPT  ,Interrupt Debug Event" "0,1"
      bitfld.long   0x0 24.          "  TRAP  ,Trap Debug Event" "0,1"
      TEXTLINE "                "
      bitfld.long   0x0 23.          "  IAC1  ,Instruction Address Compare (IAC) 1 Debug Event" "0,1"
      bitfld.long   0x0 22.          "  IAC2  ,IAC 2 Debug Event" "0,1"
      bitfld.long   0x0 21.          "  IAC3  ,IAC 3 Debug Event" "0,1"
      bitfld.long   0x0 20.          "  IAC4  ,IAC 4 Debug Event" "0,1"
      TEXTLINE "                "
      bitfld.long   0x0 19.          "  DAC1  ,Data Address Compare 1 Debug Event" "0,1"
      bitfld.long   0x0 17.          "           DAC2  ,Data Address Compare 2 Debug Event" "0,1"
      TEXTLINE "                "
      bitfld.long   0x0 15.          "  RET   ,Return Debug Event" "0,1"
      TEXTLINE "                "
      bitfld.long   0x0 10.          "  DEVT1 ,External debug event 1 enable" "0,1"
      bitfld.long   0x0 09.          "  DEVT2 ,External debug event 2 enable" "0,1"
      TEXTLINE "                "
      bitfld.long   0x0 08.          "  DCNT1 ,Debug counter 1 debug event enable" "0,1"
      bitfld.long   0x0 07.          "  DCNT2 ,Debug counter 1 debug event enable" "0,1"
      TEXTLINE "                "
      bitfld.long   0x0 06.          "  CIRPT ,Critical interrupt taken debug event enable" "0,1"
      bitfld.long   0x0 05.          "  CRET  ,Critical return debug event enable" "0,1"
      TEXTLINE "                "
      bitfld.long   0x0 04.          "  BKPT  ,Breakpoint Instruction Debug Control" "0,1"
;     bitfld.long   0x0 03.          "  DQM   ,Data Acquisition Messaging Registers" "0,1"
      bitfld.long   0x0 00.          "  FT    ,Freeze timers on debug event" "0,1"
TEXTLINE ""
endif      
      
  group spr:0x135++0
    line.long 0x0 "DBCR1,Debug Control Register 1"
      bitfld.long   0x0 30.--31.       "IAC1US  ,Instruction Address Compare (IAC) 1" "both,res,super,user"
      bitfld.long   0x0 28.--29.     "  IAC1ER  ,IAC 1 Effective/Real" "eff,res,MSR_IS=0,MSR_IS=1"
      bitfld.long   0x0 26.--27.     "  IAC2US  ,IAC 2 User/Supervisor" "both,res,super,user"
      bitfld.long   0x0 24.--25.     "  IAC2ER  ,IAC 2 Effective/Real" "eff,res,MSR_IS=0,MSR_IS=1"
      TEXTLINE "                "
      bitfld.long   0x0 22.--23.     "  IAC12M  ,IAC 1/2 Mode" "exact,IAC1==addr&IAC2,incl. range,excl. range"
;     bitfld.long   0x0 16.          "  IAC12AT ,IAC 1/2 Auto-Toggle Enable" "0,1"
      TEXTLINE "                " 
      bitfld.long   0x0 14.--15.     "  IAC3US  ,IAC 3 User/Supervisor" "both,res,super,user"
      bitfld.long   0x0 12.--13.     "  IAC3ER  ,IAC 3 Effective/Real" "eff,res,MSR_IS=0,MSR_IS=1"
      bitfld.long   0x0 10.--11.     "  IAC4US  ,IAC 4 User/Supervisor" "both,res,super,user"
      bitfld.long   0x0  8.--9.      "  IAC4ER  ,IAC 4 Effective/Real" "eff,res,MSR_IS=0,MSR_IS=1"
      TEXTLINE "                "
      bitfld.long   0x0  6.--7.      "  IAC34M  ,IAC 3/4 Mode" "exact,IAC1==addr&IAC2,incl. range,excl. range"
;     bitfld.long   0x0  0.          "  IAC34AT ,IAC3/4 Auto-Toggle Enable" "0,1"

textline ""
  group spr:0x136++0
    line.long 0x0 "DBCR2,Debug Control Register 2"
      bitfld.long   0x0 30.--31.       "DAC1US  ,DAC1 User/Supervisor"  "both,res,super,user"
      bitfld.long   0x0 28.--29.     "  DAC1ER  ,DAC 1 Effective/Real"  "eff,res,MSR_DS=0,MSR_DS=1"
      bitfld.long   0x0 26.--27.     "  DAC2US  ,DAC 2 User/Supervisor" "both,res,super,user"
      bitfld.long   0x0 24.--25.     "  DAC2ER ,DAC 2 Effective/Real"  "eff,res,MSR_DS=0,MSR_DS=1"
     TEXTLINE "                "
      bitfld.long   0x0 22.--23.     "  DAC12M  ,DAC 1/2 Mode" "exact,DAC1==addr&DAC2,incl. range,excl. range"
     TEXTLINE "                "
      bitfld.long   0x0 21.          "  DAC1LNK ,Data address compare 1 linked" "dis,IAC1"
      bitfld.long   0x0 20.          "  DAC2LNK ,Data address compare 2 linked" "dis,IAC3"
textline ""

  group spr:561.++0
    line.long 0x0 "DBCR3,Debug Control Register 3"
      bitfld.long   0x0 31.            "DEVT1C1 ,External debug event 1 count 1 enable" "0,1"
      bitfld.long   0x0 30.          "  DEVT2C1 ,External debug event 2 count 1 enable" "0,1"
      bitfld.long   0x0 29.          "  ICMPC1  ,Instruction complete debug event count 1 enable" "0,1"
    TEXTLINE "                "
      bitfld.long   0x0 28.          "  IAC1C1  ,Instruction address compare 1 debug event count 1 enable" "0,1"
      bitfld.long   0x0 27.          "  IAC2C1  ,Instruction address compare 2 debug event count 1 enable" "0,1"
      bitfld.long   0x0 26.          "  IAC3C1  ,Instruction address compare 3 debug event count 1 enable" "0,1"
      bitfld.long   0x0 25.          "  IAC4C1  ,Instruction address compare 4 debug event count 1 enable" "0,1"
    TEXTLINE "                "
      bitfld.long   0x0 24.          "  DAC1RC1 ,Data address compare 1 read debug event count 1 enable" "0,1"
      bitfld.long   0x0 23.          "  DAC1WC1 ,Data address compare 1 write debug event count 1 enable" "0,1"
      bitfld.long   0x0 22.          "  DAC2RC1 ,Data address compare 2 read debug event count 1 enable" "0,1"
      bitfld.long   0x0 21.          "  DAC2WC1 ,Data address compare 3 write debug event count 1 enable" "0,1"
      bitfld.long   0x0 20.          "  IRPTC1  ,Interrupt taken debug event count 1 enable" "0,1"
      bitfld.long   0x0 19.          "  RETC1   ,Return debug event count 1 enable" "0,1"
    TEXTLINE "                "
      bitfld.long   0x0 18.          "  DEVT1C2 ,External debug event 1 count 2 enable" "0,1"
      bitfld.long   0x0 17.          "  DEVT2C2 ,External debug event 2 count 2 enable" "0,1"
      bitfld.long   0x0 16.          "  ICMPC2  ,Instruction complete debug event count 2 enable" "0,1"
    TEXTLINE "                "
      bitfld.long   0x0 15.          "  IAC1C2  ,Instruction address compare 1 debug event count 2 enable" "0,1"
      bitfld.long   0x0 14.          "  IAC2C2  ,Instruction address compare 2 debug event count 2 enable" "0,1"
      bitfld.long   0x0 13.          "  IAC3C2  ,Instruction address compare 3 debug event count 2 enable" "0,1"
      bitfld.long   0x0 12.          "  IAC4C2  ,Instruction address compare 4 debug event count 2 enable" "0,1"
    TEXTLINE "                "
      bitfld.long   0x0 11.          "  DAC1RC2 ,Data address compare 1 read debug event count 2 enable" "0,1"
      bitfld.long   0x0 10.          "  DAC1WC2 ,Data address compare 1 write debug event count 2 enable" "0,1"
      bitfld.long   0x0 09.          "  DAC2RC2 ,Data address compare 2 read debug event count 2 enable" "0,1"
      bitfld.long   0x0 08.          "  DAC2WC2 ,Data address compare 3 write debug event count 2 enable" "0,1"
    TEXTLINE "                "
      bitfld.long   0x0 07.          "  DEVT1T1 ,External debug event 1 trigger counter 1 enable" "0,1"
      bitfld.long   0x0 06.          "  DEVT2T1 ,External debug event 1 trigger counter 1 enable" "0,1"
      bitfld.long   0x0 05.          "  IAC1T1  ,Instruction address compare 1 trigger counter 1 enable" "0,1"
      bitfld.long   0x0 04.          "  IAC3T1  ,Instruction address compare 3 trigger counter 1 enable" "0,1"
      bitfld.long   0x0 03.          "  DAC1RT1 ,Data address compare 1 read trigger counter 1 enable" "0,1"
      bitfld.long   0x0 02.          "  DAC1WT1 ,Data address compare 1 write trigger counter 1 enable" "0,1"
    TEXTLINE "                "
      bitfld.long   0x0 01.          "  CNT2T1  ,Debug counter 2 trigger counter 1 enable" "0,1"
      bitfld.long   0x0 00.          "  CONFIG  ,Debug counter configuration" "indep.,concat."

textline ""

  group spr:562.++0
    line.long 0x0 "DBCNT,Debug Counter"
    hexmask.long.word 0. 16.--31. 1. 0.   "CNT1 ,Debug counter 1"
    hexmask.long.word 0. 00.--15. 1. 0.   "   CNT2 ,Debug counter 2"
textline ""
      
  group spr:0x130++0
    line.long 0x0 "DBSR,Debug Status Register"
      bitfld.long   0x0 31.            "IDE   ,Imprecise Debug Event" "0,1"
      bitfld.long   0x0 30.          "  UDE   ,Unconditional Debug Event" "0,1"
      bitfld.long   0x0 28.--29.     "  MRR   ,Most Recent Reset" "no,core,chip,sys"
      bitfld.long   0x0 27.          "  ICMP  ,Instruction Completion Debug Event" "0,1"
      bitfld.long   0x0 26.          "  BRT   ,Branch Taken Debug Event" "0,1"
      bitfld.long   0x0 25.          "  IRPT  ,Interrupt Debug Event" "0,1"
      bitfld.long   0x0 24.          "  TRAP  ,Trap Debug Event" "0,1"
      TEXTLINE "                "
      bitfld.long   0x0 23.          "  IAC1  ,IAC 1 Debug Event" "0,1"
      bitfld.long   0x0 22.          "  IAC2  ,IAC 2 Debug Event" "0,1"
      bitfld.long   0x0 21.          "  IAC3  ,IAC 3 Debug Event" "0,1"
      bitfld.long   0x0 20.          "  IAC4   ,IAC 4 Debug Event" "0,1"
      TEXTLINE "                "
      bitfld.long   0x0 19.          "  DAC1R ,DAC 1 Read Debug Event" "0,1"
      bitfld.long   0x0 18.          "  DAC1W ,DAC 1 Write Debug Event" "0,1"
      bitfld.long   0x0 17.          "  DAC2R ,DAC 2 Read Debug Event" "0,1"
      bitfld.long   0x0 16.          "  DAC2W  ,DAC 2 Write Debug Event" "0,1"
      TEXTLINE "                "
      bitfld.long   0x0 15.          "  RET   ,Return Debug Event" "0,1"
      bitfld.long   0x0 10.          "  DEVT1 ,External debug event 1 debug event" "0,1"
      bitfld.long   0x0 09.          "  DEVT2 ,External debug event 2 debug event" "0,1"
      bitfld.long   0x0 08.          "  DCNT1  ,Debug counter 1 debug event" "0,1"
      bitfld.long   0x0 07.          "  DCNT2 ,Debug counter 2 debug event" "0,1"
      TEXTLINE "                "
      bitfld.long   0x0 06.          "  CIRPT ,Critical interrupt taken debug event" "0,1"
      bitfld.long   0x0 05.          "  CRET  ,Critical return debug event" "0,1"
      bitfld.long   0x0  0.          "  CNT1TRG ,Counter 1 triggered" "0,1"
      TEXTLINE "                "
     
  group spr:0x138++0
    line.long 0x0 "IAC1,Instruction Address Compare 1"
  group spr:0x139++0
    line.long 0x0 "IAC2,Instruction Address Compare 2"
  group spr:0x13a++0
    line.long 0x0 "IAC3,Instruction Address Compare 3"
  group spr:0x13b++0
    line.long 0x0 "IAC4,Instruction Address Compare 4"
  TEXTLINE "                "
  group spr:0x13c++0
    line.long 0x0 "DAC1,Data Address Compare 1"
  group spr:0x13d++0
    line.long 0x0 "DAC2,Data Address Compare 2"
    
sif (CPU()=="MPC5633M")||(CPU()=="MPC5634M")||(cpu()=="SPC563M60")||(cpu()=="SPC563M64")
  group spr:0x13e++0
    line.long 0x0 "DVC1,Data Value Compare 1"
  group spr:0x13f++0
    line.long 0x0 "DVC2,Data Value Compare 2"
;  group spr:0x3f3++0
;    line.long 0x0 "DBDR,Debug Data Register"
endif

TEXTLINE ""
TEXTLINE ""

group spr:574.++0
  line.long 0x0 "DSRR0,Debug Interrupt SRR0"
group spr:575.++0
  line.long 0x0 "DSRR1,Debug Interrupt SRR1"

tree.end

sif (CPU()=="MPC5633M")||(CPU()=="MPC5634M")||(cpu()=="SPC563M60")||(cpu()=="SPC563M64")
tree "PSU Registers"

group dcr:272.++0
  line.long 0x0 "PSCR,Parallel Signature Control Register"
  bitfld.long   0x0 05.           "CNTEN  ,Counter Enable" "0,1"
  bitfld.long   0x0 02.         "  RDEN   ,Read Enable"    "0,1"
  bitfld.long   0x0 01.         "  WREN   ,Write Enable" "0,1"
  bitfld.long   0x0 00.         "  INIT   ,This bit may be written with a '1' to set the values in the PSHR, PSLR, and PSCTR registers to all '0's" "0,1"

group dcr:273.++0
  line.long 0x0 "PSSR,Parallel Signature Status Register"
  eventfld.long   0x0 00.           "TERR   ,Transfer Error Status" "0,1"

TEXTLINE ""

group dcr:274.++0
  line.long 0x0 "PSHR,Parallel Signature High Register"

group dcr:275.++0
  line.long 0x0 "PSLR,Parallel Signature Low Register"

TEXTLINE ""

group dcr:276.++0
  line.long 0x0 "PSCTR,Parallel Signature Counter Register"

TEXTLINE ""

group dcr:277.++0
  line.long 0x0 "PSUHR,Parallel Signature Update High Register"

group dcr:278.++0
  line.long 0x0 "PSULR,Parallel Signature Update Low Register"

tree.end
endif

tree.end


base ANC:0

sif ((cpu()=="MPC5632M")||(cpu()=="MPC5633M")||(cpu()=="MPC5634M")||(cpu()=="SPC563M54")||(cpu()=="SPC563M60")||(cpu()=="SPC563M64"))
tree "XBAR Switch"

group VM:0++0
TEXTLINE ""
TEXTLINE "Module         XBAR Port     Master ID"
TEXTLINE "--------------------------------------"

TEXTLINE "e200z335 instr Master 0      0"
TEXTLINE "eDMA           Master 1      2"
TEXTLINE "e200z6 data    Master 4      0"
TEXTLINE "e200z6-Nexus   Master 4      1"
TEXTLINE "Flash          Slave  0"      
TEXTLINE "Cal Bus        Slave  1"      
TEXTLINE "Internal SRAM  Slave  3"      
TEXTLINE "PBRIDGE        Slave  7"      

TEXTLINE ""
group.long 0xfff04800++0x03
  line.long 0x00 "MGPCR0,General Purpose Control Register for Master port 0"
  bitfld.long 0x00 00.--02.           "AULB  ,Arbitrate on Undefined Length Bursts" "not allowed,allowed,after four beats,after eight beats,after 16 beats,res.,res.,res"
group.long 0xfff04900++0x03
  line.long 0x00 "MGPCR1,General Purpose Control Register for Master port 1"
  bitfld.long 0x00 00.--02.           "AULB  ,Arbitrate on Undefined Length Bursts" "not allowed,allowed,after four beats,after eight beats,after 16 beats,res.,res.,res"
group.long 0xfff04A00++0x03
  line.long 0x00 "MGPCR2,General Purpose Control Register for Master port 2"
  bitfld.long 0x00 00.--02.           "AULB  ,Arbitrate on Undefined Length Bursts" "not allowed,allowed,after four beats,after eight beats,after 16 beats,res.,res.,res"
group.long 0xfff04B00++0x03
  line.long 0x00 "MGPCR3,General Purpose Control Register for Master port 3"
  bitfld.long 0x00 00.--02.           "AULB  ,Arbitrate on Undefined Length Bursts" "not allowed,allowed,after four beats,after eight beats,after 16 beats,res.,res.,res"
group.long 0xfff04C00++0x03
  line.long 0x00 "MGPCR4,General Purpose Control Register for Master port 4"
  bitfld.long 0x00 00.--02.           "AULB  ,Arbitrate on Undefined Length Bursts" "not allowed,allowed,after four beats,after eight beats,after 16 beats,res.,res.,res"
group.long 0xfff04D00++0x03
  line.long 0x00 "MGPCR5,General Purpose Control Register for Master port 5"
  bitfld.long 0x00 00.--02.           "AULB  ,Arbitrate on Undefined Length Bursts" "not allowed,allowed,after four beats,after eight beats,after 16 beats,res.,res.,res"
group.long 0xfff04E00++0x03
  line.long 0x00 "MGPCR6,General Purpose Control Register for Master port 6"
  bitfld.long 0x00 00.--02.           "AULB  ,Arbitrate on Undefined Length Bursts" "not allowed,allowed,after four beats,after eight beats,after 16 beats,res.,res.,res"
group.long 0xfff04F00++0x03
  line.long 0x00 "MGPCR7,General Purpose Control Register for Master port 7"
  bitfld.long 0x00 00.--02.           "AULB  ,Arbitrate on Undefined Length Bursts" "not allowed,allowed,after four beats,after eight beats,after 16 beats,res.,res.,res"


TEXTLINE ""
group.long 0xfff04000++0x03 "Slave Port 0"
  line.long 0x00 "MPR0,Master Priority Register for Slave Port 0"
  bitfld.long 0x00 28.--30.             "MSTR7 ,Master 7 priority" "0(high),1,2,3,4,5,6,7(low)"
  bitfld.long 0x00 24.--26.           "  MSTR6 ,Master 6 priority" "0(high),1,2,3,4,5,6,7(low)"
  bitfld.long 0x00 20.--22.           "  MSTR5 ,Master 5 priority" "0(high),1,2,3,4,5,6,7(low)"
  bitfld.long 0x00 16.--18.           "  MSTR4 ,Master 4 priority" "0(high),1,2,3,4,5,6,7(low)"
TEXTLINE "                "
  bitfld.long 0x00 12.--14.           "  MSTR3 ,Master 3 priority" "0(high),1,2,3,4,5,6,7(low)"
  bitfld.long 0x00 08.--10.           "  MSTR2 ,Master 2 priority" "0(high),1,2,3,4,5,6,7(low)"
  bitfld.long 0x00 04.--06.           "  MSTR1 ,Master 1 priority" "0(high),1,2,3,4,5,6,7(low)"
  bitfld.long 0x00 00.--02.           "  MSTR0 ,Master 0 priority" "0(high),1,2,3,4,5,6,7(low)"
TEXTLINE ""

group.long (0xfff04000+0x04)++0x03
  line.long 0x00 "AMPR0,Alternate Master Priority Register for Slave Port 0"
  bitfld.long 0x00 28.--30.             "MSTR7 ,Master 7 priority" "0(high),1,2,3,4,5,6,7(low)"
  bitfld.long 0x00 24.--26.           "  MSTR6 ,Master 6 priority" "0(high),1,2,3,4,5,6,7(low)"
  bitfld.long 0x00 20.--22.           "  MSTR5 ,Master 5 priority" "0(high),1,2,3,4,5,6,7(low)"
  bitfld.long 0x00 16.--18.           "  MSTR4 ,Master 4 priority" "0(high),1,2,3,4,5,6,7(low)"
TEXTLINE "                "
  bitfld.long 0x00 12.--14.           "  MSTR3 ,Master 3 priority" "0(high),1,2,3,4,5,6,7(low)"
  bitfld.long 0x00 08.--10.           "  MSTR2 ,Master 2 priority" "0(high),1,2,3,4,5,6,7(low)"
  bitfld.long 0x00 04.--06.           "  MSTR1 ,Master 1 priority" "0(high),1,2,3,4,5,6,7(low)"
  bitfld.long 0x00 00.--02.           "  MSTR0 ,Master 0 priority" "0(high),1,2,3,4,5,6,7(low)"
TEXTLINE ""

group.long (0xfff04000+0x10)++0x03
  line.long 0x00 "SGPCR0,Slave General Purpose Control Register 0"
  bitfld.long 0x00 31.                  "RO    ,Read Only" "0,1"
  bitfld.long 0x00 30.                "  HLP   ,Halt Low Priority" "0,1"
TEXTLINE "                "
  bitfld.long 0x00 23.                "  HPE7  ,High Priority Enable" "0,1"
  bitfld.long 0x00 22.                "  HPE6  ,High Priority Enable" "0,1"
  bitfld.long 0x00 21.                "  HPE5  ,High Priority Enable" "0,1"
  bitfld.long 0x00 20.                "  HPE4  ,High Priority Enable" "0,1"
TEXTLINE "                "
  bitfld.long 0x00 19.                "  HPE3  ,High Priority Enable" "0,1"
  bitfld.long 0x00 18.                "  HPE2  ,High Priority Enable" "0,1"
  bitfld.long 0x00 17.                "  HPE1  ,High Priority Enable" "0,1"
  bitfld.long 0x00 16.                "  HPE0  ,High Priority Enable" "0,1"
TEXTLINE "                "
  bitfld.long 0x00 08.--09.           "  ARB   ,Arbitration mode" "Fixed (MPR),Round-robin,res,res"
  bitfld.long 0x00 04.--05.           "  PCTL  ,Parking control" "PARK ctrl field,Park on last,Low power park,res"
  bitfld.long 0x00 00.--02.           "  PARK  ,Park" "Master Port 0,Master Port 1,Master Port 2,Master Port 3,Master Port 4,Master Port 5,Master Port 6,Master Port 7"
TEXTLINE ""

group.long (0xfff04000+0x14)++0x03
  line.long 0x00 "ASGPCR0,Alternate Slave General Purpose Control Register 0"
  bitfld.long 0x00 30.                  "HLP   ,Halt Low Priority" "0,1"
TEXTLINE "                "
  bitfld.long 0x00 23.                "  HPE7  ,High Priority Enable" "0,1"
  bitfld.long 0x00 22.                "  HPE6  ,High Priority Enable" "0,1"
  bitfld.long 0x00 21.                "  HPE5  ,High Priority Enable" "0,1"
  bitfld.long 0x00 20.                "  HPE4  ,High Priority Enable" "0,1"
TEXTLINE "                "
  bitfld.long 0x00 19.                "  HPE3  ,High Priority Enable" "0,1"
  bitfld.long 0x00 18.                "  HPE2  ,High Priority Enable" "0,1"
  bitfld.long 0x00 17.                "  HPE1  ,High Priority Enable" "0,1"
  bitfld.long 0x00 16.                "  HPE0  ,High Priority Enable" "0,1"
TEXTLINE "                "
  bitfld.long 0x00 08.--09.           "  ARB   ,Arbitration mode" "Fixed (MPR),Round-robin,res,res"
  bitfld.long 0x00 04.--05.           "  PCTL  ,Parking control" "PARK ctrl field,Park on last,Low power park,res"
  bitfld.long 0x00 00.--02.           "  PARK  ,Park" "Master Port 0,Master Port 1,Master Port 2,Master Port 3,Master Port 4,Master Port 5,Master Port 6,Master Port 7"
TEXTLINE ""
group.long 0xfff04100++0x03 "Slave Port 1"
  line.long 0x00 "MPR1,Master Priority Register for Slave Port 1"
  bitfld.long 0x00 28.--30.             "MSTR7 ,Master 7 priority" "0(high),1,2,3,4,5,6,7(low)"
  bitfld.long 0x00 24.--26.           "  MSTR6 ,Master 6 priority" "0(high),1,2,3,4,5,6,7(low)"
  bitfld.long 0x00 20.--22.           "  MSTR5 ,Master 5 priority" "0(high),1,2,3,4,5,6,7(low)"
  bitfld.long 0x00 16.--18.           "  MSTR4 ,Master 4 priority" "0(high),1,2,3,4,5,6,7(low)"
TEXTLINE "                "
  bitfld.long 0x00 12.--14.           "  MSTR3 ,Master 3 priority" "0(high),1,2,3,4,5,6,7(low)"
  bitfld.long 0x00 08.--10.           "  MSTR2 ,Master 2 priority" "0(high),1,2,3,4,5,6,7(low)"
  bitfld.long 0x00 04.--06.           "  MSTR1 ,Master 1 priority" "0(high),1,2,3,4,5,6,7(low)"
  bitfld.long 0x00 00.--02.           "  MSTR0 ,Master 0 priority" "0(high),1,2,3,4,5,6,7(low)"
TEXTLINE ""

group.long (0xfff04100+0x04)++0x03
  line.long 0x00 "AMPR1,Alternate Master Priority Register for Slave Port 1"
  bitfld.long 0x00 28.--30.             "MSTR7 ,Master 7 priority" "0(high),1,2,3,4,5,6,7(low)"
  bitfld.long 0x00 24.--26.           "  MSTR6 ,Master 6 priority" "0(high),1,2,3,4,5,6,7(low)"
  bitfld.long 0x00 20.--22.           "  MSTR5 ,Master 5 priority" "0(high),1,2,3,4,5,6,7(low)"
  bitfld.long 0x00 16.--18.           "  MSTR4 ,Master 4 priority" "0(high),1,2,3,4,5,6,7(low)"
TEXTLINE "                "
  bitfld.long 0x00 12.--14.           "  MSTR3 ,Master 3 priority" "0(high),1,2,3,4,5,6,7(low)"
  bitfld.long 0x00 08.--10.           "  MSTR2 ,Master 2 priority" "0(high),1,2,3,4,5,6,7(low)"
  bitfld.long 0x00 04.--06.           "  MSTR1 ,Master 1 priority" "0(high),1,2,3,4,5,6,7(low)"
  bitfld.long 0x00 00.--02.           "  MSTR0 ,Master 0 priority" "0(high),1,2,3,4,5,6,7(low)"
TEXTLINE ""

group.long (0xfff04100+0x10)++0x03
  line.long 0x00 "SGPCR1,Slave General Purpose Control Register 1"
  bitfld.long 0x00 31.                  "RO    ,Read Only" "0,1"
  bitfld.long 0x00 30.                "  HLP   ,Halt Low Priority" "0,1"
TEXTLINE "                "
  bitfld.long 0x00 23.                "  HPE7  ,High Priority Enable" "0,1"
  bitfld.long 0x00 22.                "  HPE6  ,High Priority Enable" "0,1"
  bitfld.long 0x00 21.                "  HPE5  ,High Priority Enable" "0,1"
  bitfld.long 0x00 20.                "  HPE4  ,High Priority Enable" "0,1"
TEXTLINE "                "
  bitfld.long 0x00 19.                "  HPE3  ,High Priority Enable" "0,1"
  bitfld.long 0x00 18.                "  HPE2  ,High Priority Enable" "0,1"
  bitfld.long 0x00 17.                "  HPE1  ,High Priority Enable" "0,1"
  bitfld.long 0x00 16.                "  HPE0  ,High Priority Enable" "0,1"
TEXTLINE "                "
  bitfld.long 0x00 08.--09.           "  ARB   ,Arbitration mode" "Fixed (MPR),Round-robin,res,res"
  bitfld.long 0x00 04.--05.           "  PCTL  ,Parking control" "PARK ctrl field,Park on last,Low power park,res"
  bitfld.long 0x00 00.--02.           "  PARK  ,Park" "Master Port 0,Master Port 1,Master Port 2,Master Port 3,Master Port 4,Master Port 5,Master Port 6,Master Port 7"
TEXTLINE ""

group.long (0xfff04100+0x14)++0x03
  line.long 0x00 "ASGPCR1,Alternate Slave General Purpose Control Register 1"
  bitfld.long 0x00 30.                  "HLP   ,Halt Low Priority" "0,1"
TEXTLINE "                "
  bitfld.long 0x00 23.                "  HPE7  ,High Priority Enable" "0,1"
  bitfld.long 0x00 22.                "  HPE6  ,High Priority Enable" "0,1"
  bitfld.long 0x00 21.                "  HPE5  ,High Priority Enable" "0,1"
  bitfld.long 0x00 20.                "  HPE4  ,High Priority Enable" "0,1"
TEXTLINE "                "
  bitfld.long 0x00 19.                "  HPE3  ,High Priority Enable" "0,1"
  bitfld.long 0x00 18.                "  HPE2  ,High Priority Enable" "0,1"
  bitfld.long 0x00 17.                "  HPE1  ,High Priority Enable" "0,1"
  bitfld.long 0x00 16.                "  HPE0  ,High Priority Enable" "0,1"
TEXTLINE "                "
  bitfld.long 0x00 08.--09.           "  ARB   ,Arbitration mode" "Fixed (MPR),Round-robin,res,res"
  bitfld.long 0x00 04.--05.           "  PCTL  ,Parking control" "PARK ctrl field,Park on last,Low power park,res"
  bitfld.long 0x00 00.--02.           "  PARK  ,Park" "Master Port 0,Master Port 1,Master Port 2,Master Port 3,Master Port 4,Master Port 5,Master Port 6,Master Port 7"
TEXTLINE ""
group.long 0xfff04200++0x03 "Slave Port 2"
  line.long 0x00 "MPR2,Master Priority Register for Slave Port 2"
  bitfld.long 0x00 28.--30.             "MSTR7 ,Master 7 priority" "0(high),1,2,3,4,5,6,7(low)"
  bitfld.long 0x00 24.--26.           "  MSTR6 ,Master 6 priority" "0(high),1,2,3,4,5,6,7(low)"
  bitfld.long 0x00 20.--22.           "  MSTR5 ,Master 5 priority" "0(high),1,2,3,4,5,6,7(low)"
  bitfld.long 0x00 16.--18.           "  MSTR4 ,Master 4 priority" "0(high),1,2,3,4,5,6,7(low)"
TEXTLINE "                "
  bitfld.long 0x00 12.--14.           "  MSTR3 ,Master 3 priority" "0(high),1,2,3,4,5,6,7(low)"
  bitfld.long 0x00 08.--10.           "  MSTR2 ,Master 2 priority" "0(high),1,2,3,4,5,6,7(low)"
  bitfld.long 0x00 04.--06.           "  MSTR1 ,Master 1 priority" "0(high),1,2,3,4,5,6,7(low)"
  bitfld.long 0x00 00.--02.           "  MSTR0 ,Master 0 priority" "0(high),1,2,3,4,5,6,7(low)"
TEXTLINE ""

group.long (0xfff04200+0x04)++0x03
  line.long 0x00 "AMPR2,Alternate Master Priority Register for Slave Port 2"
  bitfld.long 0x00 28.--30.             "MSTR7 ,Master 7 priority" "0(high),1,2,3,4,5,6,7(low)"
  bitfld.long 0x00 24.--26.           "  MSTR6 ,Master 6 priority" "0(high),1,2,3,4,5,6,7(low)"
  bitfld.long 0x00 20.--22.           "  MSTR5 ,Master 5 priority" "0(high),1,2,3,4,5,6,7(low)"
  bitfld.long 0x00 16.--18.           "  MSTR4 ,Master 4 priority" "0(high),1,2,3,4,5,6,7(low)"
TEXTLINE "                "
  bitfld.long 0x00 12.--14.           "  MSTR3 ,Master 3 priority" "0(high),1,2,3,4,5,6,7(low)"
  bitfld.long 0x00 08.--10.           "  MSTR2 ,Master 2 priority" "0(high),1,2,3,4,5,6,7(low)"
  bitfld.long 0x00 04.--06.           "  MSTR1 ,Master 1 priority" "0(high),1,2,3,4,5,6,7(low)"
  bitfld.long 0x00 00.--02.           "  MSTR0 ,Master 0 priority" "0(high),1,2,3,4,5,6,7(low)"
TEXTLINE ""

group.long (0xfff04200+0x10)++0x03
  line.long 0x00 "SGPCR2,Slave General Purpose Control Register 2"
  bitfld.long 0x00 31.                  "RO    ,Read Only" "0,1"
  bitfld.long 0x00 30.                "  HLP   ,Halt Low Priority" "0,1"
TEXTLINE "                "
  bitfld.long 0x00 23.                "  HPE7  ,High Priority Enable" "0,1"
  bitfld.long 0x00 22.                "  HPE6  ,High Priority Enable" "0,1"
  bitfld.long 0x00 21.                "  HPE5  ,High Priority Enable" "0,1"
  bitfld.long 0x00 20.                "  HPE4  ,High Priority Enable" "0,1"
TEXTLINE "                "
  bitfld.long 0x00 19.                "  HPE3  ,High Priority Enable" "0,1"
  bitfld.long 0x00 18.                "  HPE2  ,High Priority Enable" "0,1"
  bitfld.long 0x00 17.                "  HPE1  ,High Priority Enable" "0,1"
  bitfld.long 0x00 16.                "  HPE0  ,High Priority Enable" "0,1"
TEXTLINE "                "
  bitfld.long 0x00 08.--09.           "  ARB   ,Arbitration mode" "Fixed (MPR),Round-robin,res,res"
  bitfld.long 0x00 04.--05.           "  PCTL  ,Parking control" "PARK ctrl field,Park on last,Low power park,res"
  bitfld.long 0x00 00.--02.           "  PARK  ,Park" "Master Port 0,Master Port 1,Master Port 2,Master Port 3,Master Port 4,Master Port 5,Master Port 6,Master Port 7"
TEXTLINE ""

group.long (0xfff04200+0x14)++0x03
  line.long 0x00 "ASGPCR2,Alternate Slave General Purpose Control Register 2"
  bitfld.long 0x00 30.                  "HLP   ,Halt Low Priority" "0,1"
TEXTLINE "                "
  bitfld.long 0x00 23.                "  HPE7  ,High Priority Enable" "0,1"
  bitfld.long 0x00 22.                "  HPE6  ,High Priority Enable" "0,1"
  bitfld.long 0x00 21.                "  HPE5  ,High Priority Enable" "0,1"
  bitfld.long 0x00 20.                "  HPE4  ,High Priority Enable" "0,1"
TEXTLINE "                "
  bitfld.long 0x00 19.                "  HPE3  ,High Priority Enable" "0,1"
  bitfld.long 0x00 18.                "  HPE2  ,High Priority Enable" "0,1"
  bitfld.long 0x00 17.                "  HPE1  ,High Priority Enable" "0,1"
  bitfld.long 0x00 16.                "  HPE0  ,High Priority Enable" "0,1"
TEXTLINE "                "
  bitfld.long 0x00 08.--09.           "  ARB   ,Arbitration mode" "Fixed (MPR),Round-robin,res,res"
  bitfld.long 0x00 04.--05.           "  PCTL  ,Parking control" "PARK ctrl field,Park on last,Low power park,res"
  bitfld.long 0x00 00.--02.           "  PARK  ,Park" "Master Port 0,Master Port 1,Master Port 2,Master Port 3,Master Port 4,Master Port 5,Master Port 6,Master Port 7"
TEXTLINE ""
group.long 0xfff04300++0x03 "Slave Port 3"
  line.long 0x00 "MPR3,Master Priority Register for Slave Port 3"
  bitfld.long 0x00 28.--30.             "MSTR7 ,Master 7 priority" "0(high),1,2,3,4,5,6,7(low)"
  bitfld.long 0x00 24.--26.           "  MSTR6 ,Master 6 priority" "0(high),1,2,3,4,5,6,7(low)"
  bitfld.long 0x00 20.--22.           "  MSTR5 ,Master 5 priority" "0(high),1,2,3,4,5,6,7(low)"
  bitfld.long 0x00 16.--18.           "  MSTR4 ,Master 4 priority" "0(high),1,2,3,4,5,6,7(low)"
TEXTLINE "                "
  bitfld.long 0x00 12.--14.           "  MSTR3 ,Master 3 priority" "0(high),1,2,3,4,5,6,7(low)"
  bitfld.long 0x00 08.--10.           "  MSTR2 ,Master 2 priority" "0(high),1,2,3,4,5,6,7(low)"
  bitfld.long 0x00 04.--06.           "  MSTR1 ,Master 1 priority" "0(high),1,2,3,4,5,6,7(low)"
  bitfld.long 0x00 00.--02.           "  MSTR0 ,Master 0 priority" "0(high),1,2,3,4,5,6,7(low)"
TEXTLINE ""

group.long (0xfff04300+0x04)++0x03
  line.long 0x00 "AMPR3,Alternate Master Priority Register for Slave Port 3"
  bitfld.long 0x00 28.--30.             "MSTR7 ,Master 7 priority" "0(high),1,2,3,4,5,6,7(low)"
  bitfld.long 0x00 24.--26.           "  MSTR6 ,Master 6 priority" "0(high),1,2,3,4,5,6,7(low)"
  bitfld.long 0x00 20.--22.           "  MSTR5 ,Master 5 priority" "0(high),1,2,3,4,5,6,7(low)"
  bitfld.long 0x00 16.--18.           "  MSTR4 ,Master 4 priority" "0(high),1,2,3,4,5,6,7(low)"
TEXTLINE "                "
  bitfld.long 0x00 12.--14.           "  MSTR3 ,Master 3 priority" "0(high),1,2,3,4,5,6,7(low)"
  bitfld.long 0x00 08.--10.           "  MSTR2 ,Master 2 priority" "0(high),1,2,3,4,5,6,7(low)"
  bitfld.long 0x00 04.--06.           "  MSTR1 ,Master 1 priority" "0(high),1,2,3,4,5,6,7(low)"
  bitfld.long 0x00 00.--02.           "  MSTR0 ,Master 0 priority" "0(high),1,2,3,4,5,6,7(low)"
TEXTLINE ""

group.long (0xfff04300+0x10)++0x03
  line.long 0x00 "SGPCR3,Slave General Purpose Control Register 3"
  bitfld.long 0x00 31.                  "RO    ,Read Only" "0,1"
  bitfld.long 0x00 30.                "  HLP   ,Halt Low Priority" "0,1"
TEXTLINE "                "
  bitfld.long 0x00 23.                "  HPE7  ,High Priority Enable" "0,1"
  bitfld.long 0x00 22.                "  HPE6  ,High Priority Enable" "0,1"
  bitfld.long 0x00 21.                "  HPE5  ,High Priority Enable" "0,1"
  bitfld.long 0x00 20.                "  HPE4  ,High Priority Enable" "0,1"
TEXTLINE "                "
  bitfld.long 0x00 19.                "  HPE3  ,High Priority Enable" "0,1"
  bitfld.long 0x00 18.                "  HPE2  ,High Priority Enable" "0,1"
  bitfld.long 0x00 17.                "  HPE1  ,High Priority Enable" "0,1"
  bitfld.long 0x00 16.                "  HPE0  ,High Priority Enable" "0,1"
TEXTLINE "                "
  bitfld.long 0x00 08.--09.           "  ARB   ,Arbitration mode" "Fixed (MPR),Round-robin,res,res"
  bitfld.long 0x00 04.--05.           "  PCTL  ,Parking control" "PARK ctrl field,Park on last,Low power park,res"
  bitfld.long 0x00 00.--02.           "  PARK  ,Park" "Master Port 0,Master Port 1,Master Port 2,Master Port 3,Master Port 4,Master Port 5,Master Port 6,Master Port 7"
TEXTLINE ""

group.long (0xfff04300+0x14)++0x03
  line.long 0x00 "ASGPCR3,Alternate Slave General Purpose Control Register 3"
  bitfld.long 0x00 30.                  "HLP   ,Halt Low Priority" "0,1"
TEXTLINE "                "
  bitfld.long 0x00 23.                "  HPE7  ,High Priority Enable" "0,1"
  bitfld.long 0x00 22.                "  HPE6  ,High Priority Enable" "0,1"
  bitfld.long 0x00 21.                "  HPE5  ,High Priority Enable" "0,1"
  bitfld.long 0x00 20.                "  HPE4  ,High Priority Enable" "0,1"
TEXTLINE "                "
  bitfld.long 0x00 19.                "  HPE3  ,High Priority Enable" "0,1"
  bitfld.long 0x00 18.                "  HPE2  ,High Priority Enable" "0,1"
  bitfld.long 0x00 17.                "  HPE1  ,High Priority Enable" "0,1"
  bitfld.long 0x00 16.                "  HPE0  ,High Priority Enable" "0,1"
TEXTLINE "                "
  bitfld.long 0x00 08.--09.           "  ARB   ,Arbitration mode" "Fixed (MPR),Round-robin,res,res"
  bitfld.long 0x00 04.--05.           "  PCTL  ,Parking control" "PARK ctrl field,Park on last,Low power park,res"
  bitfld.long 0x00 00.--02.           "  PARK  ,Park" "Master Port 0,Master Port 1,Master Port 2,Master Port 3,Master Port 4,Master Port 5,Master Port 6,Master Port 7"
TEXTLINE ""
group.long 0xfff04400++0x03 "Slave Port 4"
  line.long 0x00 "MPR4,Master Priority Register for Slave Port 4"
  bitfld.long 0x00 28.--30.             "MSTR7 ,Master 7 priority" "0(high),1,2,3,4,5,6,7(low)"
  bitfld.long 0x00 24.--26.           "  MSTR6 ,Master 6 priority" "0(high),1,2,3,4,5,6,7(low)"
  bitfld.long 0x00 20.--22.           "  MSTR5 ,Master 5 priority" "0(high),1,2,3,4,5,6,7(low)"
  bitfld.long 0x00 16.--18.           "  MSTR4 ,Master 4 priority" "0(high),1,2,3,4,5,6,7(low)"
TEXTLINE "                "
  bitfld.long 0x00 12.--14.           "  MSTR3 ,Master 3 priority" "0(high),1,2,3,4,5,6,7(low)"
  bitfld.long 0x00 08.--10.           "  MSTR2 ,Master 2 priority" "0(high),1,2,3,4,5,6,7(low)"
  bitfld.long 0x00 04.--06.           "  MSTR1 ,Master 1 priority" "0(high),1,2,3,4,5,6,7(low)"
  bitfld.long 0x00 00.--02.           "  MSTR0 ,Master 0 priority" "0(high),1,2,3,4,5,6,7(low)"
TEXTLINE ""

group.long (0xfff04400+0x04)++0x03
  line.long 0x00 "AMPR4,Alternate Master Priority Register for Slave Port 4"
  bitfld.long 0x00 28.--30.             "MSTR7 ,Master 7 priority" "0(high),1,2,3,4,5,6,7(low)"
  bitfld.long 0x00 24.--26.           "  MSTR6 ,Master 6 priority" "0(high),1,2,3,4,5,6,7(low)"
  bitfld.long 0x00 20.--22.           "  MSTR5 ,Master 5 priority" "0(high),1,2,3,4,5,6,7(low)"
  bitfld.long 0x00 16.--18.           "  MSTR4 ,Master 4 priority" "0(high),1,2,3,4,5,6,7(low)"
TEXTLINE "                "
  bitfld.long 0x00 12.--14.           "  MSTR3 ,Master 3 priority" "0(high),1,2,3,4,5,6,7(low)"
  bitfld.long 0x00 08.--10.           "  MSTR2 ,Master 2 priority" "0(high),1,2,3,4,5,6,7(low)"
  bitfld.long 0x00 04.--06.           "  MSTR1 ,Master 1 priority" "0(high),1,2,3,4,5,6,7(low)"
  bitfld.long 0x00 00.--02.           "  MSTR0 ,Master 0 priority" "0(high),1,2,3,4,5,6,7(low)"
TEXTLINE ""

group.long (0xfff04400+0x10)++0x03
  line.long 0x00 "SGPCR4,Slave General Purpose Control Register 4"
  bitfld.long 0x00 31.                  "RO    ,Read Only" "0,1"
  bitfld.long 0x00 30.                "  HLP   ,Halt Low Priority" "0,1"
TEXTLINE "                "
  bitfld.long 0x00 23.                "  HPE7  ,High Priority Enable" "0,1"
  bitfld.long 0x00 22.                "  HPE6  ,High Priority Enable" "0,1"
  bitfld.long 0x00 21.                "  HPE5  ,High Priority Enable" "0,1"
  bitfld.long 0x00 20.                "  HPE4  ,High Priority Enable" "0,1"
TEXTLINE "                "
  bitfld.long 0x00 19.                "  HPE3  ,High Priority Enable" "0,1"
  bitfld.long 0x00 18.                "  HPE2  ,High Priority Enable" "0,1"
  bitfld.long 0x00 17.                "  HPE1  ,High Priority Enable" "0,1"
  bitfld.long 0x00 16.                "  HPE0  ,High Priority Enable" "0,1"
TEXTLINE "                "
  bitfld.long 0x00 08.--09.           "  ARB   ,Arbitration mode" "Fixed (MPR),Round-robin,res,res"
  bitfld.long 0x00 04.--05.           "  PCTL  ,Parking control" "PARK ctrl field,Park on last,Low power park,res"
  bitfld.long 0x00 00.--02.           "  PARK  ,Park" "Master Port 0,Master Port 1,Master Port 2,Master Port 3,Master Port 4,Master Port 5,Master Port 6,Master Port 7"
TEXTLINE ""

group.long (0xfff04400+0x14)++0x03
  line.long 0x00 "ASGPCR4,Alternate Slave General Purpose Control Register 4"
  bitfld.long 0x00 30.                  "HLP   ,Halt Low Priority" "0,1"
TEXTLINE "                "
  bitfld.long 0x00 23.                "  HPE7  ,High Priority Enable" "0,1"
  bitfld.long 0x00 22.                "  HPE6  ,High Priority Enable" "0,1"
  bitfld.long 0x00 21.                "  HPE5  ,High Priority Enable" "0,1"
  bitfld.long 0x00 20.                "  HPE4  ,High Priority Enable" "0,1"
TEXTLINE "                "
  bitfld.long 0x00 19.                "  HPE3  ,High Priority Enable" "0,1"
  bitfld.long 0x00 18.                "  HPE2  ,High Priority Enable" "0,1"
  bitfld.long 0x00 17.                "  HPE1  ,High Priority Enable" "0,1"
  bitfld.long 0x00 16.                "  HPE0  ,High Priority Enable" "0,1"
TEXTLINE "                "
  bitfld.long 0x00 08.--09.           "  ARB   ,Arbitration mode" "Fixed (MPR),Round-robin,res,res"
  bitfld.long 0x00 04.--05.           "  PCTL  ,Parking control" "PARK ctrl field,Park on last,Low power park,res"
  bitfld.long 0x00 00.--02.           "  PARK  ,Park" "Master Port 0,Master Port 1,Master Port 2,Master Port 3,Master Port 4,Master Port 5,Master Port 6,Master Port 7"
TEXTLINE ""
group.long 0xfff04500++0x03 "Slave Port 5"
  line.long 0x00 "MPR5,Master Priority Register for Slave Port 5"
  bitfld.long 0x00 28.--30.             "MSTR7 ,Master 7 priority" "0(high),1,2,3,4,5,6,7(low)"
  bitfld.long 0x00 24.--26.           "  MSTR6 ,Master 6 priority" "0(high),1,2,3,4,5,6,7(low)"
  bitfld.long 0x00 20.--22.           "  MSTR5 ,Master 5 priority" "0(high),1,2,3,4,5,6,7(low)"
  bitfld.long 0x00 16.--18.           "  MSTR4 ,Master 4 priority" "0(high),1,2,3,4,5,6,7(low)"
TEXTLINE "                "
  bitfld.long 0x00 12.--14.           "  MSTR3 ,Master 3 priority" "0(high),1,2,3,4,5,6,7(low)"
  bitfld.long 0x00 08.--10.           "  MSTR2 ,Master 2 priority" "0(high),1,2,3,4,5,6,7(low)"
  bitfld.long 0x00 04.--06.           "  MSTR1 ,Master 1 priority" "0(high),1,2,3,4,5,6,7(low)"
  bitfld.long 0x00 00.--02.           "  MSTR0 ,Master 0 priority" "0(high),1,2,3,4,5,6,7(low)"
TEXTLINE ""

group.long (0xfff04500+0x04)++0x03
  line.long 0x00 "AMPR5,Alternate Master Priority Register for Slave Port 5"
  bitfld.long 0x00 28.--30.             "MSTR7 ,Master 7 priority" "0(high),1,2,3,4,5,6,7(low)"
  bitfld.long 0x00 24.--26.           "  MSTR6 ,Master 6 priority" "0(high),1,2,3,4,5,6,7(low)"
  bitfld.long 0x00 20.--22.           "  MSTR5 ,Master 5 priority" "0(high),1,2,3,4,5,6,7(low)"
  bitfld.long 0x00 16.--18.           "  MSTR4 ,Master 4 priority" "0(high),1,2,3,4,5,6,7(low)"
TEXTLINE "                "
  bitfld.long 0x00 12.--14.           "  MSTR3 ,Master 3 priority" "0(high),1,2,3,4,5,6,7(low)"
  bitfld.long 0x00 08.--10.           "  MSTR2 ,Master 2 priority" "0(high),1,2,3,4,5,6,7(low)"
  bitfld.long 0x00 04.--06.           "  MSTR1 ,Master 1 priority" "0(high),1,2,3,4,5,6,7(low)"
  bitfld.long 0x00 00.--02.           "  MSTR0 ,Master 0 priority" "0(high),1,2,3,4,5,6,7(low)"
TEXTLINE ""

group.long (0xfff04500+0x10)++0x03
  line.long 0x00 "SGPCR5,Slave General Purpose Control Register 5"
  bitfld.long 0x00 31.                  "RO    ,Read Only" "0,1"
  bitfld.long 0x00 30.                "  HLP   ,Halt Low Priority" "0,1"
TEXTLINE "                "
  bitfld.long 0x00 23.                "  HPE7  ,High Priority Enable" "0,1"
  bitfld.long 0x00 22.                "  HPE6  ,High Priority Enable" "0,1"
  bitfld.long 0x00 21.                "  HPE5  ,High Priority Enable" "0,1"
  bitfld.long 0x00 20.                "  HPE4  ,High Priority Enable" "0,1"
TEXTLINE "                "
  bitfld.long 0x00 19.                "  HPE3  ,High Priority Enable" "0,1"
  bitfld.long 0x00 18.                "  HPE2  ,High Priority Enable" "0,1"
  bitfld.long 0x00 17.                "  HPE1  ,High Priority Enable" "0,1"
  bitfld.long 0x00 16.                "  HPE0  ,High Priority Enable" "0,1"
TEXTLINE "                "
  bitfld.long 0x00 08.--09.           "  ARB   ,Arbitration mode" "Fixed (MPR),Round-robin,res,res"
  bitfld.long 0x00 04.--05.           "  PCTL  ,Parking control" "PARK ctrl field,Park on last,Low power park,res"
  bitfld.long 0x00 00.--02.           "  PARK  ,Park" "Master Port 0,Master Port 1,Master Port 2,Master Port 3,Master Port 4,Master Port 5,Master Port 6,Master Port 7"
TEXTLINE ""

group.long (0xfff04500+0x14)++0x03
  line.long 0x00 "ASGPCR5,Alternate Slave General Purpose Control Register 5"
  bitfld.long 0x00 30.                  "HLP   ,Halt Low Priority" "0,1"
TEXTLINE "                "
  bitfld.long 0x00 23.                "  HPE7  ,High Priority Enable" "0,1"
  bitfld.long 0x00 22.                "  HPE6  ,High Priority Enable" "0,1"
  bitfld.long 0x00 21.                "  HPE5  ,High Priority Enable" "0,1"
  bitfld.long 0x00 20.                "  HPE4  ,High Priority Enable" "0,1"
TEXTLINE "                "
  bitfld.long 0x00 19.                "  HPE3  ,High Priority Enable" "0,1"
  bitfld.long 0x00 18.                "  HPE2  ,High Priority Enable" "0,1"
  bitfld.long 0x00 17.                "  HPE1  ,High Priority Enable" "0,1"
  bitfld.long 0x00 16.                "  HPE0  ,High Priority Enable" "0,1"
TEXTLINE "                "
  bitfld.long 0x00 08.--09.           "  ARB   ,Arbitration mode" "Fixed (MPR),Round-robin,res,res"
  bitfld.long 0x00 04.--05.           "  PCTL  ,Parking control" "PARK ctrl field,Park on last,Low power park,res"
  bitfld.long 0x00 00.--02.           "  PARK  ,Park" "Master Port 0,Master Port 1,Master Port 2,Master Port 3,Master Port 4,Master Port 5,Master Port 6,Master Port 7"
TEXTLINE ""
group.long 0xfff04600++0x03 "Slave Port 6"
  line.long 0x00 "MPR6,Master Priority Register for Slave Port 6"
  bitfld.long 0x00 28.--30.             "MSTR7 ,Master 7 priority" "0(high),1,2,3,4,5,6,7(low)"
  bitfld.long 0x00 24.--26.           "  MSTR6 ,Master 6 priority" "0(high),1,2,3,4,5,6,7(low)"
  bitfld.long 0x00 20.--22.           "  MSTR5 ,Master 5 priority" "0(high),1,2,3,4,5,6,7(low)"
  bitfld.long 0x00 16.--18.           "  MSTR4 ,Master 4 priority" "0(high),1,2,3,4,5,6,7(low)"
TEXTLINE "                "
  bitfld.long 0x00 12.--14.           "  MSTR3 ,Master 3 priority" "0(high),1,2,3,4,5,6,7(low)"
  bitfld.long 0x00 08.--10.           "  MSTR2 ,Master 2 priority" "0(high),1,2,3,4,5,6,7(low)"
  bitfld.long 0x00 04.--06.           "  MSTR1 ,Master 1 priority" "0(high),1,2,3,4,5,6,7(low)"
  bitfld.long 0x00 00.--02.           "  MSTR0 ,Master 0 priority" "0(high),1,2,3,4,5,6,7(low)"
TEXTLINE ""

group.long (0xfff04600+0x04)++0x03
  line.long 0x00 "AMPR6,Alternate Master Priority Register for Slave Port 6"
  bitfld.long 0x00 28.--30.             "MSTR7 ,Master 7 priority" "0(high),1,2,3,4,5,6,7(low)"
  bitfld.long 0x00 24.--26.           "  MSTR6 ,Master 6 priority" "0(high),1,2,3,4,5,6,7(low)"
  bitfld.long 0x00 20.--22.           "  MSTR5 ,Master 5 priority" "0(high),1,2,3,4,5,6,7(low)"
  bitfld.long 0x00 16.--18.           "  MSTR4 ,Master 4 priority" "0(high),1,2,3,4,5,6,7(low)"
TEXTLINE "                "
  bitfld.long 0x00 12.--14.           "  MSTR3 ,Master 3 priority" "0(high),1,2,3,4,5,6,7(low)"
  bitfld.long 0x00 08.--10.           "  MSTR2 ,Master 2 priority" "0(high),1,2,3,4,5,6,7(low)"
  bitfld.long 0x00 04.--06.           "  MSTR1 ,Master 1 priority" "0(high),1,2,3,4,5,6,7(low)"
  bitfld.long 0x00 00.--02.           "  MSTR0 ,Master 0 priority" "0(high),1,2,3,4,5,6,7(low)"
TEXTLINE ""

group.long (0xfff04600+0x10)++0x03
  line.long 0x00 "SGPCR6,Slave General Purpose Control Register 6"
  bitfld.long 0x00 31.                  "RO    ,Read Only" "0,1"
  bitfld.long 0x00 30.                "  HLP   ,Halt Low Priority" "0,1"
TEXTLINE "                "
  bitfld.long 0x00 23.                "  HPE7  ,High Priority Enable" "0,1"
  bitfld.long 0x00 22.                "  HPE6  ,High Priority Enable" "0,1"
  bitfld.long 0x00 21.                "  HPE5  ,High Priority Enable" "0,1"
  bitfld.long 0x00 20.                "  HPE4  ,High Priority Enable" "0,1"
TEXTLINE "                "
  bitfld.long 0x00 19.                "  HPE3  ,High Priority Enable" "0,1"
  bitfld.long 0x00 18.                "  HPE2  ,High Priority Enable" "0,1"
  bitfld.long 0x00 17.                "  HPE1  ,High Priority Enable" "0,1"
  bitfld.long 0x00 16.                "  HPE0  ,High Priority Enable" "0,1"
TEXTLINE "                "
  bitfld.long 0x00 08.--09.           "  ARB   ,Arbitration mode" "Fixed (MPR),Round-robin,res,res"
  bitfld.long 0x00 04.--05.           "  PCTL  ,Parking control" "PARK ctrl field,Park on last,Low power park,res"
  bitfld.long 0x00 00.--02.           "  PARK  ,Park" "Master Port 0,Master Port 1,Master Port 2,Master Port 3,Master Port 4,Master Port 5,Master Port 6,Master Port 7"
TEXTLINE ""

group.long (0xfff04600+0x14)++0x03
  line.long 0x00 "ASGPCR6,Alternate Slave General Purpose Control Register 6"
  bitfld.long 0x00 30.                  "HLP   ,Halt Low Priority" "0,1"
TEXTLINE "                "
  bitfld.long 0x00 23.                "  HPE7  ,High Priority Enable" "0,1"
  bitfld.long 0x00 22.                "  HPE6  ,High Priority Enable" "0,1"
  bitfld.long 0x00 21.                "  HPE5  ,High Priority Enable" "0,1"
  bitfld.long 0x00 20.                "  HPE4  ,High Priority Enable" "0,1"
TEXTLINE "                "
  bitfld.long 0x00 19.                "  HPE3  ,High Priority Enable" "0,1"
  bitfld.long 0x00 18.                "  HPE2  ,High Priority Enable" "0,1"
  bitfld.long 0x00 17.                "  HPE1  ,High Priority Enable" "0,1"
  bitfld.long 0x00 16.                "  HPE0  ,High Priority Enable" "0,1"
TEXTLINE "                "
  bitfld.long 0x00 08.--09.           "  ARB   ,Arbitration mode" "Fixed (MPR),Round-robin,res,res"
  bitfld.long 0x00 04.--05.           "  PCTL  ,Parking control" "PARK ctrl field,Park on last,Low power park,res"
  bitfld.long 0x00 00.--02.           "  PARK  ,Park" "Master Port 0,Master Port 1,Master Port 2,Master Port 3,Master Port 4,Master Port 5,Master Port 6,Master Port 7"
TEXTLINE ""
group.long 0xfff04700++0x03 "Slave Port 7"
  line.long 0x00 "MPR7,Master Priority Register for Slave Port 7"
  bitfld.long 0x00 28.--30.             "MSTR7 ,Master 7 priority" "0(high),1,2,3,4,5,6,7(low)"
  bitfld.long 0x00 24.--26.           "  MSTR6 ,Master 6 priority" "0(high),1,2,3,4,5,6,7(low)"
  bitfld.long 0x00 20.--22.           "  MSTR5 ,Master 5 priority" "0(high),1,2,3,4,5,6,7(low)"
  bitfld.long 0x00 16.--18.           "  MSTR4 ,Master 4 priority" "0(high),1,2,3,4,5,6,7(low)"
TEXTLINE "                "
  bitfld.long 0x00 12.--14.           "  MSTR3 ,Master 3 priority" "0(high),1,2,3,4,5,6,7(low)"
  bitfld.long 0x00 08.--10.           "  MSTR2 ,Master 2 priority" "0(high),1,2,3,4,5,6,7(low)"
  bitfld.long 0x00 04.--06.           "  MSTR1 ,Master 1 priority" "0(high),1,2,3,4,5,6,7(low)"
  bitfld.long 0x00 00.--02.           "  MSTR0 ,Master 0 priority" "0(high),1,2,3,4,5,6,7(low)"
TEXTLINE ""

group.long (0xfff04700+0x04)++0x03
  line.long 0x00 "AMPR7,Alternate Master Priority Register for Slave Port 7"
  bitfld.long 0x00 28.--30.             "MSTR7 ,Master 7 priority" "0(high),1,2,3,4,5,6,7(low)"
  bitfld.long 0x00 24.--26.           "  MSTR6 ,Master 6 priority" "0(high),1,2,3,4,5,6,7(low)"
  bitfld.long 0x00 20.--22.           "  MSTR5 ,Master 5 priority" "0(high),1,2,3,4,5,6,7(low)"
  bitfld.long 0x00 16.--18.           "  MSTR4 ,Master 4 priority" "0(high),1,2,3,4,5,6,7(low)"
TEXTLINE "                "
  bitfld.long 0x00 12.--14.           "  MSTR3 ,Master 3 priority" "0(high),1,2,3,4,5,6,7(low)"
  bitfld.long 0x00 08.--10.           "  MSTR2 ,Master 2 priority" "0(high),1,2,3,4,5,6,7(low)"
  bitfld.long 0x00 04.--06.           "  MSTR1 ,Master 1 priority" "0(high),1,2,3,4,5,6,7(low)"
  bitfld.long 0x00 00.--02.           "  MSTR0 ,Master 0 priority" "0(high),1,2,3,4,5,6,7(low)"
TEXTLINE ""

group.long (0xfff04700+0x10)++0x03
  line.long 0x00 "SGPCR7,Slave General Purpose Control Register 7"
  bitfld.long 0x00 31.                  "RO    ,Read Only" "0,1"
  bitfld.long 0x00 30.                "  HLP   ,Halt Low Priority" "0,1"
TEXTLINE "                "
  bitfld.long 0x00 23.                "  HPE7  ,High Priority Enable" "0,1"
  bitfld.long 0x00 22.                "  HPE6  ,High Priority Enable" "0,1"
  bitfld.long 0x00 21.                "  HPE5  ,High Priority Enable" "0,1"
  bitfld.long 0x00 20.                "  HPE4  ,High Priority Enable" "0,1"
TEXTLINE "                "
  bitfld.long 0x00 19.                "  HPE3  ,High Priority Enable" "0,1"
  bitfld.long 0x00 18.                "  HPE2  ,High Priority Enable" "0,1"
  bitfld.long 0x00 17.                "  HPE1  ,High Priority Enable" "0,1"
  bitfld.long 0x00 16.                "  HPE0  ,High Priority Enable" "0,1"
TEXTLINE "                "
  bitfld.long 0x00 08.--09.           "  ARB   ,Arbitration mode" "Fixed (MPR),Round-robin,res,res"
  bitfld.long 0x00 04.--05.           "  PCTL  ,Parking control" "PARK ctrl field,Park on last,Low power park,res"
  bitfld.long 0x00 00.--02.           "  PARK  ,Park" "Master Port 0,Master Port 1,Master Port 2,Master Port 3,Master Port 4,Master Port 5,Master Port 6,Master Port 7"
TEXTLINE ""

group.long (0xfff04700+0x14)++0x03
  line.long 0x00 "ASGPCR7,Alternate Slave General Purpose Control Register 7"
  bitfld.long 0x00 30.                  "HLP   ,Halt Low Priority" "0,1"
TEXTLINE "                "
  bitfld.long 0x00 23.                "  HPE7  ,High Priority Enable" "0,1"
  bitfld.long 0x00 22.                "  HPE6  ,High Priority Enable" "0,1"
  bitfld.long 0x00 21.                "  HPE5  ,High Priority Enable" "0,1"
  bitfld.long 0x00 20.                "  HPE4  ,High Priority Enable" "0,1"
TEXTLINE "                "
  bitfld.long 0x00 19.                "  HPE3  ,High Priority Enable" "0,1"
  bitfld.long 0x00 18.                "  HPE2  ,High Priority Enable" "0,1"
  bitfld.long 0x00 17.                "  HPE1  ,High Priority Enable" "0,1"
  bitfld.long 0x00 16.                "  HPE0  ,High Priority Enable" "0,1"
TEXTLINE "                "
  bitfld.long 0x00 08.--09.           "  ARB   ,Arbitration mode" "Fixed (MPR),Round-robin,res,res"
  bitfld.long 0x00 04.--05.           "  PCTL  ,Parking control" "PARK ctrl field,Park on last,Low power park,res"
  bitfld.long 0x00 00.--02.           "  PARK  ,Park" "Master Port 0,Master Port 1,Master Port 2,Master Port 3,Master Port 4,Master Port 5,Master Port 6,Master Port 7"

tree.end
else
  sif CPUIS("MPC5674*")
tree "Peripheral Bridge A"

group.long 0xC3F00000++0x03
  line.long    0x00 "MPCR,Master Privilege Control Register"
  bitfld.long  0x00 (31.-0*4.)  "CPU:       MBW0 ,CPU:       buffer writes" "0,1"
  bitfld.long  0x00 (30.-0*4.)  "  MTR0 ,CPU:       trusted for reads" "0,1"
  bitfld.long  0x00 (29.-0*4.)  "  MTW0 ,CPU:       trusted for writes" "0,1"
  bitfld.long  0x00 (28.-0*4.)  "  MPL0 ,CPU:       privilege level" "0,1"
TEXTLINE "                  "

  bitfld.long  0x00 (31.-1*4.)  "NEXUS:     MBW1 ,NEXUS:     buffer writes" "0,1"
  bitfld.long  0x00 (30.-1*4.)  "  MTR1 ,NEXUS:     trusted for reads" "0,1"
  bitfld.long  0x00 (29.-1*4.)  "  MTW1 ,NEXUS:     trusted for writes" "0,1"
  bitfld.long  0x00 (28.-1*4.)  "  MPL1 ,NEXUS:     privilege level" "0,1"
TEXTLINE "                  "

  bitfld.long  0x00 (31.-4*4.)  "eDMA_A:    MBW4 ,eDMA_A:    buffer writes" "0,1"
  bitfld.long  0x00 (30.-4*4.)  "  MTR4 ,eDMA_A:    trusted for reads" "0,1"
  bitfld.long  0x00 (29.-4*4.)  "  MTW4 ,eDMA_A:    trusted for writes" "0,1"
  bitfld.long  0x00 (28.-4*4.)  "  MPL4 ,eDMA_A:    privilege level" "0,1"
TEXTLINE "                  "

  bitfld.long  0x00 (31.-5*4.)  "eDMA_B:    MBW5 ,eDMA_B:    buffer writes" "0,1"
  bitfld.long  0x00 (30.-5*4.)  "  MTR5 ,eDMA_B:    trusted for reads" "0,1"
  bitfld.long  0x00 (29.-5*4.)  "  MTW5 ,eDMA_B:    trusted for writes" "0,1"
  bitfld.long  0x00 (28.-5*4.)  "  MPL5 ,eDMA_B:    privilege level" "0,1"
TEXTLINE "                  "

  bitfld.long  0x00 (31.-6*4.)  "FlexRay:   MBW6 ,FlexRay:   buffer writes" "0,1"
  bitfld.long  0x00 (30.-6*4.)  "  MTR6 ,FlexRay:   trusted for reads" "0,1"
  bitfld.long  0x00 (29.-6*4.)  "  MTW6 ,FlexRay:   trusted for writes" "0,1"
  bitfld.long  0x00 (28.-6*4.)  "  MPL6 ,FlexRay:   privilege level" "0,1"
TEXTLINE "                  "

  bitfld.long  0x00 (31.-7*4.)  "EBI:       MBW7 ,EBI:       buffer writes" "0,1"
  bitfld.long  0x00 (30.-7*4.)  "  MTR7 ,EBI:       trusted for reads" "0,1"
  bitfld.long  0x00 (29.-7*4.)  "  MTW7 ,EBI:       trusted for writes" "0,1"
  bitfld.long  0x00 (28.-7*4.)  "  MPL7 ,EBI:       privilege level" "0,1"
TEXTLINE "                  "


group.long 0xC3F00020++0x03
  line.long    0x00 "PACR0,Peripheral Access Control Register 0"
  bitfld.long  0x00 (31.-0*4.) "PBRIDGE_A: BW0  ,PBRIDGE_A: buffer writes" "0,1"
  bitfld.long  0x00 (30.-0*4.) "  SP0  ,PBRIDGE_A: supervisor protect" "0,1"
  bitfld.long  0x00 (29.-0*4.) "  WP0  ,PBRIDGE_A: write protect" "0,1"
  bitfld.long  0x00 (28.-0*4.) "  TP0  ,PBRIDGE_A: trusted protect" "0,1"
TEXTLINE "                  "


group.long 0xC3F00040++0x03
  line.long    0x00 "OPACR0,Off-Platform Peripheral Access Control Register 0"
  bitfld.long  0x00 (31.-0*4.) "FMPLL:     BW0  ,FMPLL:     buffer writes" "0,1"
  bitfld.long  0x00 (30.-0*4.) "  SP0  ,FMPLL:     supervisor protect" "0,1"
  bitfld.long  0x00 (29.-0*4.) "  WP0  ,FMPLL:     write protect" "0,1"
  bitfld.long  0x00 (28.-0*4.) "  TP0  ,FMPLL:     trusted protect" "0,1"
TEXTLINE "                  "

  bitfld.long  0x00 (31.-1*4.) "EBI:       BW1  ,EBI:       buffer writes" "0,1"
  bitfld.long  0x00 (30.-1*4.) "  SP1  ,EBI:       supervisor protect" "0,1"
  bitfld.long  0x00 (29.-1*4.) "  WP1  ,EBI:       write protect" "0,1"
  bitfld.long  0x00 (28.-1*4.) "  TP1  ,EBI:       trusted protect" "0,1"
TEXTLINE "                  "

  bitfld.long  0x00 (31.-2*4.) "FLASH_A:   BW2  ,FLASH_A:   buffer writes" "0,1"
  bitfld.long  0x00 (30.-2*4.) "  SP2  ,FLASH_A:   supervisor protect" "0,1"
  bitfld.long  0x00 (29.-2*4.) "  WP2  ,FLASH_A:   write protect" "0,1"
  bitfld.long  0x00 (28.-2*4.) "  TP2  ,FLASH_A:   trusted protect" "0,1"
TEXTLINE "                  "

  bitfld.long  0x00 (31.-3*4.) "FLASH_B:   BW3  ,FLASH_B:   buffer writes" "0,1"
  bitfld.long  0x00 (30.-3*4.) "  SP3  ,FLASH_B:   supervisor protect" "0,1"
  bitfld.long  0x00 (29.-3*4.) "  WP3  ,FLASH_B:   write protect" "0,1"
  bitfld.long  0x00 (28.-3*4.) "  TP3  ,FLASH_B:   trusted protect" "0,1"
TEXTLINE "                  "

  bitfld.long  0x00 (31.-4*4.) "SIU:       BW4  ,SIU:       buffer writes" "0,1"
  bitfld.long  0x00 (30.-4*4.) "  SP4  ,SIU:       supervisor protect" "0,1"
  bitfld.long  0x00 (29.-4*4.) "  WP4  ,SIU:       write protect" "0,1"
  bitfld.long  0x00 (28.-4*4.) "  TP4  ,SIU:       trusted protect" "0,1"
TEXTLINE "                  "



group.long 0xC3F00044++0x03
  line.long    0x00 "OPACR1,Off-Platform Peripheral Access Control Register 1"
  bitfld.long  0x00 (31.-0*4.) "eMIOS:     BW0  ,eMIOS:     buffer writes" "0,1"
  bitfld.long  0x00 (30.-0*4.) "  SP0  ,eMIOS:     supervisor protect" "0,1"
  bitfld.long  0x00 (29.-0*4.) "  WP0  ,eMIOS:     write protect" "0,1"
  bitfld.long  0x00 (28.-0*4.) "  TP0  ,eMIOS:     trusted protect" "0,1"
TEXTLINE "                  "

  bitfld.long  0x00 (31.-7*4.) "PMC:       BW7  ,PMC:       buffer writes" "0,1"
  bitfld.long  0x00 (30.-7*4.) "  SP7  ,PMC:       supervisor protect" "0,1"
  bitfld.long  0x00 (29.-7*4.) "  WP7  ,PMC:       write protect" "0,1"
  bitfld.long  0x00 (28.-7*4.) "  TP7  ,PMC:       trusted protect" "0,1"
TEXTLINE "                  "


group.long 0xC3F00048++0x03
  line.long    0x00 "OPACR2,Off-Platform Peripheral Access Control Register 2"
  bitfld.long  0x00 (31.-0*4.) "eTPU:      BW0  ,eTPU:      buffer writes" "0,1"
  bitfld.long  0x00 (30.-0*4.) "  SP0  ,eTPU:      supervisor protect" "0,1"
  bitfld.long  0x00 (29.-0*4.) "  WP0  ,eTPU:      write protect" "0,1"
  bitfld.long  0x00 (28.-0*4.) "  TP0  ,eTPU:      trusted protect" "0,1"
TEXTLINE "                  "

  bitfld.long  0x00 (31.-2*4.) "eTPU-PRAM: BW2  ,eTPU-PRAM: buffer writes" "0,1"
  bitfld.long  0x00 (30.-2*4.) "  SP2  ,eTPU-PRAM: supervisor protect" "0,1"
  bitfld.long  0x00 (29.-2*4.) "  WP2  ,eTPU-PRAM: write protect" "0,1"
  bitfld.long  0x00 (28.-2*4.) "  TP2  ,eTPU-PRAM: trusted protect" "0,1"
TEXTLINE "                  "

  bitfld.long  0x00 (31.-3*4.) "eTPU-PRMI: BW3  ,eTPU-PRMI: buffer writes" "0,1"
  bitfld.long  0x00 (30.-3*4.) "  SP3  ,eTPU-PRMI: supervisor protect" "0,1"
  bitfld.long  0x00 (29.-3*4.) "  WP3  ,eTPU-PRMI: write protect" "0,1"
  bitfld.long  0x00 (28.-3*4.) "  TP3  ,eTPU-PRMI: trusted protect" "0,1"
TEXTLINE "                  "

  bitfld.long  0x00 (31.-4*4.) "eTPU-SCM:  BW4  ,eTPU-SCM:  buffer writes" "0,1"
  bitfld.long  0x00 (30.-4*4.) "  SP4  ,eTPU-SCM:  supervisor protect" "0,1"
  bitfld.long  0x00 (29.-4*4.) "  WP4  ,eTPU-SCM:  write protect" "0,1"
  bitfld.long  0x00 (28.-4*4.) "  TP4  ,eTPU-SCM:  trusted protect" "0,1"
TEXTLINE "                  "

  bitfld.long  0x00 (31.-5*4.) "eTPU-SCM:  BW5  ,eTPU-SCM:  buffer writes" "0,1"
  bitfld.long  0x00 (30.-5*4.) "  SP5  ,eTPU-SCM:  supervisor protect" "0,1"
  bitfld.long  0x00 (29.-5*4.) "  WP5  ,eTPU-SCM:  write protect" "0,1"
  bitfld.long  0x00 (28.-5*4.) "  TP5  ,eTPU-SCM:  trusted protect" "0,1"
TEXTLINE "                  "


group.long 0xC3F0004C++0x03
  line.long    0x00 "OPACR3,Off-Platform Peripheral Access Control Register 3"
  bitfld.long  0x00 (31.-4*4.) "PIT/RTI:   BW4  ,PIT/RTI:   buffer writes" "0,1"
  bitfld.long  0x00 (30.-4*4.) "  SP4  ,PIT/RTI:   supervisor protect" "0,1"
  bitfld.long  0x00 (29.-4*4.) "  WP4  ,PIT/RTI:   write protect" "0,1"
  bitfld.long  0x00 (28.-4*4.) "  TP4  ,PIT/RTI:   trusted protect" "0,1"
TEXTLINE "                  "


tree.end




tree "Peripheral Bridge B"

group.long 0xFFF00000++0x03
  line.long    0x00 "MPCR,Master Privilege Control Register"
  bitfld.long  0x00 (31.-0*4.)  "CPU:       MBW0 ,CPU:       buffer writes" "0,1"
  bitfld.long  0x00 (30.-0*4.)  "  MTR0 ,CPU:       trusted for reads" "0,1"
  bitfld.long  0x00 (29.-0*4.)  "  MTW0 ,CPU:       trusted for writes" "0,1"
  bitfld.long  0x00 (28.-0*4.)  "  MPL0 ,CPU:       privilege level" "0,1"
TEXTLINE "                  "

  bitfld.long  0x00 (31.-1*4.)  "NEXUS:     MBW1 ,NEXUS:     buffer writes" "0,1"
  bitfld.long  0x00 (30.-1*4.)  "  MTR1 ,NEXUS:     trusted for reads" "0,1"
  bitfld.long  0x00 (29.-1*4.)  "  MTW1 ,NEXUS:     trusted for writes" "0,1"
  bitfld.long  0x00 (28.-1*4.)  "  MPL1 ,NEXUS:     privilege level" "0,1"
TEXTLINE "                  "

  bitfld.long  0x00 (31.-4*4.)  "eDMA_A:    MBW4 ,eDMA_A:    buffer writes" "0,1"
  bitfld.long  0x00 (30.-4*4.)  "  MTR4 ,eDMA_A:    trusted for reads" "0,1"
  bitfld.long  0x00 (29.-4*4.)  "  MTW4 ,eDMA_A:    trusted for writes" "0,1"
  bitfld.long  0x00 (28.-4*4.)  "  MPL4 ,eDMA_A:    privilege level" "0,1"
TEXTLINE "                  "

  bitfld.long  0x00 (31.-5*4.)  "eDMA_B:    MBW5 ,eDMA_B:    buffer writes" "0,1"
  bitfld.long  0x00 (30.-5*4.)  "  MTR5 ,eDMA_B:    trusted for reads" "0,1"
  bitfld.long  0x00 (29.-5*4.)  "  MTW5 ,eDMA_B:    trusted for writes" "0,1"
  bitfld.long  0x00 (28.-5*4.)  "  MPL5 ,eDMA_B:    privilege level" "0,1"
TEXTLINE "                  "

  bitfld.long  0x00 (31.-6*4.)  "FlexRay:   MBW6 ,FlexRay:   buffer writes" "0,1"
  bitfld.long  0x00 (30.-6*4.)  "  MTR6 ,FlexRay:   trusted for reads" "0,1"
  bitfld.long  0x00 (29.-6*4.)  "  MTW6 ,FlexRay:   trusted for writes" "0,1"
  bitfld.long  0x00 (28.-6*4.)  "  MPL6 ,FlexRay:   privilege level" "0,1"
TEXTLINE "                  "

  bitfld.long  0x00 (31.-7*4.)  "EBI:       MBW7 ,EBI:       buffer writes" "0,1"
  bitfld.long  0x00 (30.-7*4.)  "  MTR7 ,EBI:       trusted for reads" "0,1"
  bitfld.long  0x00 (29.-7*4.)  "  MTW7 ,EBI:       trusted for writes" "0,1"
  bitfld.long  0x00 (28.-7*4.)  "  MPL7 ,EBI:       privilege level" "0,1"
TEXTLINE "                  "



group.long 0xFFF00020++0x03
  line.long    0x00 "PACR0,Peripheral Access Control Register 0"
  bitfld.long  0x00 (31.-0*4.) "PBRIDGE_B: BW0  ,PBRIDGE_B: buffer writes" "0,1"
  bitfld.long  0x00 (30.-0*4.) "  SP0  ,PBRIDGE_B: supervisor protect" "0,1"
  bitfld.long  0x00 (29.-0*4.) "  WP0  ,PBRIDGE_B: write protect" "0,1"
  bitfld.long  0x00 (28.-0*4.) "  TP0  ,PBRIDGE_B: trusted protect" "0,1"
TEXTLINE "                  "

  bitfld.long  0x00 (31.-1*4.) "XBAR:      BW1  ,XBAR:      buffer writes" "0,1"
  bitfld.long  0x00 (30.-1*4.) "  SP1  ,XBAR:      supervisor protect" "0,1"
  bitfld.long  0x00 (29.-1*4.) "  WP1  ,XBAR:      write protect" "0,1"
  bitfld.long  0x00 (28.-1*4.) "  TP1  ,XBAR:      trusted protect" "0,1"
TEXTLINE "                  "

  bitfld.long  0x00 (31.-4*4.) "MPU:       BW4  ,MPU:       buffer writes" "0,1"
  bitfld.long  0x00 (30.-4*4.) "  SP4  ,MPU:       supervisor protect" "0,1"
  bitfld.long  0x00 (29.-4*4.) "  WP4  ,MPU:       write protect" "0,1"
  bitfld.long  0x00 (28.-4*4.) "  TP4  ,MPU:       trusted protect" "0,1"
TEXTLINE "                  "


group.long 0xFFF00024++0x03
  line.long    0x00 "PACR1,Peripheral Access Control Register 1"
  bitfld.long  0x00 (31.-6*4.) "SWT:       BW6  ,SWT:       buffer writes" "0,1"
  bitfld.long  0x00 (30.-6*4.) "  SP6  ,SWT:       supervisor protect" "0,1"
  bitfld.long  0x00 (29.-6*4.) "  WP6  ,SWT:       write protect" "0,1"
  bitfld.long  0x00 (28.-6*4.) "  TP6  ,SWT:       trusted protect" "0,1"
TEXTLINE "                  "

  bitfld.long  0x00 (31.-7*4.) "STM:       BW7  ,STM:       buffer writes" "0,1"
  bitfld.long  0x00 (30.-7*4.) "  SP7  ,STM:       supervisor protect" "0,1"
  bitfld.long  0x00 (29.-7*4.) "  WP7  ,STM:       write protect" "0,1"
  bitfld.long  0x00 (28.-7*4.) "  TP7  ,STM:       trusted protect" "0,1"
TEXTLINE "                  "



group.long 0xFFF00028++0x03
  line.long    0x00 "PACR2,Peripheral Access Control Register 2"
  bitfld.long  0x00 (31.-0*4.) "ESCM:      BW0  ,ESCM:      buffer writes" "0,1"
  bitfld.long  0x00 (30.-0*4.) "  SP0  ,ESCM:      supervisor protect" "0,1"
  bitfld.long  0x00 (29.-0*4.) "  WP0  ,ESCM:      write protect" "0,1"
  bitfld.long  0x00 (28.-0*4.) "  TP0  ,ESCM:      trusted protect" "0,1"
TEXTLINE "                  "

  bitfld.long  0x00 (31.-1*4.) "eDMA_A:    BW1  ,eDMA_A:    buffer writes" "0,1"
  bitfld.long  0x00 (30.-1*4.) "  SP1  ,eDMA_A:    supervisor protect" "0,1"
  bitfld.long  0x00 (29.-1*4.) "  WP1  ,eDMA_A:    write protect" "0,1"
  bitfld.long  0x00 (28.-1*4.) "  TP1  ,eDMA_A:    trusted protect" "0,1"
TEXTLINE "                  "

  bitfld.long  0x00 (31.-2*4.) "INTC:      BW2  ,INTC:      buffer writes" "0,1"
  bitfld.long  0x00 (30.-2*4.) "  SP2  ,INTC:      supervisor protect" "0,1"
  bitfld.long  0x00 (29.-2*4.) "  WP2  ,INTC:      write protect" "0,1"
  bitfld.long  0x00 (28.-2*4.) "  TP2  ,INTC:      trusted protect" "0,1"
TEXTLINE "                  "

  bitfld.long  0x00 (31.-5*4.) "eDMA_B:    BW5  ,eDMA_B:    buffer writes" "0,1"
  bitfld.long  0x00 (30.-5*4.) "  SP5  ,eDMA_B:    supervisor protect" "0,1"
  bitfld.long  0x00 (29.-5*4.) "  WP5  ,eDMA_B:    write protect" "0,1"
  bitfld.long  0x00 (28.-5*4.) "  TP5  ,eDMA_B:    trusted protect" "0,1"
TEXTLINE "                  "



group.long 0xFFF00040++0x03
  line.long    0x00 "OPACR0,Off-Platform Peripheral Access Control Register 0"
  bitfld.long  0x00 (31.-0*4.) "eQADC_A:   BW0  ,eQADC_A:   buffer writes" "0,1"
  bitfld.long  0x00 (30.-0*4.) "  SP0  ,eQADC_A:   supervisor protect" "0,1"
  bitfld.long  0x00 (29.-0*4.) "  WP0  ,eQADC_A:   write protect" "0,1"
  bitfld.long  0x00 (28.-0*4.) "  TP0  ,eQADC_A:   trusted protect" "0,1"
TEXTLINE "                  "

  bitfld.long  0x00 (31.-1*4.) "eQADC_B:   BW1  ,eQADC_B:   buffer writes" "0,1"
  bitfld.long  0x00 (30.-1*4.) "  SP1  ,eQADC_B:   supervisor protect" "0,1"
  bitfld.long  0x00 (29.-1*4.) "  WP1  ,eQADC_B:   write protect" "0,1"
  bitfld.long  0x00 (28.-1*4.) "  TP1  ,eQADC_B:   trusted protect" "0,1"
TEXTLINE "                  "

  bitfld.long  0x00 (31.-2*4.) "DF_ABCD:   BW2  ,DF_ABCD:   buffer writes" "0,1"
  bitfld.long  0x00 (30.-2*4.) "  SP2  ,DF_ABCD:   supervisor protect" "0,1"
  bitfld.long  0x00 (29.-2*4.) "  WP2  ,DF_ABCD:   write protect" "0,1"
  bitfld.long  0x00 (28.-2*4.) "  TP2  ,DF_ABCD:   trusted protect" "0,1"
TEXTLINE "                  "

  bitfld.long  0x00 (31.-4*4.) "DSPI_A:    BW4  ,DSPI_A:    buffer writes" "0,1"
  bitfld.long  0x00 (30.-4*4.) "  SP4  ,DSPI_A:    supervisor protect" "0,1"
  bitfld.long  0x00 (29.-4*4.) "  WP4  ,DSPI_A:    write protect" "0,1"
  bitfld.long  0x00 (28.-4*4.) "  TP4  ,DSPI_A:    trusted protect" "0,1"
TEXTLINE "                  "

  bitfld.long  0x00 (31.-5*4.) "DSPI_B:    BW5  ,DSPI_B:    buffer writes" "0,1"
  bitfld.long  0x00 (30.-5*4.) "  SP5  ,DSPI_B:    supervisor protect" "0,1"
  bitfld.long  0x00 (29.-5*4.) "  WP5  ,DSPI_B:    write protect" "0,1"
  bitfld.long  0x00 (28.-5*4.) "  TP5  ,DSPI_B:    trusted protect" "0,1"
TEXTLINE "                  "

  bitfld.long  0x00 (31.-6*4.) "DSPI_C:    BW6  ,DSPI_C:    buffer writes" "0,1"
  bitfld.long  0x00 (30.-6*4.) "  SP6  ,DSPI_C:    supervisor protect" "0,1"
  bitfld.long  0x00 (29.-6*4.) "  WP6  ,DSPI_C:    write protect" "0,1"
  bitfld.long  0x00 (28.-6*4.) "  TP6  ,DSPI_C:    trusted protect" "0,1"
TEXTLINE "                  "

  bitfld.long  0x00 (31.-7*4.) "DSPI_D:    BW7  ,DSPI_D:    buffer writes" "0,1"
  bitfld.long  0x00 (30.-7*4.) "  SP7  ,DSPI_D:    supervisor protect" "0,1"
  bitfld.long  0x00 (29.-7*4.) "  WP7  ,DSPI_D:    write protect" "0,1"
  bitfld.long  0x00 (28.-7*4.) "  TP7  ,DSPI_D:    trusted protect" "0,1"
TEXTLINE "                  "



group.long 0xFFF00044++0x03
  line.long    0x00 "OPACR1,Off-Platform Peripheral Access Control Register 1"
  bitfld.long  0x00 (31.-4*4.) "eSCI_A:    BW4  ,eSCI_A:    buffer writes" "0,1"
  bitfld.long  0x00 (30.-4*4.) "  SP4  ,eSCI_A:    supervisor protect" "0,1"
  bitfld.long  0x00 (29.-4*4.) "  WP4  ,eSCI_A:    write protect" "0,1"
  bitfld.long  0x00 (28.-4*4.) "  TP4  ,eSCI_A:    trusted protect" "0,1"
TEXTLINE "                  "

  bitfld.long  0x00 (31.-5*4.) "eSCI_B:    BW5  ,eSCI_B:    buffer writes" "0,1"
  bitfld.long  0x00 (30.-5*4.) "  SP5  ,eSCI_B:    supervisor protect" "0,1"
  bitfld.long  0x00 (29.-5*4.) "  WP5  ,eSCI_B:    write protect" "0,1"
  bitfld.long  0x00 (28.-5*4.) "  TP5  ,eSCI_B:    trusted protect" "0,1"
TEXTLINE "                  "

  bitfld.long  0x00 (31.-6*4.) "eSCI_C:    BW6  ,eSCI_C:    buffer writes" "0,1"
  bitfld.long  0x00 (30.-6*4.) "  SP6  ,eSCI_C:    supervisor protect" "0,1"
  bitfld.long  0x00 (29.-6*4.) "  WP6  ,eSCI_C:    write protect" "0,1"
  bitfld.long  0x00 (28.-6*4.) "  TP6  ,eSCI_C:    trusted protect" "0,1"
TEXTLINE "                  "


group.long 0xFFF00048++0x03
  line.long    0x00 "OPACR2,Off-Platform Peripheral Access Control Register 2"
  bitfld.long  0x00 (31.-0*4.) "FlexCAN_A: BW0  ,FlexCAN_A: buffer writes" "0,1"
  bitfld.long  0x00 (30.-0*4.) "  SP0  ,FlexCAN_A: supervisor protect" "0,1"
  bitfld.long  0x00 (29.-0*4.) "  WP0  ,FlexCAN_A: write protect" "0,1"
  bitfld.long  0x00 (28.-0*4.) "  TP0  ,FlexCAN_A: trusted protect" "0,1"
TEXTLINE "                  "

  bitfld.long  0x00 (31.-1*4.) "FlexCAN_B: BW1  ,FlexCAN_B: buffer writes" "0,1"
  bitfld.long  0x00 (30.-1*4.) "  SP1  ,FlexCAN_B: supervisor protect" "0,1"
  bitfld.long  0x00 (29.-1*4.) "  WP1  ,FlexCAN_B: write protect" "0,1"
  bitfld.long  0x00 (28.-1*4.) "  TP1  ,FlexCAN_B: trusted protect" "0,1"
TEXTLINE "                  "

  bitfld.long  0x00 (31.-2*4.) "FlexCAN_C: BW2  ,FlexCAN_C: buffer writes" "0,1"
  bitfld.long  0x00 (30.-2*4.) "  SP2  ,FlexCAN_C: supervisor protect" "0,1"
  bitfld.long  0x00 (29.-2*4.) "  WP2  ,FlexCAN_C: write protect" "0,1"
  bitfld.long  0x00 (28.-2*4.) "  TP2  ,FlexCAN_C: trusted protect" "0,1"
TEXTLINE "                  "

  bitfld.long  0x00 (31.-3*4.) "FlexCAN_D: BW3  ,FlexCAN_D: buffer writes" "0,1"
  bitfld.long  0x00 (30.-3*4.) "  SP3  ,FlexCAN_D: supervisor protect" "0,1"
  bitfld.long  0x00 (29.-3*4.) "  WP3  ,FlexCAN_D: write protect" "0,1"
  bitfld.long  0x00 (28.-3*4.) "  TP3  ,FlexCAN_D: trusted protect" "0,1"
TEXTLINE "                  "


group.long 0xFFF0004C++0x03
  line.long    0x00 "OPACR3,Off-Platform Peripheral Access Control Register 3"
  bitfld.long  0x00 (31.-0*4.) "FlexRay:   BW0  ,FlexRay:   buffer writes" "0,1"
  bitfld.long  0x00 (30.-0*4.) "  SP0  ,FlexRay:   supervisor protect" "0,1"
  bitfld.long  0x00 (29.-0*4.) "  WP0  ,FlexRay:   write protect" "0,1"
  bitfld.long  0x00 (28.-0*4.) "  TP0  ,FlexRay:   trusted protect" "0,1"
TEXTLINE "                  "

  bitfld.long  0x00 (31.-3*4.) "TempSens:  BW3  ,TempSens:  buffer writes" "0,1"
  bitfld.long  0x00 (30.-3*4.) "  SP3  ,TempSens:  supervisor protect" "0,1"
  bitfld.long  0x00 (29.-3*4.) "  WP3  ,TempSens:  write protect" "0,1"
  bitfld.long  0x00 (28.-3*4.) "  TP3  ,TempSens:  trusted protect" "0,1"
TEXTLINE "                  "

  bitfld.long  0x00 (31.-7*4.) "BAM:       BW7  ,BAM:       buffer writes" "0,1"
  bitfld.long  0x00 (30.-7*4.) "  SP7  ,BAM:       supervisor protect" "0,1"
  bitfld.long  0x00 (29.-7*4.) "  WP7  ,BAM:       write protect" "0,1"
  bitfld.long  0x00 (28.-7*4.) "  TP7  ,BAM:       trusted protect" "0,1"
TEXTLINE "                  "


tree.end
  else  
tree "Peripheral Bridge A"

group.long 0xC3F00000++0x03
  line.long    0x00 "MPCR,Master Privilege Control Register"
  bitfld.long  0x00 (31.-0*4.)  "CPU:       MBW0 ,CPU:       buffer writes" "0,1"
  bitfld.long  0x00 (30.-0*4.)  "  MTR0 ,CPU:       trusted for reads" "0,1"
  bitfld.long  0x00 (29.-0*4.)  "  MTW0 ,CPU:       trusted for writes" "0,1"
  bitfld.long  0x00 (28.-0*4.)  "  MPL0 ,CPU:       privilege level" "0,1"
TEXTLINE "                  "

  bitfld.long  0x00 (31.-1*4.)  "NEXUS:     MBW1 ,NEXUS:     buffer writes" "0,1"
  bitfld.long  0x00 (30.-1*4.)  "  MTR1 ,NEXUS:     trusted for reads" "0,1"
  bitfld.long  0x00 (29.-1*4.)  "  MTW1 ,NEXUS:     trusted for writes" "0,1"
  bitfld.long  0x00 (28.-1*4.)  "  MPL1 ,NEXUS:     privilege level" "0,1"
TEXTLINE "                  "

  bitfld.long  0x00 (31.-2*4.)  "eDMA:      MBW2 ,eDMA:      buffer writes" "0,1"
  bitfld.long  0x00 (30.-2*4.)  "  MTR2 ,eDMA:      trusted for reads" "0,1"
  bitfld.long  0x00 (29.-2*4.)  "  MTW2 ,eDMA:      trusted for writes" "0,1"
  bitfld.long  0x00 (28.-2*4.)  "  MPL2 ,eDMA:      privilege level" "0,1"
TEXTLINE "                  "

  bitfld.long  0x00 (31.-3*4.)  "EBI:       MBW3 ,EBI:       buffer writes" "0,1"
  bitfld.long  0x00 (30.-3*4.)  "  MTR3 ,EBI:       trusted for reads" "0,1"
  bitfld.long  0x00 (29.-3*4.)  "  MTW3 ,EBI:       trusted for writes" "0,1"
  bitfld.long  0x00 (28.-3*4.)  "  MPL3 ,EBI:       privilege level" "0,1"
TEXTLINE "                  "

sif (CPU()=="MPC5553")||(CPU()=="MPC5566")||(CPU()=="MPC5567")
  bitfld.long  0x00 (31.-4*4.)  "FEC:       MBW4 ,FEC:       buffer writes" "0,1"
  bitfld.long  0x00 (30.-4*4.)  "  MTR4 ,FEC:       trusted for reads" "0,1"
  bitfld.long  0x00 (29.-4*4.)  "  MTW4 ,FEC:       trusted for writes" "0,1"
  bitfld.long  0x00 (28.-4*4.)  "  MPL4 ,FEC:       privilege level" "0,1"
TEXTLINE "                  "

endif
sif (CPU()=="MPC5561")||(CPU()=="MPC5567")
  bitfld.long  0x00 (31.-6*4.)  "FlexRay:   MBW6 ,FlexRay:   buffer writes" "0,1"
  bitfld.long  0x00 (30.-6*4.)  "  MTR6 ,FlexRay:   trusted for reads" "0,1"
  bitfld.long  0x00 (29.-6*4.)  "  MTW6 ,FlexRay:   trusted for writes" "0,1"
  bitfld.long  0x00 (28.-6*4.)  "  MPL6 ,FlexRay:   privilege level" "0,1"
TEXTLINE "                  "

endif

sif (CPU()=="MPC5553")||(CPU()=="MPC5554")||(CPU()=="MPC5561")||(CPU()=="MPC5565")||(CPU()=="MPC5566")||(CPU()=="MPC5567")||(CPUIS("MPC5674*"))

group.long 0xC3F00020++0x03
  line.long    0x00 "PACR0,Peripheral Access Control Register 0"
  bitfld.long  0x00 (31.-0*4.) "PBRIDGE_A: BW0  ,PBRIDGE_A: buffer writes" "0,1"
  bitfld.long  0x00 (30.-0*4.) "  SP0  ,PBRIDGE_A: supervisor protect" "0,1"
  bitfld.long  0x00 (29.-0*4.) "  WP0  ,PBRIDGE_A: write protect" "0,1"
  bitfld.long  0x00 (28.-0*4.) "  TP0  ,PBRIDGE_A: trusted protect" "0,1"
TEXTLINE "                  "


group.long 0xC3F00040++0x03
  line.long    0x00 "OPACR0,Off-Platform Peripheral Access Control Register 0"
  bitfld.long  0x00 (31.-0*4.) "FMPLL:     BW0  ,FMPLL:     buffer writes" "0,1"
  bitfld.long  0x00 (30.-0*4.) "  SP0  ,FMPLL:     supervisor protect" "0,1"
  bitfld.long  0x00 (29.-0*4.) "  WP0  ,FMPLL:     write protect" "0,1"
  bitfld.long  0x00 (28.-0*4.) "  TP0  ,FMPLL:     trusted protect" "0,1"
TEXTLINE "                  "

  bitfld.long  0x00 (31.-1*4.) "EBI:       BW1  ,EBI:       buffer writes" "0,1"
  bitfld.long  0x00 (30.-1*4.) "  SP1  ,EBI:       supervisor protect" "0,1"
  bitfld.long  0x00 (29.-1*4.) "  WP1  ,EBI:       write protect" "0,1"
  bitfld.long  0x00 (28.-1*4.) "  TP1  ,EBI:       trusted protect" "0,1"
TEXTLINE "                  "

  bitfld.long  0x00 (31.-2*4.) "FLASH:     BW2  ,FLASH:     buffer writes" "0,1"
  bitfld.long  0x00 (30.-2*4.) "  SP2  ,FLASH:     supervisor protect" "0,1"
  bitfld.long  0x00 (29.-2*4.) "  WP2  ,FLASH:     write protect" "0,1"
  bitfld.long  0x00 (28.-2*4.) "  TP2  ,FLASH:     trusted protect" "0,1"
TEXTLINE "                  "

  bitfld.long  0x00 (31.-4*4.) "SIU:       BW4  ,SIU:       buffer writes" "0,1"
  bitfld.long  0x00 (30.-4*4.) "  SP4  ,SIU:       supervisor protect" "0,1"
  bitfld.long  0x00 (29.-4*4.) "  WP4  ,SIU:       write protect" "0,1"
  bitfld.long  0x00 (28.-4*4.) "  TP4  ,SIU:       trusted protect" "0,1"
TEXTLINE "                  "



group.long 0xC3F00044++0x03
  line.long    0x00 "OPACR1,Off-Platform Peripheral Access Control Register 1"
  bitfld.long  0x00 (31.-0*4.) "eMIOS:     BW0  ,eMIOS:     buffer writes" "0,1"
  bitfld.long  0x00 (30.-0*4.) "  SP0  ,eMIOS:     supervisor protect" "0,1"
  bitfld.long  0x00 (29.-0*4.) "  WP0  ,eMIOS:     write protect" "0,1"
  bitfld.long  0x00 (28.-0*4.) "  TP0  ,eMIOS:     trusted protect" "0,1"
TEXTLINE "                  "


sif (CPU()=="MPC5553")||(CPU()=="MPC5554")||(CPU()=="MPC5565")||(CPU()=="MPC5566")||(CPU()=="MPC5567")
group.long 0xC3F00048++0x03
  line.long    0x00 "OPACR2,Off-Platform Peripheral Access Control Register 2"
  bitfld.long  0x00 (31.-0*4.) "eTPU:      BW0  ,eTPU:      buffer writes" "0,1"
  bitfld.long  0x00 (30.-0*4.) "  SP0  ,eTPU:      supervisor protect" "0,1"
  bitfld.long  0x00 (29.-0*4.) "  WP0  ,eTPU:      write protect" "0,1"
  bitfld.long  0x00 (28.-0*4.) "  TP0  ,eTPU:      trusted protect" "0,1"
TEXTLINE "                  "

  bitfld.long  0x00 (31.-2*4.) "eTPU-PRAM: BW2  ,eTPU-PRAM: buffer writes" "0,1"
  bitfld.long  0x00 (30.-2*4.) "  SP2  ,eTPU-PRAM: supervisor protect" "0,1"
  bitfld.long  0x00 (29.-2*4.) "  WP2  ,eTPU-PRAM: write protect" "0,1"
  bitfld.long  0x00 (28.-2*4.) "  TP2  ,eTPU-PRAM: trusted protect" "0,1"
TEXTLINE "                  "

  bitfld.long  0x00 (31.-3*4.) "eTPU-PRMI: BW3  ,eTPU-PRMI: buffer writes" "0,1"
  bitfld.long  0x00 (30.-3*4.) "  SP3  ,eTPU-PRMI: supervisor protect" "0,1"
  bitfld.long  0x00 (29.-3*4.) "  WP3  ,eTPU-PRMI: write protect" "0,1"
  bitfld.long  0x00 (28.-3*4.) "  TP3  ,eTPU-PRMI: trusted protect" "0,1"
TEXTLINE "                  "

  bitfld.long  0x00 (31.-4*4.) "eTPU-SCM:  BW4  ,eTPU-SCM:  buffer writes" "0,1"
  bitfld.long  0x00 (30.-4*4.) "  SP4  ,eTPU-SCM:  supervisor protect" "0,1"
  bitfld.long  0x00 (29.-4*4.) "  WP4  ,eTPU-SCM:  write protect" "0,1"
  bitfld.long  0x00 (28.-4*4.) "  TP4  ,eTPU-SCM:  trusted protect" "0,1"
TEXTLINE "                  "

endif

endif
tree.end




tree "Peripheral Bridge B"

group.long 0xFFF00000++0x03
  line.long    0x00 "MPCR,Master Privilege Control Register"
  bitfld.long  0x00 (31.-0*4.)  "CPU:       MBW0 ,CPU:       buffer writes" "0,1"
  bitfld.long  0x00 (30.-0*4.)  "  MTR0 ,CPU:       trusted for reads" "0,1"
  bitfld.long  0x00 (29.-0*4.)  "  MTW0 ,CPU:       trusted for writes" "0,1"
  bitfld.long  0x00 (28.-0*4.)  "  MPL0 ,CPU:       privilege level" "0,1"
TEXTLINE "                  "

  bitfld.long  0x00 (31.-1*4.)  "NEXUS:     MBW1 ,NEXUS:     buffer writes" "0,1"
  bitfld.long  0x00 (30.-1*4.)  "  MTR1 ,NEXUS:     trusted for reads" "0,1"
  bitfld.long  0x00 (29.-1*4.)  "  MTW1 ,NEXUS:     trusted for writes" "0,1"
  bitfld.long  0x00 (28.-1*4.)  "  MPL1 ,NEXUS:     privilege level" "0,1"
TEXTLINE "                  "

  bitfld.long  0x00 (31.-2*4.)  "eDMA:      MBW2 ,eDMA:      buffer writes" "0,1"
  bitfld.long  0x00 (30.-2*4.)  "  MTR2 ,eDMA:      trusted for reads" "0,1"
  bitfld.long  0x00 (29.-2*4.)  "  MTW2 ,eDMA:      trusted for writes" "0,1"
  bitfld.long  0x00 (28.-2*4.)  "  MPL2 ,eDMA:      privilege level" "0,1"
TEXTLINE "                  "

  bitfld.long  0x00 (31.-3*4.)  "EBI:       MBW3 ,EBI:       buffer writes" "0,1"
  bitfld.long  0x00 (30.-3*4.)  "  MTR3 ,EBI:       trusted for reads" "0,1"
  bitfld.long  0x00 (29.-3*4.)  "  MTW3 ,EBI:       trusted for writes" "0,1"
  bitfld.long  0x00 (28.-3*4.)  "  MPL3 ,EBI:       privilege level" "0,1"
TEXTLINE "                  "

sif (CPU()=="MPC5553")||(CPU()=="MPC5566")||(CPU()=="MPC5567")
  bitfld.long  0x00 (31.-4*4.)  "FEC:       MBW4 ,FEC:       buffer writes" "0,1"
  bitfld.long  0x00 (30.-4*4.)  "  MTR4 ,FEC:       trusted for reads" "0,1"
  bitfld.long  0x00 (29.-4*4.)  "  MTW4 ,FEC:       trusted for writes" "0,1"
  bitfld.long  0x00 (28.-4*4.)  "  MPL4 ,FEC:       privilege level" "0,1"
TEXTLINE "                  "

endif
sif (CPU()=="MPC5561")||(CPU()=="MPC5567")
  bitfld.long  0x00 (31.-6*4.)  "FlexRay:   MBW6 ,FlexRay:   buffer writes" "0,1"
  bitfld.long  0x00 (30.-6*4.)  "  MTR6 ,FlexRay:   trusted for reads" "0,1"
  bitfld.long  0x00 (29.-6*4.)  "  MTW6 ,FlexRay:   trusted for writes" "0,1"
  bitfld.long  0x00 (28.-6*4.)  "  MPL6 ,FlexRay:   privilege level" "0,1"
TEXTLINE "                  "

endif

sif (CPU()=="MPC5553")||(CPU()=="MPC5554")||(CPU()=="MPC5561")||(CPU()=="MPC5565")||(CPU()=="MPC5566")||(CPU()=="MPC5567")||(CPUIS("MPC5674*"))

group.long 0xFFF00020++0x03
  line.long    0x00 "PACR0,Peripheral Access Control Register 0"
  bitfld.long  0x00 (31.-0*4.) "PBRIDGE_B: BW0  ,PBRIDGE_B: buffer writes" "0,1"
  bitfld.long  0x00 (30.-0*4.) "  SP0  ,PBRIDGE_B: supervisor protect" "0,1"
  bitfld.long  0x00 (29.-0*4.) "  WP0  ,PBRIDGE_B: write protect" "0,1"
  bitfld.long  0x00 (28.-0*4.) "  TP0  ,PBRIDGE_B: trusted protect" "0,1"
TEXTLINE "                  "

  bitfld.long  0x00 (31.-1*4.) "XBAR:      BW1  ,XBAR:      buffer writes" "0,1"
  bitfld.long  0x00 (30.-1*4.) "  SP1  ,XBAR:      supervisor protect" "0,1"
  bitfld.long  0x00 (29.-1*4.) "  WP1  ,XBAR:      write protect" "0,1"
  bitfld.long  0x00 (28.-1*4.) "  TP1  ,XBAR:      trusted protect" "0,1"
TEXTLINE "                  "



group.long 0xFFF00028++0x03
  line.long    0x00 "PACR2,Peripheral Access Control Register 2"
  bitfld.long  0x00 (31.-0*4.) "ESCM:      BW0  ,ESCM:      buffer writes" "0,1"
  bitfld.long  0x00 (30.-0*4.) "  SP0  ,ESCM:      supervisor protect" "0,1"
  bitfld.long  0x00 (29.-0*4.) "  WP0  ,ESCM:      write protect" "0,1"
  bitfld.long  0x00 (28.-0*4.) "  TP0  ,ESCM:      trusted protect" "0,1"
TEXTLINE "                  "

  bitfld.long  0x00 (31.-1*4.) "eDMA:      BW1  ,eDMA:      buffer writes" "0,1"
  bitfld.long  0x00 (30.-1*4.) "  SP1  ,eDMA:      supervisor protect" "0,1"
  bitfld.long  0x00 (29.-1*4.) "  WP1  ,eDMA:      write protect" "0,1"
  bitfld.long  0x00 (28.-1*4.) "  TP1  ,eDMA:      trusted protect" "0,1"
TEXTLINE "                  "

  bitfld.long  0x00 (31.-2*4.) "INTC:      BW2  ,INTC:      buffer writes" "0,1"
  bitfld.long  0x00 (30.-2*4.) "  SP2  ,INTC:      supervisor protect" "0,1"
  bitfld.long  0x00 (29.-2*4.) "  WP2  ,INTC:      write protect" "0,1"
  bitfld.long  0x00 (28.-2*4.) "  TP2  ,INTC:      trusted protect" "0,1"
TEXTLINE "                  "

sif (CPU()=="MPC5553")||(CPU()=="MPC5566")||(CPU()=="MPC5567")
  bitfld.long  0x00 (31.-3*4.) "FEC:       BW3  ,FEC:       buffer writes" "0,1"
  bitfld.long  0x00 (30.-3*4.) "  SP3  ,FEC:       supervisor protect" "0,1"
  bitfld.long  0x00 (29.-3*4.) "  WP3  ,FEC:       write protect" "0,1"
  bitfld.long  0x00 (28.-3*4.) "  TP3  ,FEC:       trusted protect" "0,1"
TEXTLINE "                  "

endif


group.long 0xFFF00040++0x03
  line.long    0x00 "OPACR0,Off-Platform Peripheral Access Control Register 0"
  bitfld.long  0x00 (31.-0*4.) "eQADC:     BW0  ,eQADC:     buffer writes" "0,1"
  bitfld.long  0x00 (30.-0*4.) "  SP0  ,eQADC:     supervisor protect" "0,1"
  bitfld.long  0x00 (29.-0*4.) "  WP0  ,eQADC:     write protect" "0,1"
  bitfld.long  0x00 (28.-0*4.) "  TP0  ,eQADC:     trusted protect" "0,1"
TEXTLINE "                  "

sif (CPU()=="MPC5554")||(CPU()=="MPC5566")
  bitfld.long  0x00 (31.-4*4.) "DSPI_A:    BW4  ,DSPI_A:    buffer writes" "0,1"
  bitfld.long  0x00 (30.-4*4.) "  SP4  ,DSPI_A:    supervisor protect" "0,1"
  bitfld.long  0x00 (29.-4*4.) "  WP4  ,DSPI_A:    write protect" "0,1"
  bitfld.long  0x00 (28.-4*4.) "  TP4  ,DSPI_A:    trusted protect" "0,1"
TEXTLINE "                  "

endif
  bitfld.long  0x00 (31.-5*4.) "DSPI_B:    BW5  ,DSPI_B:    buffer writes" "0,1"
  bitfld.long  0x00 (30.-5*4.) "  SP5  ,DSPI_B:    supervisor protect" "0,1"
  bitfld.long  0x00 (29.-5*4.) "  WP5  ,DSPI_B:    write protect" "0,1"
  bitfld.long  0x00 (28.-5*4.) "  TP5  ,DSPI_B:    trusted protect" "0,1"
TEXTLINE "                  "

  bitfld.long  0x00 (31.-6*4.) "DSPI_C:    BW6  ,DSPI_C:    buffer writes" "0,1"
  bitfld.long  0x00 (30.-6*4.) "  SP6  ,DSPI_C:    supervisor protect" "0,1"
  bitfld.long  0x00 (29.-6*4.) "  WP6  ,DSPI_C:    write protect" "0,1"
  bitfld.long  0x00 (28.-6*4.) "  TP6  ,DSPI_C:    trusted protect" "0,1"
TEXTLINE "                  "

sif (CPU()=="MPC5554")||(CPU()=="MPC5565")||(CPU()=="MPC5566")||(CPU()=="MPC5567")
  bitfld.long  0x00 (31.-7*4.) "DSPI_D:    BW7  ,DSPI_D:    buffer writes" "0,1"
  bitfld.long  0x00 (30.-7*4.) "  SP7  ,DSPI_D:    supervisor protect" "0,1"
  bitfld.long  0x00 (29.-7*4.) "  WP7  ,DSPI_D:    write protect" "0,1"
  bitfld.long  0x00 (28.-7*4.) "  TP7  ,DSPI_D:    trusted protect" "0,1"
TEXTLINE "                  "

endif


group.long 0xFFF00044++0x03
  line.long    0x00 "OPACR1,Off-Platform Peripheral Access Control Register 1"
  bitfld.long  0x00 (31.-4*4.) "eSCI_A:    BW4  ,eSCI_A:    buffer writes" "0,1"
  bitfld.long  0x00 (30.-4*4.) "  SP4  ,eSCI_A:    supervisor protect" "0,1"
  bitfld.long  0x00 (29.-4*4.) "  WP4  ,eSCI_A:    write protect" "0,1"
  bitfld.long  0x00 (28.-4*4.) "  TP4  ,eSCI_A:    trusted protect" "0,1"
TEXTLINE "                  "

  bitfld.long  0x00 (31.-5*4.) "eSCI_B:    BW5  ,eSCI_B:    buffer writes" "0,1"
  bitfld.long  0x00 (30.-5*4.) "  SP5  ,eSCI_B:    supervisor protect" "0,1"
  bitfld.long  0x00 (29.-5*4.) "  WP5  ,eSCI_B:    write protect" "0,1"
  bitfld.long  0x00 (28.-5*4.) "  TP5  ,eSCI_B:    trusted protect" "0,1"
TEXTLINE "                  "

sif (CPU()=="MPC5561")
  bitfld.long  0x00 (31.-6*4.) "eSCI_C:    BW6  ,eSCI_C:    buffer writes" "0,1"
  bitfld.long  0x00 (30.-6*4.) "  SP6  ,eSCI_C:    supervisor protect" "0,1"
  bitfld.long  0x00 (29.-6*4.) "  WP6  ,eSCI_C:    write protect" "0,1"
  bitfld.long  0x00 (28.-6*4.) "  TP6  ,eSCI_C:    trusted protect" "0,1"
TEXTLINE "                  "

  bitfld.long  0x00 (31.-7*4.) "eSCI_D:    BW7  ,eSCI_D:    buffer writes" "0,1"
  bitfld.long  0x00 (30.-7*4.) "  SP7  ,eSCI_D:    supervisor protect" "0,1"
  bitfld.long  0x00 (29.-7*4.) "  WP7  ,eSCI_D:    write protect" "0,1"
  bitfld.long  0x00 (28.-7*4.) "  TP7  ,eSCI_D:    trusted protect" "0,1"
TEXTLINE "                  "

endif

group.long 0xFFF00048++0x03
  line.long    0x00 "OPACR2,Off-Platform Peripheral Access Control Register 2"
  bitfld.long  0x00 (31.-0*4.) "FlexCAN_A: BW0  ,FlexCAN_A: buffer writes" "0,1"
  bitfld.long  0x00 (30.-0*4.) "  SP0  ,FlexCAN_A: supervisor protect" "0,1"
  bitfld.long  0x00 (29.-0*4.) "  WP0  ,FlexCAN_A: write protect" "0,1"
  bitfld.long  0x00 (28.-0*4.) "  TP0  ,FlexCAN_A: trusted protect" "0,1"
TEXTLINE "                  "

sif (CPU()=="MPC5554")||(CPU()=="MPC5565")||(CPU()=="MPC5566")||(CPU()=="MPC5567")
  bitfld.long  0x00 (31.-1*4.) "FlexCAN_B: BW1  ,FlexCAN_B: buffer writes" "0,1"
  bitfld.long  0x00 (30.-1*4.) "  SP1  ,FlexCAN_B: supervisor protect" "0,1"
  bitfld.long  0x00 (29.-1*4.) "  WP1  ,FlexCAN_B: write protect" "0,1"
  bitfld.long  0x00 (28.-1*4.) "  TP1  ,FlexCAN_B: trusted protect" "0,1"
TEXTLINE "                  "

endif
  bitfld.long  0x00 (31.-2*4.) "FlexCAN_C: BW2  ,FlexCAN_C: buffer writes" "0,1"
  bitfld.long  0x00 (30.-2*4.) "  SP2  ,FlexCAN_C: supervisor protect" "0,1"
  bitfld.long  0x00 (29.-2*4.) "  WP2  ,FlexCAN_C: write protect" "0,1"
  bitfld.long  0x00 (28.-2*4.) "  TP2  ,FlexCAN_C: trusted protect" "0,1"
TEXTLINE "                  "

sif (CPU()=="MPC5566")
  bitfld.long  0x00 (31.-3*4.) "FlexCAN_D: BW3  ,FlexCAN_D: buffer writes" "0,1"
  bitfld.long  0x00 (30.-3*4.) "  SP3  ,FlexCAN_D: supervisor protect" "0,1"
  bitfld.long  0x00 (29.-3*4.) "  WP3  ,FlexCAN_D: write protect" "0,1"
  bitfld.long  0x00 (28.-3*4.) "  TP3  ,FlexCAN_D: trusted protect" "0,1"
TEXTLINE "                  "

endif
sif (CPU()=="MPC5567")
  bitfld.long  0x00 (31.-4*4.) "FlexCAN_E: BW4  ,FlexCAN_E: buffer writes" "0,1"
  bitfld.long  0x00 (30.-4*4.) "  SP4  ,FlexCAN_E: supervisor protect" "0,1"
  bitfld.long  0x00 (29.-4*4.) "  WP4  ,FlexCAN_E: write protect" "0,1"
  bitfld.long  0x00 (28.-4*4.) "  TP4  ,FlexCAN_E: trusted protect" "0,1"
TEXTLINE "                  "

endif

group.long 0xFFF0004C++0x03
  line.long    0x00 "OPACR3,Off-Platform Peripheral Access Control Register 3"
sif (CPU()=="MPC5561")||(CPU()=="MPC5567")
  bitfld.long  0x00 (31.-0*4.) "FlexRay:   BW0  ,FlexRay:   buffer writes" "0,1"
  bitfld.long  0x00 (30.-0*4.) "  SP0  ,FlexRay:   supervisor protect" "0,1"
  bitfld.long  0x00 (29.-0*4.) "  WP0  ,FlexRay:   write protect" "0,1"
  bitfld.long  0x00 (28.-0*4.) "  TP0  ,FlexRay:   trusted protect" "0,1"
TEXTLINE "                  "

endif
sif (CPU()=="MPC5561")
  bitfld.long  0x00 (31.-2*4.) "PDI:       BW2  ,PDI:       buffer writes" "0,1"
  bitfld.long  0x00 (30.-2*4.) "  SP2  ,PDI:       supervisor protect" "0,1"
  bitfld.long  0x00 (29.-2*4.) "  WP2  ,PDI:       write protect" "0,1"
  bitfld.long  0x00 (28.-2*4.) "  TP2  ,PDI:       trusted protect" "0,1"
TEXTLINE "                  "

endif
  bitfld.long  0x00 (31.-7*4.) "BAM:       BW7  ,BAM:       buffer writes" "0,1"
  bitfld.long  0x00 (30.-7*4.) "  SP7  ,BAM:       supervisor protect" "0,1"
  bitfld.long  0x00 (29.-7*4.) "  WP7  ,BAM:       write protect" "0,1"
  bitfld.long  0x00 (28.-7*4.) "  TP7  ,BAM:       trusted protect" "0,1"
TEXTLINE "                  "


endif

tree.end
  endif
tree "XBAR Switch"

group VM:0++0
TEXTLINE ""
TEXTLINE "Module         XBAR Port     Master ID"
TEXTLINE "--------------------------------------"

sif (CPU()=="MPC5533")||(CPU()=="MPC5534")
TEXTLINE "e200z6 instr   Master 0      0"
TEXTLINE "eDMA           Master 1      2"
TEXTLINE "EBI            Master 2      3"
TEXTLINE "e200z6 data    Master 4      0"
TEXTLINE "e200z6-Nexus   Master 4      1"
TEXTLINE "Flash          Slave  0"      
TEXTLINE "EBI            Slave  1"      
TEXTLINE "Internal SRAM  Slave  3"      
TEXTLINE "PBRIDGE_A      Slave  6"      
TEXTLINE "PBRIDGE_B      Slave  7"      

TEXTLINE ""
group.long 0xfff04000++0x03 "Slave Port 0"
  line.long 0x00 "MPR0,Master Priority Register for Slave Port 0"
  bitfld.long 0x00 16.--17.             "MSTR4 ,Master 4 priority" "highest,2nd high,3rd high, lowest"
  bitfld.long 0x00 08.--09.           "  MSTR2 ,Master 2 priority" "highest,2nd high,3rd high, lowest"
TEXTLINE "                "
  bitfld.long 0x00 04.--05.           "  MSTR1 ,Master 1 priority" "highest,2nd high,3rd high, lowest"
  bitfld.long 0x00 00.--01.           "  MSTR0 ,Master 0 priority" "highest,2nd high,3rd high, lowest"
TEXTLINE ""

group.long (0xfff04000+0x10)++0x03
  line.long 0x00 "SGPCR0,Slave General Purpose Control Register 0"
  bitfld.long 0x00 31.                  "RO    ,Read Only" "0,1"
TEXTLINE "                "
  bitfld.long 0x00 08.--09.           "  ARB   ,Arbitration mode" "Fixed (MPR),Round-robin,res,res"
TEXTLINE "                "
  bitfld.long 0x00 04.--05.           "  PCTL  ,Parking control" "PARK ctrl field,Park on last,Low power park,res"
TEXTLINE "                "
  bitfld.long 0x00 00.--02.           "  PARK  ,Park" "Master Port 0,Master Port 1,Master Port 2,Master Port 3,Master Port 4,Master Port 5,Master Port 6,Master Port 7"

TEXTLINE ""
group.long 0xfff04100++0x03 "Slave Port 1"
  line.long 0x00 "MPR1,Master Priority Register for Slave Port 1"
  bitfld.long 0x00 16.--17.             "MSTR4 ,Master 4 priority" "highest,2nd high,3rd high, lowest"
  bitfld.long 0x00 08.--09.           "  MSTR2 ,Master 2 priority" "highest,2nd high,3rd high, lowest"
TEXTLINE "                "
  bitfld.long 0x00 04.--05.           "  MSTR1 ,Master 1 priority" "highest,2nd high,3rd high, lowest"
  bitfld.long 0x00 00.--01.           "  MSTR0 ,Master 0 priority" "highest,2nd high,3rd high, lowest"
TEXTLINE ""

group.long (0xfff04100+0x10)++0x03
  line.long 0x00 "SGPCR1,Slave General Purpose Control Register 1"
  bitfld.long 0x00 31.                  "RO    ,Read Only" "0,1"
TEXTLINE "                "
  bitfld.long 0x00 08.--09.           "  ARB   ,Arbitration mode" "Fixed (MPR),Round-robin,res,res"
TEXTLINE "                "
  bitfld.long 0x00 04.--05.           "  PCTL  ,Parking control" "PARK ctrl field,Park on last,Low power park,res"
TEXTLINE "                "
  bitfld.long 0x00 00.--02.           "  PARK  ,Park" "Master Port 0,Master Port 1,Master Port 2,Master Port 3,Master Port 4,Master Port 5,Master Port 6,Master Port 7"

TEXTLINE ""
group.long 0xfff04300++0x03 "Slave Port 3"
  line.long 0x00 "MPR3,Master Priority Register for Slave Port 3"
  bitfld.long 0x00 16.--17.             "MSTR4 ,Master 4 priority" "highest,2nd high,3rd high, lowest"
  bitfld.long 0x00 08.--09.           "  MSTR2 ,Master 2 priority" "highest,2nd high,3rd high, lowest"
TEXTLINE "                "
  bitfld.long 0x00 04.--05.           "  MSTR1 ,Master 1 priority" "highest,2nd high,3rd high, lowest"
  bitfld.long 0x00 00.--01.           "  MSTR0 ,Master 0 priority" "highest,2nd high,3rd high, lowest"
TEXTLINE ""

group.long (0xfff04300+0x10)++0x03
  line.long 0x00 "SGPCR3,Slave General Purpose Control Register 3"
  bitfld.long 0x00 31.                  "RO    ,Read Only" "0,1"
TEXTLINE "                "
  bitfld.long 0x00 08.--09.           "  ARB   ,Arbitration mode" "Fixed (MPR),Round-robin,res,res"
TEXTLINE "                "
  bitfld.long 0x00 04.--05.           "  PCTL  ,Parking control" "PARK ctrl field,Park on last,Low power park,res"
TEXTLINE "                "
  bitfld.long 0x00 00.--02.           "  PARK  ,Park" "Master Port 0,Master Port 1,Master Port 2,Master Port 3,Master Port 4,Master Port 5,Master Port 6,Master Port 7"

TEXTLINE ""
group.long 0xfff04600++0x03 "Slave Port 6"
  line.long 0x00 "MPR6,Master Priority Register for Slave Port 6"
  bitfld.long 0x00 16.--17.             "MSTR4 ,Master 4 priority" "highest,2nd high,3rd high, lowest"
  bitfld.long 0x00 08.--09.           "  MSTR2 ,Master 2 priority" "highest,2nd high,3rd high, lowest"
TEXTLINE "                "
  bitfld.long 0x00 04.--05.           "  MSTR1 ,Master 1 priority" "highest,2nd high,3rd high, lowest"
  bitfld.long 0x00 00.--01.           "  MSTR0 ,Master 0 priority" "highest,2nd high,3rd high, lowest"
TEXTLINE ""

group.long (0xfff04600+0x10)++0x03
  line.long 0x00 "SGPCR6,Slave General Purpose Control Register 6"
  bitfld.long 0x00 31.                  "RO    ,Read Only" "0,1"
TEXTLINE "                "
  bitfld.long 0x00 08.--09.           "  ARB   ,Arbitration mode" "Fixed (MPR),Round-robin,res,res"
TEXTLINE "                "
  bitfld.long 0x00 04.--05.           "  PCTL  ,Parking control" "PARK ctrl field,Park on last,Low power park,res"
TEXTLINE "                "
  bitfld.long 0x00 00.--02.           "  PARK  ,Park" "Master Port 0,Master Port 1,Master Port 2,Master Port 3,Master Port 4,Master Port 5,Master Port 6,Master Port 7"

TEXTLINE ""
group.long 0xfff04700++0x03 "Slave Port 7"
  line.long 0x00 "MPR7,Master Priority Register for Slave Port 7"
  bitfld.long 0x00 16.--17.             "MSTR4 ,Master 4 priority" "highest,2nd high,3rd high, lowest"
  bitfld.long 0x00 08.--09.           "  MSTR2 ,Master 2 priority" "highest,2nd high,3rd high, lowest"
TEXTLINE "                "
  bitfld.long 0x00 04.--05.           "  MSTR1 ,Master 1 priority" "highest,2nd high,3rd high, lowest"
  bitfld.long 0x00 00.--01.           "  MSTR0 ,Master 0 priority" "highest,2nd high,3rd high, lowest"
TEXTLINE ""

group.long (0xfff04700+0x10)++0x03
  line.long 0x00 "SGPCR7,Slave General Purpose Control Register 7"
  bitfld.long 0x00 31.                  "RO    ,Read Only" "0,1"
TEXTLINE "                "
  bitfld.long 0x00 08.--09.           "  ARB   ,Arbitration mode" "Fixed (MPR),Round-robin,res,res"
TEXTLINE "                "
  bitfld.long 0x00 04.--05.           "  PCTL  ,Parking control" "PARK ctrl field,Park on last,Low power park,res"
TEXTLINE "                "
  bitfld.long 0x00 00.--02.           "  PARK  ,Park" "Master Port 0,Master Port 1,Master Port 2,Master Port 3,Master Port 4,Master Port 5,Master Port 6,Master Port 7"

endif

sif CPU()=="MPC5554"
TEXTLINE "e200z6 core    Master 0      0"
TEXTLINE "e200z6-Nexus   Master 0      1"
TEXTLINE "eDMA           Master 1      2"
TEXTLINE "EBI            Master 2      3"
TEXTLINE "Flash          Slave  0"      
TEXTLINE "EBI            Slave  1"      
TEXTLINE "Internal SRAM  Slave  3"      
TEXTLINE "PBRIDGE_A      Slave  6"      
TEXTLINE "PBRIDGE_B      Slave  7"      

TEXTLINE ""
group.long 0xfff04000++0x03 "Slave Port 0"
  line.long 0x00 "MPR0,Master Priority Register for Slave Port 0"
  bitfld.long 0x00 08.--09.             "MSTR2 ,Master 2 priority" "highest,2nd high,3rd high, lowest"
  bitfld.long 0x00 04.--05.           "  MSTR1 ,Master 1 priority" "highest,2nd high,3rd high, lowest"
  bitfld.long 0x00 00.--01.           "  MSTR0 ,Master 0 priority" "highest,2nd high,3rd high, lowest"
TEXTLINE ""

group.long (0xfff04000+0x10)++0x03
  line.long 0x00 "SGPCR0,Slave General Purpose Control Register 0"
  bitfld.long 0x00 31.                  "RO    ,Read Only" "0,1"
TEXTLINE "                "
  bitfld.long 0x00 08.--09.           "  ARB   ,Arbitration mode" "Fixed (MPR),Round-robin,res,res"
TEXTLINE "                "
  bitfld.long 0x00 04.--05.           "  PCTL  ,Parking control" "PARK ctrl field,Park on last,Low power park,res"
TEXTLINE "                "
  bitfld.long 0x00 00.--02.           "  PARK  ,Park" "Master Port 0,Master Port 1,Master Port 2,Master Port 3,Master Port 4,Master Port 5,Master Port 6,Master Port 7"

TEXTLINE ""
group.long 0xfff04100++0x03 "Slave Port 1"
  line.long 0x00 "MPR1,Master Priority Register for Slave Port 1"
  bitfld.long 0x00 08.--09.             "MSTR2 ,Master 2 priority" "highest,2nd high,3rd high, lowest"
  bitfld.long 0x00 04.--05.           "  MSTR1 ,Master 1 priority" "highest,2nd high,3rd high, lowest"
  bitfld.long 0x00 00.--01.           "  MSTR0 ,Master 0 priority" "highest,2nd high,3rd high, lowest"
TEXTLINE ""

group.long (0xfff04100+0x10)++0x03
  line.long 0x00 "SGPCR1,Slave General Purpose Control Register 1"
  bitfld.long 0x00 31.                  "RO    ,Read Only" "0,1"
TEXTLINE "                "
  bitfld.long 0x00 08.--09.           "  ARB   ,Arbitration mode" "Fixed (MPR),Round-robin,res,res"
TEXTLINE "                "
  bitfld.long 0x00 04.--05.           "  PCTL  ,Parking control" "PARK ctrl field,Park on last,Low power park,res"
TEXTLINE "                "
  bitfld.long 0x00 00.--02.           "  PARK  ,Park" "Master Port 0,Master Port 1,Master Port 2,Master Port 3,Master Port 4,Master Port 5,Master Port 6,Master Port 7"

TEXTLINE ""
group.long 0xfff04300++0x03 "Slave Port 3"
  line.long 0x00 "MPR3,Master Priority Register for Slave Port 3"
  bitfld.long 0x00 08.--09.             "MSTR2 ,Master 2 priority" "highest,2nd high,3rd high, lowest"
  bitfld.long 0x00 04.--05.           "  MSTR1 ,Master 1 priority" "highest,2nd high,3rd high, lowest"
  bitfld.long 0x00 00.--01.           "  MSTR0 ,Master 0 priority" "highest,2nd high,3rd high, lowest"
TEXTLINE ""

group.long (0xfff04300+0x10)++0x03
  line.long 0x00 "SGPCR3,Slave General Purpose Control Register 3"
  bitfld.long 0x00 31.                  "RO    ,Read Only" "0,1"
TEXTLINE "                "
  bitfld.long 0x00 08.--09.           "  ARB   ,Arbitration mode" "Fixed (MPR),Round-robin,res,res"
TEXTLINE "                "
  bitfld.long 0x00 04.--05.           "  PCTL  ,Parking control" "PARK ctrl field,Park on last,Low power park,res"
TEXTLINE "                "
  bitfld.long 0x00 00.--02.           "  PARK  ,Park" "Master Port 0,Master Port 1,Master Port 2,Master Port 3,Master Port 4,Master Port 5,Master Port 6,Master Port 7"

TEXTLINE ""
group.long 0xfff04600++0x03 "Slave Port 6"
  line.long 0x00 "MPR6,Master Priority Register for Slave Port 6"
  bitfld.long 0x00 08.--09.             "MSTR2 ,Master 2 priority" "highest,2nd high,3rd high, lowest"
  bitfld.long 0x00 04.--05.           "  MSTR1 ,Master 1 priority" "highest,2nd high,3rd high, lowest"
  bitfld.long 0x00 00.--01.           "  MSTR0 ,Master 0 priority" "highest,2nd high,3rd high, lowest"
TEXTLINE ""

group.long (0xfff04600+0x10)++0x03
  line.long 0x00 "SGPCR6,Slave General Purpose Control Register 6"
  bitfld.long 0x00 31.                  "RO    ,Read Only" "0,1"
TEXTLINE "                "
  bitfld.long 0x00 08.--09.           "  ARB   ,Arbitration mode" "Fixed (MPR),Round-robin,res,res"
TEXTLINE "                "
  bitfld.long 0x00 04.--05.           "  PCTL  ,Parking control" "PARK ctrl field,Park on last,Low power park,res"
TEXTLINE "                "
  bitfld.long 0x00 00.--02.           "  PARK  ,Park" "Master Port 0,Master Port 1,Master Port 2,Master Port 3,Master Port 4,Master Port 5,Master Port 6,Master Port 7"

TEXTLINE ""
group.long 0xfff04700++0x03 "Slave Port 7"
  line.long 0x00 "MPR7,Master Priority Register for Slave Port 7"
  bitfld.long 0x00 08.--09.             "MSTR2 ,Master 2 priority" "highest,2nd high,3rd high, lowest"
  bitfld.long 0x00 04.--05.           "  MSTR1 ,Master 1 priority" "highest,2nd high,3rd high, lowest"
  bitfld.long 0x00 00.--01.           "  MSTR0 ,Master 0 priority" "highest,2nd high,3rd high, lowest"
TEXTLINE ""

group.long (0xfff04700+0x10)++0x03
  line.long 0x00 "SGPCR7,Slave General Purpose Control Register 7"
  bitfld.long 0x00 31.                  "RO    ,Read Only" "0,1"
TEXTLINE "                "
  bitfld.long 0x00 08.--09.           "  ARB   ,Arbitration mode" "Fixed (MPR),Round-robin,res,res"
TEXTLINE "                "
  bitfld.long 0x00 04.--05.           "  PCTL  ,Parking control" "PARK ctrl field,Park on last,Low power park,res"
TEXTLINE "                "
  bitfld.long 0x00 00.--02.           "  PARK  ,Park" "Master Port 0,Master Port 1,Master Port 2,Master Port 3,Master Port 4,Master Port 5,Master Port 6,Master Port 7"

endif

sif CPU()=="MPC5553"
TEXTLINE "e200z6 core    Master 0      0"
TEXTLINE "e200z6-Nexus   Master 0      1"
TEXTLINE "eDMA           Master 1      2"
TEXTLINE "EBI            Master 2      3"
TEXTLINE "FEC            Master 3      4"
TEXTLINE "Flash          Slave  0"      
TEXTLINE "EBI            Slave  1"      
TEXTLINE "Internal SRAM  Slave  3"      
TEXTLINE "PBRIDGE_A      Slave  6"      
TEXTLINE "PBRIDGE_B      Slave  7"      

TEXTLINE ""
group.long 0xfff04000++0x03
  line.long 0x00 "MPR0,Master Priority Register for Slave Port 0"
  bitfld.long 0x00 12.--13.             "MSTR3 ,Master 3 priority" "highest,2nd high,3rd high, lowest"
  bitfld.long 0x00 08.--09.           "  MSTR2 ,Master 2 priority" "highest,2nd high,3rd high, lowest"
TEXTLINE "                "
  bitfld.long 0x00 04.--05.           "  MSTR1 ,Master 1 priority" "highest,2nd high,3rd high, lowest"
  bitfld.long 0x00 00.--01.           "  MSTR0 ,Master 0 priority" "highest,2nd high,3rd high, lowest"
TEXTLINE ""

group.long (0xfff04000+0x10)++0x03
  line.long 0x00 "SGPCR0,Slave General Purpose Control Register 0"
  bitfld.long 0x00 31.                  "RO    ,Read Only" "0,1"
TEXTLINE "                "
  bitfld.long 0x00 08.--09.           "  ARB   ,Arbitration mode" "Fixed (MPR),Round-robin,res,res"
TEXTLINE "                "
  bitfld.long 0x00 04.--05.           "  PCTL  ,Parking control" "PARK ctrl field,Park on last,Low power park,res"
TEXTLINE "                "
  bitfld.long 0x00 00.--02.           "  PARK  ,Park" "Master Port 0,Master Port 1,Master Port 2,Master Port 3,Master Port 4,Master Port 5,Master Port 6,Master Port 7"

TEXTLINE ""
group.long 0xfff04100++0x03
  line.long 0x00 "MPR1,Master Priority Register for Slave Port 1"
  bitfld.long 0x00 12.--13.             "MSTR3 ,Master 3 priority" "highest,2nd high,3rd high, lowest"
  bitfld.long 0x00 08.--09.           "  MSTR2 ,Master 2 priority" "highest,2nd high,3rd high, lowest"
TEXTLINE "                "
  bitfld.long 0x00 04.--05.           "  MSTR1 ,Master 1 priority" "highest,2nd high,3rd high, lowest"
  bitfld.long 0x00 00.--01.           "  MSTR0 ,Master 0 priority" "highest,2nd high,3rd high, lowest"
TEXTLINE ""

group.long (0xfff04100+0x10)++0x03
  line.long 0x00 "SGPCR1,Slave General Purpose Control Register 1"
  bitfld.long 0x00 31.                  "RO    ,Read Only" "0,1"
TEXTLINE "                "
  bitfld.long 0x00 08.--09.           "  ARB   ,Arbitration mode" "Fixed (MPR),Round-robin,res,res"
TEXTLINE "                "
  bitfld.long 0x00 04.--05.           "  PCTL  ,Parking control" "PARK ctrl field,Park on last,Low power park,res"
TEXTLINE "                "
  bitfld.long 0x00 00.--02.           "  PARK  ,Park" "Master Port 0,Master Port 1,Master Port 2,Master Port 3,Master Port 4,Master Port 5,Master Port 6,Master Port 7"

TEXTLINE ""
group.long 0xfff04300++0x03
  line.long 0x00 "MPR3,Master Priority Register for Slave Port 3"
  bitfld.long 0x00 12.--13.             "MSTR3 ,Master 3 priority" "highest,2nd high,3rd high, lowest"
  bitfld.long 0x00 08.--09.           "  MSTR2 ,Master 2 priority" "highest,2nd high,3rd high, lowest"
TEXTLINE "                "
  bitfld.long 0x00 04.--05.           "  MSTR1 ,Master 1 priority" "highest,2nd high,3rd high, lowest"
  bitfld.long 0x00 00.--01.           "  MSTR0 ,Master 0 priority" "highest,2nd high,3rd high, lowest"
TEXTLINE ""

group.long (0xfff04300+0x10)++0x03
  line.long 0x00 "SGPCR3,Slave General Purpose Control Register 3"
  bitfld.long 0x00 31.                  "RO    ,Read Only" "0,1"
TEXTLINE "                "
  bitfld.long 0x00 08.--09.           "  ARB   ,Arbitration mode" "Fixed (MPR),Round-robin,res,res"
TEXTLINE "                "
  bitfld.long 0x00 04.--05.           "  PCTL  ,Parking control" "PARK ctrl field,Park on last,Low power park,res"
TEXTLINE "                "
  bitfld.long 0x00 00.--02.           "  PARK  ,Park" "Master Port 0,Master Port 1,Master Port 2,Master Port 3,Master Port 4,Master Port 5,Master Port 6,Master Port 7"

TEXTLINE ""
group.long 0xfff04600++0x03
  line.long 0x00 "MPR6,Master Priority Register for Slave Port 6"
  bitfld.long 0x00 12.--13.             "MSTR3 ,Master 3 priority" "highest,2nd high,3rd high, lowest"
  bitfld.long 0x00 08.--09.           "  MSTR2 ,Master 2 priority" "highest,2nd high,3rd high, lowest"
TEXTLINE "                "
  bitfld.long 0x00 04.--05.           "  MSTR1 ,Master 1 priority" "highest,2nd high,3rd high, lowest"
  bitfld.long 0x00 00.--01.           "  MSTR0 ,Master 0 priority" "highest,2nd high,3rd high, lowest"
TEXTLINE ""

group.long (0xfff04600+0x10)++0x03
  line.long 0x00 "SGPCR6,Slave General Purpose Control Register 6"
  bitfld.long 0x00 31.                  "RO    ,Read Only" "0,1"
TEXTLINE "                "
  bitfld.long 0x00 08.--09.           "  ARB   ,Arbitration mode" "Fixed (MPR),Round-robin,res,res"
TEXTLINE "                "
  bitfld.long 0x00 04.--05.           "  PCTL  ,Parking control" "PARK ctrl field,Park on last,Low power park,res"
TEXTLINE "                "
  bitfld.long 0x00 00.--02.           "  PARK  ,Park" "Master Port 0,Master Port 1,Master Port 2,Master Port 3,Master Port 4,Master Port 5,Master Port 6,Master Port 7"

TEXTLINE ""
group.long 0xfff04700++0x03
  line.long 0x00 "MPR7,Master Priority Register for Slave Port 7"
  bitfld.long 0x00 12.--13.             "MSTR3 ,Master 3 priority" "highest,2nd high,3rd high, lowest"
  bitfld.long 0x00 08.--09.           "  MSTR2 ,Master 2 priority" "highest,2nd high,3rd high, lowest"
TEXTLINE "                "
  bitfld.long 0x00 04.--05.           "  MSTR1 ,Master 1 priority" "highest,2nd high,3rd high, lowest"
  bitfld.long 0x00 00.--01.           "  MSTR0 ,Master 0 priority" "highest,2nd high,3rd high, lowest"
TEXTLINE ""

group.long (0xfff04700+0x10)++0x03
  line.long 0x00 "SGPCR7,Slave General Purpose Control Register 7"
  bitfld.long 0x00 31.                  "RO    ,Read Only" "0,1"
TEXTLINE "                "
  bitfld.long 0x00 08.--09.           "  ARB   ,Arbitration mode" "Fixed (MPR),Round-robin,res,res"
TEXTLINE "                "
  bitfld.long 0x00 04.--05.           "  PCTL  ,Parking control" "PARK ctrl field,Park on last,Low power park,res"
TEXTLINE "                "
  bitfld.long 0x00 00.--02.           "  PARK  ,Park" "Master Port 0,Master Port 1,Master Port 2,Master Port 3,Master Port 4,Master Port 5,Master Port 6,Master Port 7"

endif

sif CPU()=="MPC5561"
TEXTLINE "e200z6 core    Master 0      0"
TEXTLINE "e200z6-Nexus   Master 0      1"
TEXTLINE "eDMA           Master 1      2"
TEXTLINE "EBI            Master 2      3"
TEXTLINE "FlexRay        Master 6      6"
TEXTLINE "Flash          Slave  0"      
TEXTLINE "EBI            Slave  1"      
TEXTLINE "Internal SRAM  Slave  3"      
TEXTLINE "PDI            Slave  5"      
TEXTLINE "PBRIDGE_A      Slave  6"      
TEXTLINE "PBRIDGE_B      Slave  7"      

TEXTLINE ""
group.long 0xfff04000++0x03 "Slave Port 0"
  line.long 0x00 "MPR0,Master Priority Register for Slave Port 0"
  bitfld.long 0x00 24.--26.             "MSTR6 ,Master 6 priority" "0 (high),1,2,3,4 (low),res.,res.,res."
  bitfld.long 0x00 12.--14.           "  MSTR3 ,Master 3 priority" "0 (high),1,2,3,4 (low),res.,res.,res."
TEXTLINE "                "
  bitfld.long 0x00 08.--10.           "  MSTR2 ,Master 2 priority" "0 (high),1,2,3,4 (low),res.,res.,res."
  bitfld.long 0x00 04.--06.           "  MSTR1 ,Master 1 priority" "0 (high),1,2,3,4 (low),res.,res.,res."
  bitfld.long 0x00 00.--02.           "  MSTR0 ,Master 0 priority" "0 (high),1,2,3,4 (low),res.,res.,res."
TEXTLINE ""

group.long (0xfff04000+0x10)++0x03
  line.long 0x00 "SGPCR0,Slave General Purpose Control Register 0"
  bitfld.long 0x00 31.                  "RO    ,Read Only" "0,1"
TEXTLINE "                "
  bitfld.long 0x00 08.--09.           "  ARB   ,Arbitration mode" "Fixed (MPR),Round-robin,res,res"
TEXTLINE "                "
  bitfld.long 0x00 04.--05.           "  PCTL  ,Parking control" "PARK ctrl field,Park on last,Low power park,res"
TEXTLINE "                "
  bitfld.long 0x00 00.--02.           "  PARK  ,Park" "Master Port 0,Master Port 1,Master Port 2,Master Port 3,Master Port 4,Master Port 5,Master Port 6,Master Port 7"

TEXTLINE ""
group.long 0xfff04100++0x03 "Slave Port 1"
  line.long 0x00 "MPR1,Master Priority Register for Slave Port 1"
  bitfld.long 0x00 24.--26.             "MSTR6 ,Master 6 priority" "0 (high),1,2,3,4 (low),res.,res.,res."
  bitfld.long 0x00 12.--14.           "  MSTR3 ,Master 3 priority" "0 (high),1,2,3,4 (low),res.,res.,res."
TEXTLINE "                "
  bitfld.long 0x00 08.--10.           "  MSTR2 ,Master 2 priority" "0 (high),1,2,3,4 (low),res.,res.,res."
  bitfld.long 0x00 04.--06.           "  MSTR1 ,Master 1 priority" "0 (high),1,2,3,4 (low),res.,res.,res."
  bitfld.long 0x00 00.--02.           "  MSTR0 ,Master 0 priority" "0 (high),1,2,3,4 (low),res.,res.,res."
TEXTLINE ""

group.long (0xfff04100+0x10)++0x03
  line.long 0x00 "SGPCR1,Slave General Purpose Control Register 1"
  bitfld.long 0x00 31.                  "RO    ,Read Only" "0,1"
TEXTLINE "                "
  bitfld.long 0x00 08.--09.           "  ARB   ,Arbitration mode" "Fixed (MPR),Round-robin,res,res"
TEXTLINE "                "
  bitfld.long 0x00 04.--05.           "  PCTL  ,Parking control" "PARK ctrl field,Park on last,Low power park,res"
TEXTLINE "                "
  bitfld.long 0x00 00.--02.           "  PARK  ,Park" "Master Port 0,Master Port 1,Master Port 2,Master Port 3,Master Port 4,Master Port 5,Master Port 6,Master Port 7"

TEXTLINE ""
group.long 0xfff04300++0x03 "Slave Port 3"
  line.long 0x00 "MPR3,Master Priority Register for Slave Port 3"
  bitfld.long 0x00 24.--26.             "MSTR6 ,Master 6 priority" "0 (high),1,2,3,4 (low),res.,res.,res."
  bitfld.long 0x00 12.--14.           "  MSTR3 ,Master 3 priority" "0 (high),1,2,3,4 (low),res.,res.,res."
TEXTLINE "                "
  bitfld.long 0x00 08.--10.           "  MSTR2 ,Master 2 priority" "0 (high),1,2,3,4 (low),res.,res.,res."
  bitfld.long 0x00 04.--06.           "  MSTR1 ,Master 1 priority" "0 (high),1,2,3,4 (low),res.,res.,res."
  bitfld.long 0x00 00.--02.           "  MSTR0 ,Master 0 priority" "0 (high),1,2,3,4 (low),res.,res.,res."
TEXTLINE ""

group.long (0xfff04300+0x10)++0x03
  line.long 0x00 "SGPCR3,Slave General Purpose Control Register 3"
  bitfld.long 0x00 31.                  "RO    ,Read Only" "0,1"
TEXTLINE "                "
  bitfld.long 0x00 08.--09.           "  ARB   ,Arbitration mode" "Fixed (MPR),Round-robin,res,res"
TEXTLINE "                "
  bitfld.long 0x00 04.--05.           "  PCTL  ,Parking control" "PARK ctrl field,Park on last,Low power park,res"
TEXTLINE "                "
  bitfld.long 0x00 00.--02.           "  PARK  ,Park" "Master Port 0,Master Port 1,Master Port 2,Master Port 3,Master Port 4,Master Port 5,Master Port 6,Master Port 7"

TEXTLINE ""
group.long 0xfff04500++0x03 "Slave Port 5"
  line.long 0x00 "MPR5,Master Priority Register for Slave Port 5"
  bitfld.long 0x00 24.--26.             "MSTR6 ,Master 6 priority" "0 (high),1,2,3,4 (low),res.,res.,res."
  bitfld.long 0x00 12.--14.           "  MSTR3 ,Master 3 priority" "0 (high),1,2,3,4 (low),res.,res.,res."
TEXTLINE "                "
  bitfld.long 0x00 08.--10.           "  MSTR2 ,Master 2 priority" "0 (high),1,2,3,4 (low),res.,res.,res."
  bitfld.long 0x00 04.--06.           "  MSTR1 ,Master 1 priority" "0 (high),1,2,3,4 (low),res.,res.,res."
  bitfld.long 0x00 00.--02.           "  MSTR0 ,Master 0 priority" "0 (high),1,2,3,4 (low),res.,res.,res."
TEXTLINE ""

group.long (0xfff04500+0x10)++0x03
  line.long 0x00 "SGPCR5,Slave General Purpose Control Register 5"
  bitfld.long 0x00 31.                  "RO    ,Read Only" "0,1"
TEXTLINE "                "
  bitfld.long 0x00 08.--09.           "  ARB   ,Arbitration mode" "Fixed (MPR),Round-robin,res,res"
TEXTLINE "                "
  bitfld.long 0x00 04.--05.           "  PCTL  ,Parking control" "PARK ctrl field,Park on last,Low power park,res"
TEXTLINE "                "
  bitfld.long 0x00 00.--02.           "  PARK  ,Park" "Master Port 0,Master Port 1,Master Port 2,Master Port 3,Master Port 4,Master Port 5,Master Port 6,Master Port 7"

TEXTLINE ""
group.long 0xfff04600++0x03 "Slave Port 6"
  line.long 0x00 "MPR6,Master Priority Register for Slave Port 6"
  bitfld.long 0x00 24.--26.             "MSTR6 ,Master 6 priority" "0 (high),1,2,3,4 (low),res.,res.,res."
  bitfld.long 0x00 12.--14.           "  MSTR3 ,Master 3 priority" "0 (high),1,2,3,4 (low),res.,res.,res."
TEXTLINE "                "
  bitfld.long 0x00 08.--10.           "  MSTR2 ,Master 2 priority" "0 (high),1,2,3,4 (low),res.,res.,res."
  bitfld.long 0x00 04.--06.           "  MSTR1 ,Master 1 priority" "0 (high),1,2,3,4 (low),res.,res.,res."
  bitfld.long 0x00 00.--02.           "  MSTR0 ,Master 0 priority" "0 (high),1,2,3,4 (low),res.,res.,res."
TEXTLINE ""

group.long (0xfff04600+0x10)++0x03
  line.long 0x00 "SGPCR6,Slave General Purpose Control Register 6"
  bitfld.long 0x00 31.                  "RO    ,Read Only" "0,1"
TEXTLINE "                "
  bitfld.long 0x00 08.--09.           "  ARB   ,Arbitration mode" "Fixed (MPR),Round-robin,res,res"
TEXTLINE "                "
  bitfld.long 0x00 04.--05.           "  PCTL  ,Parking control" "PARK ctrl field,Park on last,Low power park,res"
TEXTLINE "                "
  bitfld.long 0x00 00.--02.           "  PARK  ,Park" "Master Port 0,Master Port 1,Master Port 2,Master Port 3,Master Port 4,Master Port 5,Master Port 6,Master Port 7"

TEXTLINE ""
group.long 0xfff04700++0x03 "Slave Port 7"
  line.long 0x00 "MPR7,Master Priority Register for Slave Port 7"
  bitfld.long 0x00 24.--26.             "MSTR6 ,Master 6 priority" "0 (high),1,2,3,4 (low),res.,res.,res."
  bitfld.long 0x00 12.--14.           "  MSTR3 ,Master 3 priority" "0 (high),1,2,3,4 (low),res.,res.,res."
TEXTLINE "                "
  bitfld.long 0x00 08.--10.           "  MSTR2 ,Master 2 priority" "0 (high),1,2,3,4 (low),res.,res.,res."
  bitfld.long 0x00 04.--06.           "  MSTR1 ,Master 1 priority" "0 (high),1,2,3,4 (low),res.,res.,res."
  bitfld.long 0x00 00.--02.           "  MSTR0 ,Master 0 priority" "0 (high),1,2,3,4 (low),res.,res.,res."
TEXTLINE ""

group.long (0xfff04700+0x10)++0x03
  line.long 0x00 "SGPCR7,Slave General Purpose Control Register 7"
  bitfld.long 0x00 31.                  "RO    ,Read Only" "0,1"
TEXTLINE "                "
  bitfld.long 0x00 08.--09.           "  ARB   ,Arbitration mode" "Fixed (MPR),Round-robin,res,res"
TEXTLINE "                "
  bitfld.long 0x00 04.--05.           "  PCTL  ,Parking control" "PARK ctrl field,Park on last,Low power park,res"
TEXTLINE "                "
  bitfld.long 0x00 00.--02.           "  PARK  ,Park" "Master Port 0,Master Port 1,Master Port 2,Master Port 3,Master Port 4,Master Port 5,Master Port 6,Master Port 7"

endif

sif CPU()=="MPC5565"
TEXTLINE "e200z6 core    Master 0      0"
TEXTLINE "e200z6-Nexus   Master 0      1"
TEXTLINE "eDMA           Master 1      2"
TEXTLINE "EBI            Master 2      3"
TEXTLINE "Flash          Slave  0"      
TEXTLINE "EBI            Slave  1"      
TEXTLINE "Internal SRAM  Slave  3"      
TEXTLINE "PBRIDGE_A      Slave  6"      
TEXTLINE "PBRIDGE_B      Slave  7"      

TEXTLINE ""
group.long 0xfff04000++0x03 "Slave Port 0"
  line.long 0x00 "MPR0,Master Priority Register for Slave Port 0"
  bitfld.long 0x00 08.--09.             "MSTR2 ,Master 2 priority" "highest,2nd high, lowest,res."
  bitfld.long 0x00 04.--05.           "  MSTR1 ,Master 1 priority" "highest,2nd high, lowest,res."
  bitfld.long 0x00 00.--01.           "  MSTR0 ,Master 0 priority" "highest,2nd high, lowest,res."
TEXTLINE ""

group.long (0xfff04000+0x10)++0x03
  line.long 0x00 "SGPCR0,Slave General Purpose Control Register 0"
  bitfld.long 0x00 31.                  "RO    ,Read Only" "0,1"
TEXTLINE "                "
  bitfld.long 0x00 08.--09.           "  ARB   ,Arbitration mode" "Fixed (MPR),Round-robin,res,res"
TEXTLINE "                "
  bitfld.long 0x00 04.--05.           "  PCTL  ,Parking control" "PARK ctrl field,Park on last,Low power park,res"
TEXTLINE "                "
  bitfld.long 0x00 00.--02.           "  PARK  ,Park" "Master Port 0,Master Port 1,Master Port 2,Master Port 3,Master Port 4,Master Port 5,Master Port 6,Master Port 7"
TEXTLINE ""
group.long 0xfff04100++0x03 "Slave Port 1"
  line.long 0x00 "MPR1,Master Priority Register for Slave Port 1"
  bitfld.long 0x00 08.--09.             "MSTR2 ,Master 2 priority" "highest,2nd high, lowest,res."
  bitfld.long 0x00 04.--05.           "  MSTR1 ,Master 1 priority" "highest,2nd high, lowest,res."
  bitfld.long 0x00 00.--01.           "  MSTR0 ,Master 0 priority" "highest,2nd high, lowest,res."
TEXTLINE ""

group.long (0xfff04100+0x10)++0x03
  line.long 0x00 "SGPCR1,Slave General Purpose Control Register 1"
  bitfld.long 0x00 31.                  "RO    ,Read Only" "0,1"
TEXTLINE "                "
  bitfld.long 0x00 08.--09.           "  ARB   ,Arbitration mode" "Fixed (MPR),Round-robin,res,res"
TEXTLINE "                "
  bitfld.long 0x00 04.--05.           "  PCTL  ,Parking control" "PARK ctrl field,Park on last,Low power park,res"
TEXTLINE "                "
  bitfld.long 0x00 00.--02.           "  PARK  ,Park" "Master Port 0,Master Port 1,Master Port 2,Master Port 3,Master Port 4,Master Port 5,Master Port 6,Master Port 7"
TEXTLINE ""
group.long 0xfff04300++0x03 "Slave Port 3"
  line.long 0x00 "MPR3,Master Priority Register for Slave Port 3"
  bitfld.long 0x00 08.--09.             "MSTR2 ,Master 2 priority" "highest,2nd high, lowest,res."
  bitfld.long 0x00 04.--05.           "  MSTR1 ,Master 1 priority" "highest,2nd high, lowest,res."
  bitfld.long 0x00 00.--01.           "  MSTR0 ,Master 0 priority" "highest,2nd high, lowest,res."
TEXTLINE ""

group.long (0xfff04300+0x10)++0x03
  line.long 0x00 "SGPCR3,Slave General Purpose Control Register 3"
  bitfld.long 0x00 31.                  "RO    ,Read Only" "0,1"
TEXTLINE "                "
  bitfld.long 0x00 08.--09.           "  ARB   ,Arbitration mode" "Fixed (MPR),Round-robin,res,res"
TEXTLINE "                "
  bitfld.long 0x00 04.--05.           "  PCTL  ,Parking control" "PARK ctrl field,Park on last,Low power park,res"
TEXTLINE "                "
  bitfld.long 0x00 00.--02.           "  PARK  ,Park" "Master Port 0,Master Port 1,Master Port 2,Master Port 3,Master Port 4,Master Port 5,Master Port 6,Master Port 7"
TEXTLINE ""
group.long 0xfff04600++0x03 "Slave Port 6"
  line.long 0x00 "MPR6,Master Priority Register for Slave Port 6"
  bitfld.long 0x00 08.--09.             "MSTR2 ,Master 2 priority" "highest,2nd high, lowest,res."
  bitfld.long 0x00 04.--05.           "  MSTR1 ,Master 1 priority" "highest,2nd high, lowest,res."
  bitfld.long 0x00 00.--01.           "  MSTR0 ,Master 0 priority" "highest,2nd high, lowest,res."
TEXTLINE ""

group.long (0xfff04600+0x10)++0x03
  line.long 0x00 "SGPCR6,Slave General Purpose Control Register 6"
  bitfld.long 0x00 31.                  "RO    ,Read Only" "0,1"
TEXTLINE "                "
  bitfld.long 0x00 08.--09.           "  ARB   ,Arbitration mode" "Fixed (MPR),Round-robin,res,res"
TEXTLINE "                "
  bitfld.long 0x00 04.--05.           "  PCTL  ,Parking control" "PARK ctrl field,Park on last,Low power park,res"
TEXTLINE "                "
  bitfld.long 0x00 00.--02.           "  PARK  ,Park" "Master Port 0,Master Port 1,Master Port 2,Master Port 3,Master Port 4,Master Port 5,Master Port 6,Master Port 7"
TEXTLINE ""
group.long 0xfff04700++0x03 "Slave Port 7"
  line.long 0x00 "MPR7,Master Priority Register for Slave Port 7"
  bitfld.long 0x00 08.--09.             "MSTR2 ,Master 2 priority" "highest,2nd high, lowest,res."
  bitfld.long 0x00 04.--05.           "  MSTR1 ,Master 1 priority" "highest,2nd high, lowest,res."
  bitfld.long 0x00 00.--01.           "  MSTR0 ,Master 0 priority" "highest,2nd high, lowest,res."
TEXTLINE ""

group.long (0xfff04700+0x10)++0x03
  line.long 0x00 "SGPCR7,Slave General Purpose Control Register 7"
  bitfld.long 0x00 31.                  "RO    ,Read Only" "0,1"
TEXTLINE "                "
  bitfld.long 0x00 08.--09.           "  ARB   ,Arbitration mode" "Fixed (MPR),Round-robin,res,res"
TEXTLINE "                "
  bitfld.long 0x00 04.--05.           "  PCTL  ,Parking control" "PARK ctrl field,Park on last,Low power park,res"
TEXTLINE "                "
  bitfld.long 0x00 00.--02.           "  PARK  ,Park" "Master Port 0,Master Port 1,Master Port 2,Master Port 3,Master Port 4,Master Port 5,Master Port 6,Master Port 7"
endif

sif CPU()=="MPC5566"
TEXTLINE "e200z6 core    Master 0      0"
TEXTLINE "e200z6-Nexus   Master 0      1"
TEXTLINE "eDMA           Master 1      2"
TEXTLINE "EBI            Master 2      3"
TEXTLINE "FEC            Master 3      4"
TEXTLINE "Flash          Slave  0"      
TEXTLINE "EBI            Slave  1"      
TEXTLINE "Internal SRAM  Slave  3"      
TEXTLINE "PBRIDGE_A      Slave  6"      
TEXTLINE "PBRIDGE_B      Slave  7"      

TEXTLINE ""
group.long 0xfff04000++0x03 "Slave Port 0"
  line.long 0x00 "MPR0,Master Priority Register for Slave Port 0"
  bitfld.long 0x00 12.--14.             "MSTR3 ,Master 3 priority" "0 (high),1,2,3,4 (low),res.,res.,res."
  bitfld.long 0x00 08.--10.           "  MSTR2 ,Master 2 priority" "0 (high),1,2,3,4 (low),res.,res.,res."
TEXTLINE "                "
  bitfld.long 0x00 04.--06.           "  MSTR1 ,Master 1 priority" "0 (high),1,2,3,4 (low),res.,res.,res."
  bitfld.long 0x00 00.--02.           "  MSTR0 ,Master 0 priority" "0 (high),1,2,3,4 (low),res.,res.,res."
TEXTLINE ""

group.long (0xfff04000+0x10)++0x03
  line.long 0x00 "SGPCR0,Slave General Purpose Control Register 0"
  bitfld.long 0x00 31.                  "RO    ,Read Only" "0,1"
TEXTLINE "                "
  bitfld.long 0x00 08.--09.           "  ARB   ,Arbitration mode" "Fixed (MPR),Round-robin,res,res"
TEXTLINE "                "
  bitfld.long 0x00 04.--05.           "  PCTL  ,Parking control" "PARK ctrl field,Park on last,Low power park,res"
TEXTLINE "                "
  bitfld.long 0x00 00.--02.           "  PARK  ,Park" "Master Port 0,Master Port 1,Master Port 2,Master Port 3,Master Port 4,Master Port 5,Master Port 6,Master Port 7"

TEXTLINE ""
group.long 0xfff04100++0x03 "Slave Port 1"
  line.long 0x00 "MPR1,Master Priority Register for Slave Port 1"
  bitfld.long 0x00 12.--14.             "MSTR3 ,Master 3 priority" "0 (high),1,2,3,4 (low),res.,res.,res."
  bitfld.long 0x00 08.--10.           "  MSTR2 ,Master 2 priority" "0 (high),1,2,3,4 (low),res.,res.,res."
TEXTLINE "                "
  bitfld.long 0x00 04.--06.           "  MSTR1 ,Master 1 priority" "0 (high),1,2,3,4 (low),res.,res.,res."
  bitfld.long 0x00 00.--02.           "  MSTR0 ,Master 0 priority" "0 (high),1,2,3,4 (low),res.,res.,res."
TEXTLINE ""

group.long (0xfff04100+0x10)++0x03
  line.long 0x00 "SGPCR1,Slave General Purpose Control Register 1"
  bitfld.long 0x00 31.                  "RO    ,Read Only" "0,1"
TEXTLINE "                "
  bitfld.long 0x00 08.--09.           "  ARB   ,Arbitration mode" "Fixed (MPR),Round-robin,res,res"
TEXTLINE "                "
  bitfld.long 0x00 04.--05.           "  PCTL  ,Parking control" "PARK ctrl field,Park on last,Low power park,res"
TEXTLINE "                "
  bitfld.long 0x00 00.--02.           "  PARK  ,Park" "Master Port 0,Master Port 1,Master Port 2,Master Port 3,Master Port 4,Master Port 5,Master Port 6,Master Port 7"

TEXTLINE ""
group.long 0xfff04300++0x03 "Slave Port 3"
  line.long 0x00 "MPR3,Master Priority Register for Slave Port 3"
  bitfld.long 0x00 12.--14.             "MSTR3 ,Master 3 priority" "0 (high),1,2,3,4 (low),res.,res.,res."
  bitfld.long 0x00 08.--10.           "  MSTR2 ,Master 2 priority" "0 (high),1,2,3,4 (low),res.,res.,res."
TEXTLINE "                "
  bitfld.long 0x00 04.--06.           "  MSTR1 ,Master 1 priority" "0 (high),1,2,3,4 (low),res.,res.,res."
  bitfld.long 0x00 00.--02.           "  MSTR0 ,Master 0 priority" "0 (high),1,2,3,4 (low),res.,res.,res."
TEXTLINE ""

group.long (0xfff04300+0x10)++0x03
  line.long 0x00 "SGPCR3,Slave General Purpose Control Register 3"
  bitfld.long 0x00 31.                  "RO    ,Read Only" "0,1"
TEXTLINE "                "
  bitfld.long 0x00 08.--09.           "  ARB   ,Arbitration mode" "Fixed (MPR),Round-robin,res,res"
TEXTLINE "                "
  bitfld.long 0x00 04.--05.           "  PCTL  ,Parking control" "PARK ctrl field,Park on last,Low power park,res"
TEXTLINE "                "
  bitfld.long 0x00 00.--02.           "  PARK  ,Park" "Master Port 0,Master Port 1,Master Port 2,Master Port 3,Master Port 4,Master Port 5,Master Port 6,Master Port 7"

TEXTLINE ""
group.long 0xfff04600++0x03 "Slave Port 6"
  line.long 0x00 "MPR6,Master Priority Register for Slave Port 6"
  bitfld.long 0x00 12.--14.             "MSTR3 ,Master 3 priority" "0 (high),1,2,3,4 (low),res.,res.,res."
  bitfld.long 0x00 08.--10.           "  MSTR2 ,Master 2 priority" "0 (high),1,2,3,4 (low),res.,res.,res."
TEXTLINE "                "
  bitfld.long 0x00 04.--06.           "  MSTR1 ,Master 1 priority" "0 (high),1,2,3,4 (low),res.,res.,res."
  bitfld.long 0x00 00.--02.           "  MSTR0 ,Master 0 priority" "0 (high),1,2,3,4 (low),res.,res.,res."
TEXTLINE ""

group.long (0xfff04600+0x10)++0x03
  line.long 0x00 "SGPCR6,Slave General Purpose Control Register 6"
  bitfld.long 0x00 31.                  "RO    ,Read Only" "0,1"
TEXTLINE "                "
  bitfld.long 0x00 08.--09.           "  ARB   ,Arbitration mode" "Fixed (MPR),Round-robin,res,res"
TEXTLINE "                "
  bitfld.long 0x00 04.--05.           "  PCTL  ,Parking control" "PARK ctrl field,Park on last,Low power park,res"
TEXTLINE "                "
  bitfld.long 0x00 00.--02.           "  PARK  ,Park" "Master Port 0,Master Port 1,Master Port 2,Master Port 3,Master Port 4,Master Port 5,Master Port 6,Master Port 7"

TEXTLINE ""
group.long 0xfff04700++0x03 "Slave Port 7"
  line.long 0x00 "MPR7,Master Priority Register for Slave Port 7"
  bitfld.long 0x00 12.--14.             "MSTR3 ,Master 3 priority" "0 (high),1,2,3,4 (low),res.,res.,res."
  bitfld.long 0x00 08.--10.           "  MSTR2 ,Master 2 priority" "0 (high),1,2,3,4 (low),res.,res.,res."
TEXTLINE "                "
  bitfld.long 0x00 04.--06.           "  MSTR1 ,Master 1 priority" "0 (high),1,2,3,4 (low),res.,res.,res."
  bitfld.long 0x00 00.--02.           "  MSTR0 ,Master 0 priority" "0 (high),1,2,3,4 (low),res.,res.,res."
TEXTLINE ""

group.long (0xfff04700+0x10)++0x03
  line.long 0x00 "SGPCR7,Slave General Purpose Control Register 7"
  bitfld.long 0x00 31.                  "RO    ,Read Only" "0,1"
TEXTLINE "                "
  bitfld.long 0x00 08.--09.           "  ARB   ,Arbitration mode" "Fixed (MPR),Round-robin,res,res"
TEXTLINE "                "
  bitfld.long 0x00 04.--05.           "  PCTL  ,Parking control" "PARK ctrl field,Park on last,Low power park,res"
TEXTLINE "                "
  bitfld.long 0x00 00.--02.           "  PARK  ,Park" "Master Port 0,Master Port 1,Master Port 2,Master Port 3,Master Port 4,Master Port 5,Master Port 6,Master Port 7"

endif

sif CPU()=="MPC5567"
TEXTLINE "e200z6 core    Master 0      0"
TEXTLINE "e200z6-Nexus   Master 0      1"
TEXTLINE "eDMA           Master 1      2"
TEXTLINE "EBI            Master 2      3"
TEXTLINE "FEC            Master 3      4"
TEXTLINE "FlexRay        Master 6      6"
TEXTLINE "Flash          Slave  0"      
TEXTLINE "EBI            Slave  1"      
TEXTLINE "Internal SRAM  Slave  3"      
TEXTLINE "PBRIDGE_A      Slave  6"      
TEXTLINE "PBRIDGE_B      Slave  7"      

TEXTLINE ""
group.long 0xfff04000++0x03 "Slave Port 0"
  line.long 0x00 "MPR0,Master Priority Register for Slave Port 0"
  bitfld.long 0x00 24.--26.             "MSTR6 ,Master 6 priority" "0 (high),1,2,3,4 (low),res.,res.,res."
  bitfld.long 0x00 12.--14.           "  MSTR3 ,Master 3 priority" "0 (high),1,2,3,4 (low),res.,res.,res."
TEXTLINE "                "
  bitfld.long 0x00 08.--10.           "  MSTR2 ,Master 2 priority" "0 (high),1,2,3,4 (low),res.,res.,res."
  bitfld.long 0x00 04.--06.           "  MSTR1 ,Master 1 priority" "0 (high),1,2,3,4 (low),res.,res.,res."
  bitfld.long 0x00 00.--02.           "  MSTR0 ,Master 0 priority" "0 (high),1,2,3,4 (low),res.,res.,res."
TEXTLINE ""

group.long (0xfff04000+0x10)++0x03
  line.long 0x00 "SGPCR0,Slave General Purpose Control Register 0"
  bitfld.long 0x00 31.                  "RO    ,Read Only" "0,1"
TEXTLINE "                "
  bitfld.long 0x00 08.--09.           "  ARB   ,Arbitration mode" "Fixed (MPR),Round-robin,res,res"
TEXTLINE "                "
  bitfld.long 0x00 04.--05.           "  PCTL  ,Parking control" "PARK ctrl field,Park on last,Low power park,res"
TEXTLINE "                "
  bitfld.long 0x00 00.--02.           "  PARK  ,Park" "Master Port 0,Master Port 1,Master Port 2,Master Port 3,Master Port 4,Master Port 5,Master Port 6,Master Port 7"

TEXTLINE ""
group.long 0xfff04100++0x03 "Slave Port 1"
  line.long 0x00 "MPR1,Master Priority Register for Slave Port 1"
  bitfld.long 0x00 24.--26.             "MSTR6 ,Master 6 priority" "0 (high),1,2,3,4 (low),res.,res.,res."
  bitfld.long 0x00 12.--14.           "  MSTR3 ,Master 3 priority" "0 (high),1,2,3,4 (low),res.,res.,res."
TEXTLINE "                "
  bitfld.long 0x00 08.--10.           "  MSTR2 ,Master 2 priority" "0 (high),1,2,3,4 (low),res.,res.,res."
  bitfld.long 0x00 04.--06.           "  MSTR1 ,Master 1 priority" "0 (high),1,2,3,4 (low),res.,res.,res."
  bitfld.long 0x00 00.--02.           "  MSTR0 ,Master 0 priority" "0 (high),1,2,3,4 (low),res.,res.,res."
TEXTLINE ""

group.long (0xfff04100+0x10)++0x03
  line.long 0x00 "SGPCR1,Slave General Purpose Control Register 1"
  bitfld.long 0x00 31.                  "RO    ,Read Only" "0,1"
TEXTLINE "                "
  bitfld.long 0x00 08.--09.           "  ARB   ,Arbitration mode" "Fixed (MPR),Round-robin,res,res"
TEXTLINE "                "
  bitfld.long 0x00 04.--05.           "  PCTL  ,Parking control" "PARK ctrl field,Park on last,Low power park,res"
TEXTLINE "                "
  bitfld.long 0x00 00.--02.           "  PARK  ,Park" "Master Port 0,Master Port 1,Master Port 2,Master Port 3,Master Port 4,Master Port 5,Master Port 6,Master Port 7"

TEXTLINE ""
group.long 0xfff04300++0x03 "Slave Port 3"
  line.long 0x00 "MPR3,Master Priority Register for Slave Port 3"
  bitfld.long 0x00 24.--26.             "MSTR6 ,Master 6 priority" "0 (high),1,2,3,4 (low),res.,res.,res."
  bitfld.long 0x00 12.--14.           "  MSTR3 ,Master 3 priority" "0 (high),1,2,3,4 (low),res.,res.,res."
TEXTLINE "                "
  bitfld.long 0x00 08.--10.           "  MSTR2 ,Master 2 priority" "0 (high),1,2,3,4 (low),res.,res.,res."
  bitfld.long 0x00 04.--06.           "  MSTR1 ,Master 1 priority" "0 (high),1,2,3,4 (low),res.,res.,res."
  bitfld.long 0x00 00.--02.           "  MSTR0 ,Master 0 priority" "0 (high),1,2,3,4 (low),res.,res.,res."
TEXTLINE ""

group.long (0xfff04300+0x10)++0x03
  line.long 0x00 "SGPCR3,Slave General Purpose Control Register 3"
  bitfld.long 0x00 31.                  "RO    ,Read Only" "0,1"
TEXTLINE "                "
  bitfld.long 0x00 08.--09.           "  ARB   ,Arbitration mode" "Fixed (MPR),Round-robin,res,res"
TEXTLINE "                "
  bitfld.long 0x00 04.--05.           "  PCTL  ,Parking control" "PARK ctrl field,Park on last,Low power park,res"
TEXTLINE "                "
  bitfld.long 0x00 00.--02.           "  PARK  ,Park" "Master Port 0,Master Port 1,Master Port 2,Master Port 3,Master Port 4,Master Port 5,Master Port 6,Master Port 7"

TEXTLINE ""
group.long 0xfff04600++0x03 "Slave Port 6"
  line.long 0x00 "MPR6,Master Priority Register for Slave Port 6"
  bitfld.long 0x00 24.--26.             "MSTR6 ,Master 6 priority" "0 (high),1,2,3,4 (low),res.,res.,res."
  bitfld.long 0x00 12.--14.           "  MSTR3 ,Master 3 priority" "0 (high),1,2,3,4 (low),res.,res.,res."
TEXTLINE "                "
  bitfld.long 0x00 08.--10.           "  MSTR2 ,Master 2 priority" "0 (high),1,2,3,4 (low),res.,res.,res."
  bitfld.long 0x00 04.--06.           "  MSTR1 ,Master 1 priority" "0 (high),1,2,3,4 (low),res.,res.,res."
  bitfld.long 0x00 00.--02.           "  MSTR0 ,Master 0 priority" "0 (high),1,2,3,4 (low),res.,res.,res."
TEXTLINE ""

group.long (0xfff04600+0x10)++0x03
  line.long 0x00 "SGPCR6,Slave General Purpose Control Register 6"
  bitfld.long 0x00 31.                  "RO    ,Read Only" "0,1"
TEXTLINE "                "
  bitfld.long 0x00 08.--09.           "  ARB   ,Arbitration mode" "Fixed (MPR),Round-robin,res,res"
TEXTLINE "                "
  bitfld.long 0x00 04.--05.           "  PCTL  ,Parking control" "PARK ctrl field,Park on last,Low power park,res"
TEXTLINE "                "
  bitfld.long 0x00 00.--02.           "  PARK  ,Park" "Master Port 0,Master Port 1,Master Port 2,Master Port 3,Master Port 4,Master Port 5,Master Port 6,Master Port 7"

TEXTLINE ""
group.long 0xfff04700++0x03 "Slave Port 7"
  line.long 0x00 "MPR7,Master Priority Register for Slave Port 7"
  bitfld.long 0x00 24.--26.             "MSTR6 ,Master 6 priority" "0 (high),1,2,3,4 (low),res.,res.,res."
  bitfld.long 0x00 12.--14.           "  MSTR3 ,Master 3 priority" "0 (high),1,2,3,4 (low),res.,res.,res."
TEXTLINE "                "
  bitfld.long 0x00 08.--10.           "  MSTR2 ,Master 2 priority" "0 (high),1,2,3,4 (low),res.,res.,res."
  bitfld.long 0x00 04.--06.           "  MSTR1 ,Master 1 priority" "0 (high),1,2,3,4 (low),res.,res.,res."
  bitfld.long 0x00 00.--02.           "  MSTR0 ,Master 0 priority" "0 (high),1,2,3,4 (low),res.,res.,res."
TEXTLINE ""

group.long (0xfff04700+0x10)++0x03
  line.long 0x00 "SGPCR7,Slave General Purpose Control Register 7"
  bitfld.long 0x00 31.                  "RO    ,Read Only" "0,1"
TEXTLINE "                "
  bitfld.long 0x00 08.--09.           "  ARB   ,Arbitration mode" "Fixed (MPR),Round-robin,res,res"
TEXTLINE "                "
  bitfld.long 0x00 04.--05.           "  PCTL  ,Parking control" "PARK ctrl field,Park on last,Low power park,res"
TEXTLINE "                "
  bitfld.long 0x00 00.--02.           "  PARK  ,Park" "Master Port 0,Master Port 1,Master Port 2,Master Port 3,Master Port 4,Master Port 5,Master Port 6,Master Port 7"

endif

sif CPUIS("MPC5674*")
TEXTLINE "e200z7 instr   Master 0      0"
TEXTLINE "e200z7 data    Master 1      0"
TEXTLINE "NEXUS3         Master 1      8"
TEXTLINE "eDMA_A         Master 4      4"
TEXTLINE "eDMA_B         Master 5      5"
TEXTLINE "FlexRay        Master 6      6"
TEXTLINE "EBI            Master 7      7"

TEXTLINE "Flash          Slave  0"
TEXTLINE "EBI            Slave  1"
TEXTLINE "Internal SRAM  Slave  2"
TEXTLINE "PBRIDGE_A      Slave  6"
TEXTLINE "PBRIDGE_B      Slave  7"

TEXTLINE ""
group.long 0xfff04000++0x03 "Slave Port 0"
  line.long 0x00 "MPR0,Master Priority Register for Slave Port 0"
  bitfld.long 0x00 28.--30.             "MSTR7 ,Master 7 priority" "0 (high),1,2,3,4,5 (low),res.,res."
  bitfld.long 0x00 24.--26.           "  MSTR6 ,Master 6 priority" "0 (high),1,2,3,4,5 (low),res.,res."
  bitfld.long 0x00 20.--22.           "  MSTR5 ,Master 5 priority" "0 (high),1,2,3,4,5 (low),res.,res."
TEXTLINE "                "
  bitfld.long 0x00 16.--18.           "  MSTR4 ,Master 4 priority" "0 (high),1,2,3,4,5 (low),res.,res."
  bitfld.long 0x00 04.--06.           "  MSTR1 ,Master 1 priority" "0 (high),1,2,3,4,5 (low),res.,res."
  bitfld.long 0x00 00.--02.           "  MSTR0 ,Master 0 priority" "0 (high),1,2,3,4,5 (low),res.,res."
TEXTLINE ""

group.long (0xfff04000+0x10)++0x03
  line.long 0x00 "SGPCR0,Slave General Purpose Control Register 0"
  bitfld.long 0x00 31.                  "RO    ,Read Only" "0,1"
TEXTLINE "                "
  bitfld.long 0x00 08.--09.           "  ARB   ,Arbitration mode" "Fixed (MPR),Round-robin,res,res"
TEXTLINE "                "
  bitfld.long 0x00 04.--05.           "  PCTL  ,Parking control" "PARK ctrl field,Park on last,Low power park,res"
TEXTLINE "                "
  bitfld.long 0x00 00.--02.           "  PARK  ,Park" "Master Port 0,Master Port 1,Master Port 2,Master Port 3,Master Port 4,Master Port 5,Master Port 6,Master Port 7"

TEXTLINE ""
group.long 0xfff04100++0x03 "Slave Port 1"
  line.long 0x00 "MPR1,Master Priority Register for Slave Port 1"
  bitfld.long 0x00 28.--30.             "MSTR7 ,Master 7 priority" "0 (high),1,2,3,4,5 (low),res.,res."
  bitfld.long 0x00 24.--26.           "  MSTR6 ,Master 6 priority" "0 (high),1,2,3,4,5 (low),res.,res."
  bitfld.long 0x00 20.--22.           "  MSTR5 ,Master 5 priority" "0 (high),1,2,3,4,5 (low),res.,res."
TEXTLINE "                "
  bitfld.long 0x00 16.--18.           "  MSTR4 ,Master 4 priority" "0 (high),1,2,3,4,5 (low),res.,res."
  bitfld.long 0x00 04.--06.           "  MSTR1 ,Master 1 priority" "0 (high),1,2,3,4,5 (low),res.,res."
  bitfld.long 0x00 00.--02.           "  MSTR0 ,Master 0 priority" "0 (high),1,2,3,4,5 (low),res.,res."
TEXTLINE ""

group.long (0xfff04100+0x10)++0x03
  line.long 0x00 "SGPCR1,Slave General Purpose Control Register 1"
  bitfld.long 0x00 31.                  "RO    ,Read Only" "0,1"
TEXTLINE "                "
  bitfld.long 0x00 08.--09.           "  ARB   ,Arbitration mode" "Fixed (MPR),Round-robin,res,res"
TEXTLINE "                "
  bitfld.long 0x00 04.--05.           "  PCTL  ,Parking control" "PARK ctrl field,Park on last,Low power park,res"
TEXTLINE "                "
  bitfld.long 0x00 00.--02.           "  PARK  ,Park" "Master Port 0,Master Port 1,Master Port 2,Master Port 3,Master Port 4,Master Port 5,Master Port 6,Master Port 7"

TEXTLINE ""
group.long 0xfff04200++0x03 "Slave Port 2"
  line.long 0x00 "MPR2,Master Priority Register for Slave Port 2"
  bitfld.long 0x00 28.--30.             "MSTR7 ,Master 7 priority" "0 (high),1,2,3,4,5 (low),res.,res."
  bitfld.long 0x00 24.--26.           "  MSTR6 ,Master 6 priority" "0 (high),1,2,3,4,5 (low),res.,res."
  bitfld.long 0x00 20.--22.           "  MSTR5 ,Master 5 priority" "0 (high),1,2,3,4,5 (low),res.,res."
TEXTLINE "                "
  bitfld.long 0x00 16.--18.           "  MSTR4 ,Master 4 priority" "0 (high),1,2,3,4,5 (low),res.,res."
  bitfld.long 0x00 04.--06.           "  MSTR1 ,Master 1 priority" "0 (high),1,2,3,4,5 (low),res.,res."
  bitfld.long 0x00 00.--02.           "  MSTR0 ,Master 0 priority" "0 (high),1,2,3,4,5 (low),res.,res."
TEXTLINE ""

group.long (0xfff04200+0x10)++0x03
  line.long 0x00 "SGPCR2,Slave General Purpose Control Register 2"
  bitfld.long 0x00 31.                  "RO    ,Read Only" "0,1"
TEXTLINE "                "
  bitfld.long 0x00 08.--09.           "  ARB   ,Arbitration mode" "Fixed (MPR),Round-robin,res,res"
TEXTLINE "                "
  bitfld.long 0x00 04.--05.           "  PCTL  ,Parking control" "PARK ctrl field,Park on last,Low power park,res"
TEXTLINE "                "
  bitfld.long 0x00 00.--02.           "  PARK  ,Park" "Master Port 0,Master Port 1,Master Port 2,Master Port 3,Master Port 4,Master Port 5,Master Port 6,Master Port 7"

TEXTLINE ""
group.long 0xfff04600++0x03 "Slave Port 6"
  line.long 0x00 "MPR6,Master Priority Register for Slave Port 6"
  bitfld.long 0x00 28.--30.             "MSTR7 ,Master 7 priority" "0 (high),1,2,3,4,5 (low),res.,res."
  bitfld.long 0x00 24.--26.           "  MSTR6 ,Master 6 priority" "0 (high),1,2,3,4,5 (low),res.,res."
  bitfld.long 0x00 20.--22.           "  MSTR5 ,Master 5 priority" "0 (high),1,2,3,4,5 (low),res.,res."
TEXTLINE "                "
  bitfld.long 0x00 16.--18.           "  MSTR4 ,Master 4 priority" "0 (high),1,2,3,4,5 (low),res.,res."
  bitfld.long 0x00 04.--06.           "  MSTR1 ,Master 1 priority" "0 (high),1,2,3,4,5 (low),res.,res."
  bitfld.long 0x00 00.--02.           "  MSTR0 ,Master 0 priority" "0 (high),1,2,3,4,5 (low),res.,res."
TEXTLINE ""

group.long (0xfff04600+0x10)++0x03
  line.long 0x00 "SGPCR6,Slave General Purpose Control Register 6"
  bitfld.long 0x00 31.                  "RO    ,Read Only" "0,1"
TEXTLINE "                "
  bitfld.long 0x00 08.--09.           "  ARB   ,Arbitration mode" "Fixed (MPR),Round-robin,res,res"
TEXTLINE "                "
  bitfld.long 0x00 04.--05.           "  PCTL  ,Parking control" "PARK ctrl field,Park on last,Low power park,res"
TEXTLINE "                "
  bitfld.long 0x00 00.--02.           "  PARK  ,Park" "Master Port 0,Master Port 1,Master Port 2,Master Port 3,Master Port 4,Master Port 5,Master Port 6,Master Port 7"

TEXTLINE ""
group.long 0xfff04700++0x03 "Slave Port 7"
  line.long 0x00 "MPR7,Master Priority Register for Slave Port 7"
  bitfld.long 0x00 28.--30.             "MSTR7 ,Master 7 priority" "0 (high),1,2,3,4,5 (low),res.,res."
  bitfld.long 0x00 24.--26.           "  MSTR6 ,Master 6 priority" "0 (high),1,2,3,4,5 (low),res.,res."
  bitfld.long 0x00 20.--22.           "  MSTR5 ,Master 5 priority" "0 (high),1,2,3,4,5 (low),res.,res."
TEXTLINE "                "
  bitfld.long 0x00 16.--18.           "  MSTR4 ,Master 4 priority" "0 (high),1,2,3,4,5 (low),res.,res."
  bitfld.long 0x00 04.--06.           "  MSTR1 ,Master 1 priority" "0 (high),1,2,3,4,5 (low),res.,res."
  bitfld.long 0x00 00.--02.           "  MSTR0 ,Master 0 priority" "0 (high),1,2,3,4,5 (low),res.,res."
TEXTLINE ""

group.long (0xfff04700+0x10)++0x03
  line.long 0x00 "SGPCR7,Slave General Purpose Control Register 7"
  bitfld.long 0x00 31.                  "RO    ,Read Only" "0,1"
TEXTLINE "                "
  bitfld.long 0x00 08.--09.           "  ARB   ,Arbitration mode" "Fixed (MPR),Round-robin,res,res"
TEXTLINE "                "
  bitfld.long 0x00 04.--05.           "  PCTL  ,Parking control" "PARK ctrl field,Park on last,Low power park,res"
TEXTLINE "                "
  bitfld.long 0x00 00.--02.           "  PARK  ,Park" "Master Port 0,Master Port 1,Master Port 2,Master Port 3,Master Port 4,Master Port 5,Master Port 6,Master Port 7"

endif


tree.end
endif

sif CPUIS("MPC5674*")

tree "Memory Protection Unit (MPU)"

group.long (0xFFF10000)++0x03
  line.long    0x00 "CESR,MPU control/error status register"
  eventfld.long  0 31.                      "SPERR0  ,Slave Port 0 Error" "0,1"
  eventfld.long  0 30.                    "  SPERR1  ,Slave Port 1 Error" "0,1"
  eventfld.long  0 29.                    "  SPERR2  ,Slave Port 2 Error" "0,1"
  eventfld.long  0 28.                    "  SPERR3  ,Slave Port 3 Error" "0,1"
TEXTLINE "                "
  eventfld.long  0 27.                    "  SPERR4  ,Slave Port 4 Error" "0,1"
  eventfld.long  0 26.                    "  SPERR5  ,Slave Port 5 Error" "0,1"
  eventfld.long  0 25.                    "  SPERR6  ,Slave Port 6 Error" "0,1"
  eventfld.long  0 24.                    "  SPERR7  ,Slave Port 7 Error" "0,1"
TEXTLINE "                "
  hexmask.long.byte 0 16.--19. 1. 0.       "  HRL    ,Hardware Revision Level"
  hexmask.long.byte 0 12.--15. 1. 0.       "  NSP    ,Number of Slave Ports"
  bitfld.long  0 08.--11.             "  NRGD  ,Number of Region Descriptors" "  8,res, 16,res,res,res,res,res,res,res,res,res,res,res,res,res"
  bitfld.long  0 00.                  "  VLD     ,Enable MPU" "0,1"

TEXTLINE ""

group.long (0xFFF10000+0x0010)++0x03
  line.long    0 "EAR0,MPU Error Address Register, Slave Port 0"

group.long ((0xFFF10000+0x0010)+4)++0x03
  line.long         0 "EDR0,MPU Error Detail Register, Slave Port 0"
  hexmask.long.word      0 16.--31. 1. 0.      "EACD  ,Error Access Control Detail" 
  hexmask.long.byte 0 08.--15. 1. 0.    "  EPID  ,Error Process Identification" 
  hexmask.long.byte 0 04.--07. 1. 0.    "  EMN   ,Error Master Number" 
  bitfld.long       0 02.               "  EA_SU ,Error Attributes" "User,Super"
  bitfld.long       0 01.               "  EA_DI ,Error Attributes" "Instruction,Data"
  bitfld.long       0 00.               "  ERW   ,Error Read/Write" "Read,Write"
TEXTLINE ""
group.long (0xFFF10000+0x0018)++0x03
  line.long    0 "EAR1,MPU Error Address Register, Slave Port 1"

group.long ((0xFFF10000+0x0018)+4)++0x03
  line.long         0 "EDR1,MPU Error Detail Register, Slave Port 1"
  hexmask.long.word      0 16.--31. 1. 0.      "EACD  ,Error Access Control Detail" 
  hexmask.long.byte 0 08.--15. 1. 0.    "  EPID  ,Error Process Identification" 
  hexmask.long.byte 0 04.--07. 1. 0.    "  EMN   ,Error Master Number" 
  bitfld.long       0 02.               "  EA_SU ,Error Attributes" "User,Super"
  bitfld.long       0 01.               "  EA_DI ,Error Attributes" "Instruction,Data"
  bitfld.long       0 00.               "  ERW   ,Error Read/Write" "Read,Write"
TEXTLINE ""
group.long (0xFFF10000+0x0020)++0x03
  line.long    0 "EAR2,MPU Error Address Register, Slave Port 2"

group.long ((0xFFF10000+0x0020)+4)++0x03
  line.long         0 "EDR2,MPU Error Detail Register, Slave Port 2"
  hexmask.long.word      0 16.--31. 1. 0.      "EACD  ,Error Access Control Detail" 
  hexmask.long.byte 0 08.--15. 1. 0.    "  EPID  ,Error Process Identification" 
  hexmask.long.byte 0 04.--07. 1. 0.    "  EMN   ,Error Master Number" 
  bitfld.long       0 02.               "  EA_SU ,Error Attributes" "User,Super"
  bitfld.long       0 01.               "  EA_DI ,Error Attributes" "Instruction,Data"
  bitfld.long       0 00.               "  ERW   ,Error Read/Write" "Read,Write"
TEXTLINE ""
group.long (0xFFF10000+0x0028)++0x03
  line.long    0 "EAR3,MPU Error Address Register, Slave Port 3"

group.long ((0xFFF10000+0x0028)+4)++0x03
  line.long         0 "EDR3,MPU Error Detail Register, Slave Port 3"
  hexmask.long.word      0 16.--31. 1. 0.      "EACD  ,Error Access Control Detail" 
  hexmask.long.byte 0 08.--15. 1. 0.    "  EPID  ,Error Process Identification" 
  hexmask.long.byte 0 04.--07. 1. 0.    "  EMN   ,Error Master Number" 
  bitfld.long       0 02.               "  EA_SU ,Error Attributes" "User,Super"
  bitfld.long       0 01.               "  EA_DI ,Error Attributes" "Instruction,Data"
  bitfld.long       0 00.               "  ERW   ,Error Read/Write" "Read,Write"
TEXTLINE ""

tree "MPU Region Descriptors"


group.long (0xFFF10000+0x400)++0x0F "MPU Region Descriptor 0"
  line.long    00 "SRTADDR,Start Address"
  line.long    04 "ENDADDR,End Address"
TEXTLINE "                "
  line.long    08 "WORD2"
  bitfld.long       8 29.               "M6RE  ,Bus Master ID 6 Read Enable" "0,1"
  bitfld.long       8 28.               "  M6WE  ,Bus Master ID 6 Write Enable" "0,1"
TEXTLINE "                "
  bitfld.long       8 27.               "  M5RE  ,Bus Master ID 5 Read Enable" "0,1"
  bitfld.long       8 26.               "  M5WE  ,Bus Master ID 5 Write Enable" "0,1"
TEXTLINE "                "
  bitfld.long       8 25.               "  M4RE  ,Bus Master ID 4 Read Enable" "0,1"
  bitfld.long       8 24.               "  M4WE  ,Bus Master ID 4 Write Enable" "0,1"
TEXTLINE "                "
  bitfld.long       8 05.               "  M0PE  ,PID enable" "0,1"
  bitfld.long       8 03.--04.           "  M0SM  ,Bus Master ID 0 Supervisor Mode Access Control." "rwx,r-x,rw-,M0UM"
  bitfld.long       8 02.               "  M0UM  ,M0UM_r" "-,r"
  bitfld.long       8 01.               ",M0UM_w" "-,w"
  bitfld.long       8 00.               ",M0UM_x" "-,x"
TEXTLINE "                "
  line.long    0C "WORD3"  
  hexmask.long.byte     0c 24.--31. 1. 0.      "PID  ,Process Identifier" 
  hexmask.long.byte     0c 16.--23. 1. 0.    "  PIDMASK  ,Process Identifier" 
  bitfld.long           0c 00.               "  VLD  ,This bit signals the region descriptor is valid" "0,1"
TEXTLINE "                "

group.long (0xFFF10000+0x410)++0x0F "MPU Region Descriptor 1"
  line.long    00 "SRTADDR,Start Address"
  line.long    04 "ENDADDR,End Address"
TEXTLINE "                "
  line.long    08 "WORD2"
  bitfld.long       8 29.               "M6RE  ,Bus Master ID 6 Read Enable" "0,1"
  bitfld.long       8 28.               "  M6WE  ,Bus Master ID 6 Write Enable" "0,1"
TEXTLINE "                "
  bitfld.long       8 27.               "  M5RE  ,Bus Master ID 5 Read Enable" "0,1"
  bitfld.long       8 26.               "  M5WE  ,Bus Master ID 5 Write Enable" "0,1"
TEXTLINE "                "
  bitfld.long       8 25.               "  M4RE  ,Bus Master ID 4 Read Enable" "0,1"
  bitfld.long       8 24.               "  M4WE  ,Bus Master ID 4 Write Enable" "0,1"
TEXTLINE "                "
  bitfld.long       8 05.               "  M0PE  ,PID enable" "0,1"
  bitfld.long       8 03.--04.           "  M0SM  ,Bus Master ID 0 Supervisor Mode Access Control." "rwx,r-x,rw-,M0UM"
  bitfld.long       8 02.               "  M0UM  ,M0UM_r" "-,r"
  bitfld.long       8 01.               ",M0UM_w" "-,w"
  bitfld.long       8 00.               ",M0UM_x" "-,x"
TEXTLINE "                "
  line.long    0C "WORD3"  
  hexmask.long.byte     0c 24.--31. 1. 0.      "PID  ,Process Identifier" 
  hexmask.long.byte     0c 16.--23. 1. 0.    "  PIDMASK  ,Process Identifier" 
  bitfld.long           0c 00.               "  VLD  ,This bit signals the region descriptor is valid" "0,1"
TEXTLINE "                "

group.long (0xFFF10000+0x420)++0x0F "MPU Region Descriptor 2"
  line.long    00 "SRTADDR,Start Address"
  line.long    04 "ENDADDR,End Address"
TEXTLINE "                "
  line.long    08 "WORD2"
  bitfld.long       8 29.               "M6RE  ,Bus Master ID 6 Read Enable" "0,1"
  bitfld.long       8 28.               "  M6WE  ,Bus Master ID 6 Write Enable" "0,1"
TEXTLINE "                "
  bitfld.long       8 27.               "  M5RE  ,Bus Master ID 5 Read Enable" "0,1"
  bitfld.long       8 26.               "  M5WE  ,Bus Master ID 5 Write Enable" "0,1"
TEXTLINE "                "
  bitfld.long       8 25.               "  M4RE  ,Bus Master ID 4 Read Enable" "0,1"
  bitfld.long       8 24.               "  M4WE  ,Bus Master ID 4 Write Enable" "0,1"
TEXTLINE "                "
  bitfld.long       8 05.               "  M0PE  ,PID enable" "0,1"
  bitfld.long       8 03.--04.           "  M0SM  ,Bus Master ID 0 Supervisor Mode Access Control." "rwx,r-x,rw-,M0UM"
  bitfld.long       8 02.               "  M0UM  ,M0UM_r" "-,r"
  bitfld.long       8 01.               ",M0UM_w" "-,w"
  bitfld.long       8 00.               ",M0UM_x" "-,x"
TEXTLINE "                "
  line.long    0C "WORD3"  
  hexmask.long.byte     0c 24.--31. 1. 0.      "PID  ,Process Identifier" 
  hexmask.long.byte     0c 16.--23. 1. 0.    "  PIDMASK  ,Process Identifier" 
  bitfld.long           0c 00.               "  VLD  ,This bit signals the region descriptor is valid" "0,1"
TEXTLINE "                "

group.long (0xFFF10000+0x430)++0x0F "MPU Region Descriptor 3"
  line.long    00 "SRTADDR,Start Address"
  line.long    04 "ENDADDR,End Address"
TEXTLINE "                "
  line.long    08 "WORD2"
  bitfld.long       8 29.               "M6RE  ,Bus Master ID 6 Read Enable" "0,1"
  bitfld.long       8 28.               "  M6WE  ,Bus Master ID 6 Write Enable" "0,1"
TEXTLINE "                "
  bitfld.long       8 27.               "  M5RE  ,Bus Master ID 5 Read Enable" "0,1"
  bitfld.long       8 26.               "  M5WE  ,Bus Master ID 5 Write Enable" "0,1"
TEXTLINE "                "
  bitfld.long       8 25.               "  M4RE  ,Bus Master ID 4 Read Enable" "0,1"
  bitfld.long       8 24.               "  M4WE  ,Bus Master ID 4 Write Enable" "0,1"
TEXTLINE "                "
  bitfld.long       8 05.               "  M0PE  ,PID enable" "0,1"
  bitfld.long       8 03.--04.           "  M0SM  ,Bus Master ID 0 Supervisor Mode Access Control." "rwx,r-x,rw-,M0UM"
  bitfld.long       8 02.               "  M0UM  ,M0UM_r" "-,r"
  bitfld.long       8 01.               ",M0UM_w" "-,w"
  bitfld.long       8 00.               ",M0UM_x" "-,x"
TEXTLINE "                "
  line.long    0C "WORD3"  
  hexmask.long.byte     0c 24.--31. 1. 0.      "PID  ,Process Identifier" 
  hexmask.long.byte     0c 16.--23. 1. 0.    "  PIDMASK  ,Process Identifier" 
  bitfld.long           0c 00.               "  VLD  ,This bit signals the region descriptor is valid" "0,1"
TEXTLINE "                "

group.long (0xFFF10000+0x440)++0x0F "MPU Region Descriptor 4"
  line.long    00 "SRTADDR,Start Address"
  line.long    04 "ENDADDR,End Address"
TEXTLINE "                "
  line.long    08 "WORD2"
  bitfld.long       8 29.               "M6RE  ,Bus Master ID 6 Read Enable" "0,1"
  bitfld.long       8 28.               "  M6WE  ,Bus Master ID 6 Write Enable" "0,1"
TEXTLINE "                "
  bitfld.long       8 27.               "  M5RE  ,Bus Master ID 5 Read Enable" "0,1"
  bitfld.long       8 26.               "  M5WE  ,Bus Master ID 5 Write Enable" "0,1"
TEXTLINE "                "
  bitfld.long       8 25.               "  M4RE  ,Bus Master ID 4 Read Enable" "0,1"
  bitfld.long       8 24.               "  M4WE  ,Bus Master ID 4 Write Enable" "0,1"
TEXTLINE "                "
  bitfld.long       8 05.               "  M0PE  ,PID enable" "0,1"
  bitfld.long       8 03.--04.           "  M0SM  ,Bus Master ID 0 Supervisor Mode Access Control." "rwx,r-x,rw-,M0UM"
  bitfld.long       8 02.               "  M0UM  ,M0UM_r" "-,r"
  bitfld.long       8 01.               ",M0UM_w" "-,w"
  bitfld.long       8 00.               ",M0UM_x" "-,x"
TEXTLINE "                "
  line.long    0C "WORD3"  
  hexmask.long.byte     0c 24.--31. 1. 0.      "PID  ,Process Identifier" 
  hexmask.long.byte     0c 16.--23. 1. 0.    "  PIDMASK  ,Process Identifier" 
  bitfld.long           0c 00.               "  VLD  ,This bit signals the region descriptor is valid" "0,1"
TEXTLINE "                "

group.long (0xFFF10000+0x450)++0x0F "MPU Region Descriptor 5"
  line.long    00 "SRTADDR,Start Address"
  line.long    04 "ENDADDR,End Address"
TEXTLINE "                "
  line.long    08 "WORD2"
  bitfld.long       8 29.               "M6RE  ,Bus Master ID 6 Read Enable" "0,1"
  bitfld.long       8 28.               "  M6WE  ,Bus Master ID 6 Write Enable" "0,1"
TEXTLINE "                "
  bitfld.long       8 27.               "  M5RE  ,Bus Master ID 5 Read Enable" "0,1"
  bitfld.long       8 26.               "  M5WE  ,Bus Master ID 5 Write Enable" "0,1"
TEXTLINE "                "
  bitfld.long       8 25.               "  M4RE  ,Bus Master ID 4 Read Enable" "0,1"
  bitfld.long       8 24.               "  M4WE  ,Bus Master ID 4 Write Enable" "0,1"
TEXTLINE "                "
  bitfld.long       8 05.               "  M0PE  ,PID enable" "0,1"
  bitfld.long       8 03.--04.           "  M0SM  ,Bus Master ID 0 Supervisor Mode Access Control." "rwx,r-x,rw-,M0UM"
  bitfld.long       8 02.               "  M0UM  ,M0UM_r" "-,r"
  bitfld.long       8 01.               ",M0UM_w" "-,w"
  bitfld.long       8 00.               ",M0UM_x" "-,x"
TEXTLINE "                "
  line.long    0C "WORD3"  
  hexmask.long.byte     0c 24.--31. 1. 0.      "PID  ,Process Identifier" 
  hexmask.long.byte     0c 16.--23. 1. 0.    "  PIDMASK  ,Process Identifier" 
  bitfld.long           0c 00.               "  VLD  ,This bit signals the region descriptor is valid" "0,1"
TEXTLINE "                "

group.long (0xFFF10000+0x460)++0x0F "MPU Region Descriptor 6"
  line.long    00 "SRTADDR,Start Address"
  line.long    04 "ENDADDR,End Address"
TEXTLINE "                "
  line.long    08 "WORD2"
  bitfld.long       8 29.               "M6RE  ,Bus Master ID 6 Read Enable" "0,1"
  bitfld.long       8 28.               "  M6WE  ,Bus Master ID 6 Write Enable" "0,1"
TEXTLINE "                "
  bitfld.long       8 27.               "  M5RE  ,Bus Master ID 5 Read Enable" "0,1"
  bitfld.long       8 26.               "  M5WE  ,Bus Master ID 5 Write Enable" "0,1"
TEXTLINE "                "
  bitfld.long       8 25.               "  M4RE  ,Bus Master ID 4 Read Enable" "0,1"
  bitfld.long       8 24.               "  M4WE  ,Bus Master ID 4 Write Enable" "0,1"
TEXTLINE "                "
  bitfld.long       8 05.               "  M0PE  ,PID enable" "0,1"
  bitfld.long       8 03.--04.           "  M0SM  ,Bus Master ID 0 Supervisor Mode Access Control." "rwx,r-x,rw-,M0UM"
  bitfld.long       8 02.               "  M0UM  ,M0UM_r" "-,r"
  bitfld.long       8 01.               ",M0UM_w" "-,w"
  bitfld.long       8 00.               ",M0UM_x" "-,x"
TEXTLINE "                "
  line.long    0C "WORD3"  
  hexmask.long.byte     0c 24.--31. 1. 0.      "PID  ,Process Identifier" 
  hexmask.long.byte     0c 16.--23. 1. 0.    "  PIDMASK  ,Process Identifier" 
  bitfld.long           0c 00.               "  VLD  ,This bit signals the region descriptor is valid" "0,1"
TEXTLINE "                "

group.long (0xFFF10000+0x470)++0x0F "MPU Region Descriptor 7"
  line.long    00 "SRTADDR,Start Address"
  line.long    04 "ENDADDR,End Address"
TEXTLINE "                "
  line.long    08 "WORD2"
  bitfld.long       8 29.               "M6RE  ,Bus Master ID 6 Read Enable" "0,1"
  bitfld.long       8 28.               "  M6WE  ,Bus Master ID 6 Write Enable" "0,1"
TEXTLINE "                "
  bitfld.long       8 27.               "  M5RE  ,Bus Master ID 5 Read Enable" "0,1"
  bitfld.long       8 26.               "  M5WE  ,Bus Master ID 5 Write Enable" "0,1"
TEXTLINE "                "
  bitfld.long       8 25.               "  M4RE  ,Bus Master ID 4 Read Enable" "0,1"
  bitfld.long       8 24.               "  M4WE  ,Bus Master ID 4 Write Enable" "0,1"
TEXTLINE "                "
  bitfld.long       8 05.               "  M0PE  ,PID enable" "0,1"
  bitfld.long       8 03.--04.           "  M0SM  ,Bus Master ID 0 Supervisor Mode Access Control." "rwx,r-x,rw-,M0UM"
  bitfld.long       8 02.               "  M0UM  ,M0UM_r" "-,r"
  bitfld.long       8 01.               ",M0UM_w" "-,w"
  bitfld.long       8 00.               ",M0UM_x" "-,x"
TEXTLINE "                "
  line.long    0C "WORD3"  
  hexmask.long.byte     0c 24.--31. 1. 0.      "PID  ,Process Identifier" 
  hexmask.long.byte     0c 16.--23. 1. 0.    "  PIDMASK  ,Process Identifier" 
  bitfld.long           0c 00.               "  VLD  ,This bit signals the region descriptor is valid" "0,1"
TEXTLINE "                "

group.long (0xFFF10000+0x480)++0x0F "MPU Region Descriptor 8"
  line.long    00 "SRTADDR,Start Address"
  line.long    04 "ENDADDR,End Address"
TEXTLINE "                "
  line.long    08 "WORD2"
  bitfld.long       8 29.               "M6RE  ,Bus Master ID 6 Read Enable" "0,1"
  bitfld.long       8 28.               "  M6WE  ,Bus Master ID 6 Write Enable" "0,1"
TEXTLINE "                "
  bitfld.long       8 27.               "  M5RE  ,Bus Master ID 5 Read Enable" "0,1"
  bitfld.long       8 26.               "  M5WE  ,Bus Master ID 5 Write Enable" "0,1"
TEXTLINE "                "
  bitfld.long       8 25.               "  M4RE  ,Bus Master ID 4 Read Enable" "0,1"
  bitfld.long       8 24.               "  M4WE  ,Bus Master ID 4 Write Enable" "0,1"
TEXTLINE "                "
  bitfld.long       8 05.               "  M0PE  ,PID enable" "0,1"
  bitfld.long       8 03.--04.           "  M0SM  ,Bus Master ID 0 Supervisor Mode Access Control." "rwx,r-x,rw-,M0UM"
  bitfld.long       8 02.               "  M0UM  ,M0UM_r" "-,r"
  bitfld.long       8 01.               ",M0UM_w" "-,w"
  bitfld.long       8 00.               ",M0UM_x" "-,x"
TEXTLINE "                "
  line.long    0C "WORD3"  
  hexmask.long.byte     0c 24.--31. 1. 0.      "PID  ,Process Identifier" 
  hexmask.long.byte     0c 16.--23. 1. 0.    "  PIDMASK  ,Process Identifier" 
  bitfld.long           0c 00.               "  VLD  ,This bit signals the region descriptor is valid" "0,1"
TEXTLINE "                "

group.long (0xFFF10000+0x490)++0x0F "MPU Region Descriptor 9"
  line.long    00 "SRTADDR,Start Address"
  line.long    04 "ENDADDR,End Address"
TEXTLINE "                "
  line.long    08 "WORD2"
  bitfld.long       8 29.               "M6RE  ,Bus Master ID 6 Read Enable" "0,1"
  bitfld.long       8 28.               "  M6WE  ,Bus Master ID 6 Write Enable" "0,1"
TEXTLINE "                "
  bitfld.long       8 27.               "  M5RE  ,Bus Master ID 5 Read Enable" "0,1"
  bitfld.long       8 26.               "  M5WE  ,Bus Master ID 5 Write Enable" "0,1"
TEXTLINE "                "
  bitfld.long       8 25.               "  M4RE  ,Bus Master ID 4 Read Enable" "0,1"
  bitfld.long       8 24.               "  M4WE  ,Bus Master ID 4 Write Enable" "0,1"
TEXTLINE "                "
  bitfld.long       8 05.               "  M0PE  ,PID enable" "0,1"
  bitfld.long       8 03.--04.           "  M0SM  ,Bus Master ID 0 Supervisor Mode Access Control." "rwx,r-x,rw-,M0UM"
  bitfld.long       8 02.               "  M0UM  ,M0UM_r" "-,r"
  bitfld.long       8 01.               ",M0UM_w" "-,w"
  bitfld.long       8 00.               ",M0UM_x" "-,x"
TEXTLINE "                "
  line.long    0C "WORD3"  
  hexmask.long.byte     0c 24.--31. 1. 0.      "PID  ,Process Identifier" 
  hexmask.long.byte     0c 16.--23. 1. 0.    "  PIDMASK  ,Process Identifier" 
  bitfld.long           0c 00.               "  VLD  ,This bit signals the region descriptor is valid" "0,1"
TEXTLINE "                "

group.long (0xFFF10000+0x4A0)++0x0F "MPU Region Descriptor 10"
  line.long    00 "SRTADDR,Start Address"
  line.long    04 "ENDADDR,End Address"
TEXTLINE "                "
  line.long    08 "WORD2"
  bitfld.long       8 29.               "M6RE  ,Bus Master ID 6 Read Enable" "0,1"
  bitfld.long       8 28.               "  M6WE  ,Bus Master ID 6 Write Enable" "0,1"
TEXTLINE "                "
  bitfld.long       8 27.               "  M5RE  ,Bus Master ID 5 Read Enable" "0,1"
  bitfld.long       8 26.               "  M5WE  ,Bus Master ID 5 Write Enable" "0,1"
TEXTLINE "                "
  bitfld.long       8 25.               "  M4RE  ,Bus Master ID 4 Read Enable" "0,1"
  bitfld.long       8 24.               "  M4WE  ,Bus Master ID 4 Write Enable" "0,1"
TEXTLINE "                "
  bitfld.long       8 05.               "  M0PE  ,PID enable" "0,1"
  bitfld.long       8 03.--04.           "  M0SM  ,Bus Master ID 0 Supervisor Mode Access Control." "rwx,r-x,rw-,M0UM"
  bitfld.long       8 02.               "  M0UM  ,M0UM_r" "-,r"
  bitfld.long       8 01.               ",M0UM_w" "-,w"
  bitfld.long       8 00.               ",M0UM_x" "-,x"
TEXTLINE "                "
  line.long    0C "WORD3"  
  hexmask.long.byte     0c 24.--31. 1. 0.      "PID  ,Process Identifier" 
  hexmask.long.byte     0c 16.--23. 1. 0.    "  PIDMASK  ,Process Identifier" 
  bitfld.long           0c 00.               "  VLD  ,This bit signals the region descriptor is valid" "0,1"
TEXTLINE "                "

group.long (0xFFF10000+0x4B0)++0x0F "MPU Region Descriptor 11"
  line.long    00 "SRTADDR,Start Address"
  line.long    04 "ENDADDR,End Address"
TEXTLINE "                "
  line.long    08 "WORD2"
  bitfld.long       8 29.               "M6RE  ,Bus Master ID 6 Read Enable" "0,1"
  bitfld.long       8 28.               "  M6WE  ,Bus Master ID 6 Write Enable" "0,1"
TEXTLINE "                "
  bitfld.long       8 27.               "  M5RE  ,Bus Master ID 5 Read Enable" "0,1"
  bitfld.long       8 26.               "  M5WE  ,Bus Master ID 5 Write Enable" "0,1"
TEXTLINE "                "
  bitfld.long       8 25.               "  M4RE  ,Bus Master ID 4 Read Enable" "0,1"
  bitfld.long       8 24.               "  M4WE  ,Bus Master ID 4 Write Enable" "0,1"
TEXTLINE "                "
  bitfld.long       8 05.               "  M0PE  ,PID enable" "0,1"
  bitfld.long       8 03.--04.           "  M0SM  ,Bus Master ID 0 Supervisor Mode Access Control." "rwx,r-x,rw-,M0UM"
  bitfld.long       8 02.               "  M0UM  ,M0UM_r" "-,r"
  bitfld.long       8 01.               ",M0UM_w" "-,w"
  bitfld.long       8 00.               ",M0UM_x" "-,x"
TEXTLINE "                "
  line.long    0C "WORD3"  
  hexmask.long.byte     0c 24.--31. 1. 0.      "PID  ,Process Identifier" 
  hexmask.long.byte     0c 16.--23. 1. 0.    "  PIDMASK  ,Process Identifier" 
  bitfld.long           0c 00.               "  VLD  ,This bit signals the region descriptor is valid" "0,1"
TEXTLINE "                "

group.long (0xFFF10000+0x4C0)++0x0F "MPU Region Descriptor 12"
  line.long    00 "SRTADDR,Start Address"
  line.long    04 "ENDADDR,End Address"
TEXTLINE "                "
  line.long    08 "WORD2"
  bitfld.long       8 29.               "M6RE  ,Bus Master ID 6 Read Enable" "0,1"
  bitfld.long       8 28.               "  M6WE  ,Bus Master ID 6 Write Enable" "0,1"
TEXTLINE "                "
  bitfld.long       8 27.               "  M5RE  ,Bus Master ID 5 Read Enable" "0,1"
  bitfld.long       8 26.               "  M5WE  ,Bus Master ID 5 Write Enable" "0,1"
TEXTLINE "                "
  bitfld.long       8 25.               "  M4RE  ,Bus Master ID 4 Read Enable" "0,1"
  bitfld.long       8 24.               "  M4WE  ,Bus Master ID 4 Write Enable" "0,1"
TEXTLINE "                "
  bitfld.long       8 05.               "  M0PE  ,PID enable" "0,1"
  bitfld.long       8 03.--04.           "  M0SM  ,Bus Master ID 0 Supervisor Mode Access Control." "rwx,r-x,rw-,M0UM"
  bitfld.long       8 02.               "  M0UM  ,M0UM_r" "-,r"
  bitfld.long       8 01.               ",M0UM_w" "-,w"
  bitfld.long       8 00.               ",M0UM_x" "-,x"
TEXTLINE "                "
  line.long    0C "WORD3"  
  hexmask.long.byte     0c 24.--31. 1. 0.      "PID  ,Process Identifier" 
  hexmask.long.byte     0c 16.--23. 1. 0.    "  PIDMASK  ,Process Identifier" 
  bitfld.long           0c 00.               "  VLD  ,This bit signals the region descriptor is valid" "0,1"
TEXTLINE "                "

group.long (0xFFF10000+0x4D0)++0x0F "MPU Region Descriptor 13"
  line.long    00 "SRTADDR,Start Address"
  line.long    04 "ENDADDR,End Address"
TEXTLINE "                "
  line.long    08 "WORD2"
  bitfld.long       8 29.               "M6RE  ,Bus Master ID 6 Read Enable" "0,1"
  bitfld.long       8 28.               "  M6WE  ,Bus Master ID 6 Write Enable" "0,1"
TEXTLINE "                "
  bitfld.long       8 27.               "  M5RE  ,Bus Master ID 5 Read Enable" "0,1"
  bitfld.long       8 26.               "  M5WE  ,Bus Master ID 5 Write Enable" "0,1"
TEXTLINE "                "
  bitfld.long       8 25.               "  M4RE  ,Bus Master ID 4 Read Enable" "0,1"
  bitfld.long       8 24.               "  M4WE  ,Bus Master ID 4 Write Enable" "0,1"
TEXTLINE "                "
  bitfld.long       8 05.               "  M0PE  ,PID enable" "0,1"
  bitfld.long       8 03.--04.           "  M0SM  ,Bus Master ID 0 Supervisor Mode Access Control." "rwx,r-x,rw-,M0UM"
  bitfld.long       8 02.               "  M0UM  ,M0UM_r" "-,r"
  bitfld.long       8 01.               ",M0UM_w" "-,w"
  bitfld.long       8 00.               ",M0UM_x" "-,x"
TEXTLINE "                "
  line.long    0C "WORD3"  
  hexmask.long.byte     0c 24.--31. 1. 0.      "PID  ,Process Identifier" 
  hexmask.long.byte     0c 16.--23. 1. 0.    "  PIDMASK  ,Process Identifier" 
  bitfld.long           0c 00.               "  VLD  ,This bit signals the region descriptor is valid" "0,1"
TEXTLINE "                "

group.long (0xFFF10000+0x4E0)++0x0F "MPU Region Descriptor 14"
  line.long    00 "SRTADDR,Start Address"
  line.long    04 "ENDADDR,End Address"
TEXTLINE "                "
  line.long    08 "WORD2"
  bitfld.long       8 29.               "M6RE  ,Bus Master ID 6 Read Enable" "0,1"
  bitfld.long       8 28.               "  M6WE  ,Bus Master ID 6 Write Enable" "0,1"
TEXTLINE "                "
  bitfld.long       8 27.               "  M5RE  ,Bus Master ID 5 Read Enable" "0,1"
  bitfld.long       8 26.               "  M5WE  ,Bus Master ID 5 Write Enable" "0,1"
TEXTLINE "                "
  bitfld.long       8 25.               "  M4RE  ,Bus Master ID 4 Read Enable" "0,1"
  bitfld.long       8 24.               "  M4WE  ,Bus Master ID 4 Write Enable" "0,1"
TEXTLINE "                "
  bitfld.long       8 05.               "  M0PE  ,PID enable" "0,1"
  bitfld.long       8 03.--04.           "  M0SM  ,Bus Master ID 0 Supervisor Mode Access Control." "rwx,r-x,rw-,M0UM"
  bitfld.long       8 02.               "  M0UM  ,M0UM_r" "-,r"
  bitfld.long       8 01.               ",M0UM_w" "-,w"
  bitfld.long       8 00.               ",M0UM_x" "-,x"
TEXTLINE "                "
  line.long    0C "WORD3"  
  hexmask.long.byte     0c 24.--31. 1. 0.      "PID  ,Process Identifier" 
  hexmask.long.byte     0c 16.--23. 1. 0.    "  PIDMASK  ,Process Identifier" 
  bitfld.long           0c 00.               "  VLD  ,This bit signals the region descriptor is valid" "0,1"
TEXTLINE "                "

group.long (0xFFF10000+0x4F0)++0x0F "MPU Region Descriptor 15"
  line.long    00 "SRTADDR,Start Address"
  line.long    04 "ENDADDR,End Address"
TEXTLINE "                "
  line.long    08 "WORD2"
  bitfld.long       8 29.               "M6RE  ,Bus Master ID 6 Read Enable" "0,1"
  bitfld.long       8 28.               "  M6WE  ,Bus Master ID 6 Write Enable" "0,1"
TEXTLINE "                "
  bitfld.long       8 27.               "  M5RE  ,Bus Master ID 5 Read Enable" "0,1"
  bitfld.long       8 26.               "  M5WE  ,Bus Master ID 5 Write Enable" "0,1"
TEXTLINE "                "
  bitfld.long       8 25.               "  M4RE  ,Bus Master ID 4 Read Enable" "0,1"
  bitfld.long       8 24.               "  M4WE  ,Bus Master ID 4 Write Enable" "0,1"
TEXTLINE "                "
  bitfld.long       8 05.               "  M0PE  ,PID enable" "0,1"
  bitfld.long       8 03.--04.           "  M0SM  ,Bus Master ID 0 Supervisor Mode Access Control." "rwx,r-x,rw-,M0UM"
  bitfld.long       8 02.               "  M0UM  ,M0UM_r" "-,r"
  bitfld.long       8 01.               ",M0UM_w" "-,w"
  bitfld.long       8 00.               ",M0UM_x" "-,x"
TEXTLINE "                "
  line.long    0C "WORD3"  
  hexmask.long.byte     0c 24.--31. 1. 0.      "PID  ,Process Identifier" 
  hexmask.long.byte     0c 16.--23. 1. 0.    "  PIDMASK  ,Process Identifier" 
  bitfld.long           0c 00.               "  VLD  ,This bit signals the region descriptor is valid" "0,1"
TEXTLINE "                "

tree.end

tree "MPU Alternate Access Control"

group.long (0xFFF10000+0x800)++0x03 
  line.long    0 "RGDAAC0,MPU RGD Alternate Access Control 0"
  bitfld.long       0 29.               "M6RE  ,Bus Master ID 6 Read Enable" "0,1"
  bitfld.long       0 28.               "  M6WE  ,Bus Master ID 6 Write Enable" "0,1"
TEXTLINE "                "
  bitfld.long       0 27.               "  M5RE  ,Bus Master ID 5 Read Enable" "0,1"
  bitfld.long       0 26.               "  M5WE  ,Bus Master ID 5 Write Enable" "0,1"
TEXTLINE "                "
  bitfld.long       0 25.               "  M4RE  ,Bus Master ID 4 Read Enable" "0,1"
  bitfld.long       0 24.               "  M4WE  ,Bus Master ID 4 Write Enable" "0,1"
TEXTLINE "                "
  bitfld.long       0 05.               "  M0PE  ,PID enable" "0,1"
  bitfld.long       0 03.--04.           "  M0SM  ,Bus Master ID 0 Supervisor Mode Access Control." "rwx,r-x,rw-,M0UM"
  bitfld.long       0 02.               "  M0UM  ,M0UM_r" "-,r"
  bitfld.long       0 01.               ",M0UM_w" "-,w"
  bitfld.long       0 00.               ",M0UM_x" "-,x"
TEXTLINE "                "
group.long (0xFFF10000+0x804)++0x03 
  line.long    0 "RGDAAC1,MPU RGD Alternate Access Control 1"
  bitfld.long       0 29.               "M6RE  ,Bus Master ID 6 Read Enable" "0,1"
  bitfld.long       0 28.               "  M6WE  ,Bus Master ID 6 Write Enable" "0,1"
TEXTLINE "                "
  bitfld.long       0 27.               "  M5RE  ,Bus Master ID 5 Read Enable" "0,1"
  bitfld.long       0 26.               "  M5WE  ,Bus Master ID 5 Write Enable" "0,1"
TEXTLINE "                "
  bitfld.long       0 25.               "  M4RE  ,Bus Master ID 4 Read Enable" "0,1"
  bitfld.long       0 24.               "  M4WE  ,Bus Master ID 4 Write Enable" "0,1"
TEXTLINE "                "
  bitfld.long       0 05.               "  M0PE  ,PID enable" "0,1"
  bitfld.long       0 03.--04.           "  M0SM  ,Bus Master ID 0 Supervisor Mode Access Control." "rwx,r-x,rw-,M0UM"
  bitfld.long       0 02.               "  M0UM  ,M0UM_r" "-,r"
  bitfld.long       0 01.               ",M0UM_w" "-,w"
  bitfld.long       0 00.               ",M0UM_x" "-,x"
TEXTLINE "                "
group.long (0xFFF10000+0x808)++0x03 
  line.long    0 "RGDAAC2,MPU RGD Alternate Access Control 2"
  bitfld.long       0 29.               "M6RE  ,Bus Master ID 6 Read Enable" "0,1"
  bitfld.long       0 28.               "  M6WE  ,Bus Master ID 6 Write Enable" "0,1"
TEXTLINE "                "
  bitfld.long       0 27.               "  M5RE  ,Bus Master ID 5 Read Enable" "0,1"
  bitfld.long       0 26.               "  M5WE  ,Bus Master ID 5 Write Enable" "0,1"
TEXTLINE "                "
  bitfld.long       0 25.               "  M4RE  ,Bus Master ID 4 Read Enable" "0,1"
  bitfld.long       0 24.               "  M4WE  ,Bus Master ID 4 Write Enable" "0,1"
TEXTLINE "                "
  bitfld.long       0 05.               "  M0PE  ,PID enable" "0,1"
  bitfld.long       0 03.--04.           "  M0SM  ,Bus Master ID 0 Supervisor Mode Access Control." "rwx,r-x,rw-,M0UM"
  bitfld.long       0 02.               "  M0UM  ,M0UM_r" "-,r"
  bitfld.long       0 01.               ",M0UM_w" "-,w"
  bitfld.long       0 00.               ",M0UM_x" "-,x"
TEXTLINE "                "
group.long (0xFFF10000+0x80C)++0x03 
  line.long    0 "RGDAAC3,MPU RGD Alternate Access Control 3"
  bitfld.long       0 29.               "M6RE  ,Bus Master ID 6 Read Enable" "0,1"
  bitfld.long       0 28.               "  M6WE  ,Bus Master ID 6 Write Enable" "0,1"
TEXTLINE "                "
  bitfld.long       0 27.               "  M5RE  ,Bus Master ID 5 Read Enable" "0,1"
  bitfld.long       0 26.               "  M5WE  ,Bus Master ID 5 Write Enable" "0,1"
TEXTLINE "                "
  bitfld.long       0 25.               "  M4RE  ,Bus Master ID 4 Read Enable" "0,1"
  bitfld.long       0 24.               "  M4WE  ,Bus Master ID 4 Write Enable" "0,1"
TEXTLINE "                "
  bitfld.long       0 05.               "  M0PE  ,PID enable" "0,1"
  bitfld.long       0 03.--04.           "  M0SM  ,Bus Master ID 0 Supervisor Mode Access Control." "rwx,r-x,rw-,M0UM"
  bitfld.long       0 02.               "  M0UM  ,M0UM_r" "-,r"
  bitfld.long       0 01.               ",M0UM_w" "-,w"
  bitfld.long       0 00.               ",M0UM_x" "-,x"
TEXTLINE "                "
group.long (0xFFF10000+0x810)++0x03 
  line.long    0 "RGDAAC4,MPU RGD Alternate Access Control 4"
  bitfld.long       0 29.               "M6RE  ,Bus Master ID 6 Read Enable" "0,1"
  bitfld.long       0 28.               "  M6WE  ,Bus Master ID 6 Write Enable" "0,1"
TEXTLINE "                "
  bitfld.long       0 27.               "  M5RE  ,Bus Master ID 5 Read Enable" "0,1"
  bitfld.long       0 26.               "  M5WE  ,Bus Master ID 5 Write Enable" "0,1"
TEXTLINE "                "
  bitfld.long       0 25.               "  M4RE  ,Bus Master ID 4 Read Enable" "0,1"
  bitfld.long       0 24.               "  M4WE  ,Bus Master ID 4 Write Enable" "0,1"
TEXTLINE "                "
  bitfld.long       0 05.               "  M0PE  ,PID enable" "0,1"
  bitfld.long       0 03.--04.           "  M0SM  ,Bus Master ID 0 Supervisor Mode Access Control." "rwx,r-x,rw-,M0UM"
  bitfld.long       0 02.               "  M0UM  ,M0UM_r" "-,r"
  bitfld.long       0 01.               ",M0UM_w" "-,w"
  bitfld.long       0 00.               ",M0UM_x" "-,x"
TEXTLINE "                "
group.long (0xFFF10000+0x814)++0x03 
  line.long    0 "RGDAAC5,MPU RGD Alternate Access Control 5"
  bitfld.long       0 29.               "M6RE  ,Bus Master ID 6 Read Enable" "0,1"
  bitfld.long       0 28.               "  M6WE  ,Bus Master ID 6 Write Enable" "0,1"
TEXTLINE "                "
  bitfld.long       0 27.               "  M5RE  ,Bus Master ID 5 Read Enable" "0,1"
  bitfld.long       0 26.               "  M5WE  ,Bus Master ID 5 Write Enable" "0,1"
TEXTLINE "                "
  bitfld.long       0 25.               "  M4RE  ,Bus Master ID 4 Read Enable" "0,1"
  bitfld.long       0 24.               "  M4WE  ,Bus Master ID 4 Write Enable" "0,1"
TEXTLINE "                "
  bitfld.long       0 05.               "  M0PE  ,PID enable" "0,1"
  bitfld.long       0 03.--04.           "  M0SM  ,Bus Master ID 0 Supervisor Mode Access Control." "rwx,r-x,rw-,M0UM"
  bitfld.long       0 02.               "  M0UM  ,M0UM_r" "-,r"
  bitfld.long       0 01.               ",M0UM_w" "-,w"
  bitfld.long       0 00.               ",M0UM_x" "-,x"
TEXTLINE "                "
group.long (0xFFF10000+0x818)++0x03 
  line.long    0 "RGDAAC6,MPU RGD Alternate Access Control 6"
  bitfld.long       0 29.               "M6RE  ,Bus Master ID 6 Read Enable" "0,1"
  bitfld.long       0 28.               "  M6WE  ,Bus Master ID 6 Write Enable" "0,1"
TEXTLINE "                "
  bitfld.long       0 27.               "  M5RE  ,Bus Master ID 5 Read Enable" "0,1"
  bitfld.long       0 26.               "  M5WE  ,Bus Master ID 5 Write Enable" "0,1"
TEXTLINE "                "
  bitfld.long       0 25.               "  M4RE  ,Bus Master ID 4 Read Enable" "0,1"
  bitfld.long       0 24.               "  M4WE  ,Bus Master ID 4 Write Enable" "0,1"
TEXTLINE "                "
  bitfld.long       0 05.               "  M0PE  ,PID enable" "0,1"
  bitfld.long       0 03.--04.           "  M0SM  ,Bus Master ID 0 Supervisor Mode Access Control." "rwx,r-x,rw-,M0UM"
  bitfld.long       0 02.               "  M0UM  ,M0UM_r" "-,r"
  bitfld.long       0 01.               ",M0UM_w" "-,w"
  bitfld.long       0 00.               ",M0UM_x" "-,x"
TEXTLINE "                "
group.long (0xFFF10000+0x81C)++0x03 
  line.long    0 "RGDAAC7,MPU RGD Alternate Access Control 7"
  bitfld.long       0 29.               "M6RE  ,Bus Master ID 6 Read Enable" "0,1"
  bitfld.long       0 28.               "  M6WE  ,Bus Master ID 6 Write Enable" "0,1"
TEXTLINE "                "
  bitfld.long       0 27.               "  M5RE  ,Bus Master ID 5 Read Enable" "0,1"
  bitfld.long       0 26.               "  M5WE  ,Bus Master ID 5 Write Enable" "0,1"
TEXTLINE "                "
  bitfld.long       0 25.               "  M4RE  ,Bus Master ID 4 Read Enable" "0,1"
  bitfld.long       0 24.               "  M4WE  ,Bus Master ID 4 Write Enable" "0,1"
TEXTLINE "                "
  bitfld.long       0 05.               "  M0PE  ,PID enable" "0,1"
  bitfld.long       0 03.--04.           "  M0SM  ,Bus Master ID 0 Supervisor Mode Access Control." "rwx,r-x,rw-,M0UM"
  bitfld.long       0 02.               "  M0UM  ,M0UM_r" "-,r"
  bitfld.long       0 01.               ",M0UM_w" "-,w"
  bitfld.long       0 00.               ",M0UM_x" "-,x"
TEXTLINE "                "
group.long (0xFFF10000+0x820)++0x03 
  line.long    0 "RGDAAC8,MPU RGD Alternate Access Control 8"
  bitfld.long       0 29.               "M6RE  ,Bus Master ID 6 Read Enable" "0,1"
  bitfld.long       0 28.               "  M6WE  ,Bus Master ID 6 Write Enable" "0,1"
TEXTLINE "                "
  bitfld.long       0 27.               "  M5RE  ,Bus Master ID 5 Read Enable" "0,1"
  bitfld.long       0 26.               "  M5WE  ,Bus Master ID 5 Write Enable" "0,1"
TEXTLINE "                "
  bitfld.long       0 25.               "  M4RE  ,Bus Master ID 4 Read Enable" "0,1"
  bitfld.long       0 24.               "  M4WE  ,Bus Master ID 4 Write Enable" "0,1"
TEXTLINE "                "
  bitfld.long       0 05.               "  M0PE  ,PID enable" "0,1"
  bitfld.long       0 03.--04.           "  M0SM  ,Bus Master ID 0 Supervisor Mode Access Control." "rwx,r-x,rw-,M0UM"
  bitfld.long       0 02.               "  M0UM  ,M0UM_r" "-,r"
  bitfld.long       0 01.               ",M0UM_w" "-,w"
  bitfld.long       0 00.               ",M0UM_x" "-,x"
TEXTLINE "                "
group.long (0xFFF10000+0x824)++0x03 
  line.long    0 "RGDAAC9,MPU RGD Alternate Access Control 9"
  bitfld.long       0 29.               "M6RE  ,Bus Master ID 6 Read Enable" "0,1"
  bitfld.long       0 28.               "  M6WE  ,Bus Master ID 6 Write Enable" "0,1"
TEXTLINE "                "
  bitfld.long       0 27.               "  M5RE  ,Bus Master ID 5 Read Enable" "0,1"
  bitfld.long       0 26.               "  M5WE  ,Bus Master ID 5 Write Enable" "0,1"
TEXTLINE "                "
  bitfld.long       0 25.               "  M4RE  ,Bus Master ID 4 Read Enable" "0,1"
  bitfld.long       0 24.               "  M4WE  ,Bus Master ID 4 Write Enable" "0,1"
TEXTLINE "                "
  bitfld.long       0 05.               "  M0PE  ,PID enable" "0,1"
  bitfld.long       0 03.--04.           "  M0SM  ,Bus Master ID 0 Supervisor Mode Access Control." "rwx,r-x,rw-,M0UM"
  bitfld.long       0 02.               "  M0UM  ,M0UM_r" "-,r"
  bitfld.long       0 01.               ",M0UM_w" "-,w"
  bitfld.long       0 00.               ",M0UM_x" "-,x"
TEXTLINE "                "
group.long (0xFFF10000+0x828)++0x03 
  line.long    0 "RGDAAC10,MPU RGD Alternate Access Control 10"
  bitfld.long       0 29.               "M6RE  ,Bus Master ID 6 Read Enable" "0,1"
  bitfld.long       0 28.               "  M6WE  ,Bus Master ID 6 Write Enable" "0,1"
TEXTLINE "                "
  bitfld.long       0 27.               "  M5RE  ,Bus Master ID 5 Read Enable" "0,1"
  bitfld.long       0 26.               "  M5WE  ,Bus Master ID 5 Write Enable" "0,1"
TEXTLINE "                "
  bitfld.long       0 25.               "  M4RE  ,Bus Master ID 4 Read Enable" "0,1"
  bitfld.long       0 24.               "  M4WE  ,Bus Master ID 4 Write Enable" "0,1"
TEXTLINE "                "
  bitfld.long       0 05.               "  M0PE  ,PID enable" "0,1"
  bitfld.long       0 03.--04.           "  M0SM  ,Bus Master ID 0 Supervisor Mode Access Control." "rwx,r-x,rw-,M0UM"
  bitfld.long       0 02.               "  M0UM  ,M0UM_r" "-,r"
  bitfld.long       0 01.               ",M0UM_w" "-,w"
  bitfld.long       0 00.               ",M0UM_x" "-,x"
TEXTLINE "                "
group.long (0xFFF10000+0x82C)++0x03 
  line.long    0 "RGDAAC11,MPU RGD Alternate Access Control 11"
  bitfld.long       0 29.               "M6RE  ,Bus Master ID 6 Read Enable" "0,1"
  bitfld.long       0 28.               "  M6WE  ,Bus Master ID 6 Write Enable" "0,1"
TEXTLINE "                "
  bitfld.long       0 27.               "  M5RE  ,Bus Master ID 5 Read Enable" "0,1"
  bitfld.long       0 26.               "  M5WE  ,Bus Master ID 5 Write Enable" "0,1"
TEXTLINE "                "
  bitfld.long       0 25.               "  M4RE  ,Bus Master ID 4 Read Enable" "0,1"
  bitfld.long       0 24.               "  M4WE  ,Bus Master ID 4 Write Enable" "0,1"
TEXTLINE "                "
  bitfld.long       0 05.               "  M0PE  ,PID enable" "0,1"
  bitfld.long       0 03.--04.           "  M0SM  ,Bus Master ID 0 Supervisor Mode Access Control." "rwx,r-x,rw-,M0UM"
  bitfld.long       0 02.               "  M0UM  ,M0UM_r" "-,r"
  bitfld.long       0 01.               ",M0UM_w" "-,w"
  bitfld.long       0 00.               ",M0UM_x" "-,x"
TEXTLINE "                "
group.long (0xFFF10000+0x830)++0x03 
  line.long    0 "RGDAAC12,MPU RGD Alternate Access Control 12"
  bitfld.long       0 29.               "M6RE  ,Bus Master ID 6 Read Enable" "0,1"
  bitfld.long       0 28.               "  M6WE  ,Bus Master ID 6 Write Enable" "0,1"
TEXTLINE "                "
  bitfld.long       0 27.               "  M5RE  ,Bus Master ID 5 Read Enable" "0,1"
  bitfld.long       0 26.               "  M5WE  ,Bus Master ID 5 Write Enable" "0,1"
TEXTLINE "                "
  bitfld.long       0 25.               "  M4RE  ,Bus Master ID 4 Read Enable" "0,1"
  bitfld.long       0 24.               "  M4WE  ,Bus Master ID 4 Write Enable" "0,1"
TEXTLINE "                "
  bitfld.long       0 05.               "  M0PE  ,PID enable" "0,1"
  bitfld.long       0 03.--04.           "  M0SM  ,Bus Master ID 0 Supervisor Mode Access Control." "rwx,r-x,rw-,M0UM"
  bitfld.long       0 02.               "  M0UM  ,M0UM_r" "-,r"
  bitfld.long       0 01.               ",M0UM_w" "-,w"
  bitfld.long       0 00.               ",M0UM_x" "-,x"
TEXTLINE "                "
group.long (0xFFF10000+0x834)++0x03 
  line.long    0 "RGDAAC13,MPU RGD Alternate Access Control 13"
  bitfld.long       0 29.               "M6RE  ,Bus Master ID 6 Read Enable" "0,1"
  bitfld.long       0 28.               "  M6WE  ,Bus Master ID 6 Write Enable" "0,1"
TEXTLINE "                "
  bitfld.long       0 27.               "  M5RE  ,Bus Master ID 5 Read Enable" "0,1"
  bitfld.long       0 26.               "  M5WE  ,Bus Master ID 5 Write Enable" "0,1"
TEXTLINE "                "
  bitfld.long       0 25.               "  M4RE  ,Bus Master ID 4 Read Enable" "0,1"
  bitfld.long       0 24.               "  M4WE  ,Bus Master ID 4 Write Enable" "0,1"
TEXTLINE "                "
  bitfld.long       0 05.               "  M0PE  ,PID enable" "0,1"
  bitfld.long       0 03.--04.           "  M0SM  ,Bus Master ID 0 Supervisor Mode Access Control." "rwx,r-x,rw-,M0UM"
  bitfld.long       0 02.               "  M0UM  ,M0UM_r" "-,r"
  bitfld.long       0 01.               ",M0UM_w" "-,w"
  bitfld.long       0 00.               ",M0UM_x" "-,x"
TEXTLINE "                "
group.long (0xFFF10000+0x838)++0x03 
  line.long    0 "RGDAAC14,MPU RGD Alternate Access Control 14"
  bitfld.long       0 29.               "M6RE  ,Bus Master ID 6 Read Enable" "0,1"
  bitfld.long       0 28.               "  M6WE  ,Bus Master ID 6 Write Enable" "0,1"
TEXTLINE "                "
  bitfld.long       0 27.               "  M5RE  ,Bus Master ID 5 Read Enable" "0,1"
  bitfld.long       0 26.               "  M5WE  ,Bus Master ID 5 Write Enable" "0,1"
TEXTLINE "                "
  bitfld.long       0 25.               "  M4RE  ,Bus Master ID 4 Read Enable" "0,1"
  bitfld.long       0 24.               "  M4WE  ,Bus Master ID 4 Write Enable" "0,1"
TEXTLINE "                "
  bitfld.long       0 05.               "  M0PE  ,PID enable" "0,1"
  bitfld.long       0 03.--04.           "  M0SM  ,Bus Master ID 0 Supervisor Mode Access Control." "rwx,r-x,rw-,M0UM"
  bitfld.long       0 02.               "  M0UM  ,M0UM_r" "-,r"
  bitfld.long       0 01.               ",M0UM_w" "-,w"
  bitfld.long       0 00.               ",M0UM_x" "-,x"
TEXTLINE "                "
group.long (0xFFF10000+0x83C)++0x03 
  line.long    0 "RGDAAC15,MPU RGD Alternate Access Control 15"
  bitfld.long       0 29.               "M6RE  ,Bus Master ID 6 Read Enable" "0,1"
  bitfld.long       0 28.               "  M6WE  ,Bus Master ID 6 Write Enable" "0,1"
TEXTLINE "                "
  bitfld.long       0 27.               "  M5RE  ,Bus Master ID 5 Read Enable" "0,1"
  bitfld.long       0 26.               "  M5WE  ,Bus Master ID 5 Write Enable" "0,1"
TEXTLINE "                "
  bitfld.long       0 25.               "  M4RE  ,Bus Master ID 4 Read Enable" "0,1"
  bitfld.long       0 24.               "  M4WE  ,Bus Master ID 4 Write Enable" "0,1"
TEXTLINE "                "
  bitfld.long       0 05.               "  M0PE  ,PID enable" "0,1"
  bitfld.long       0 03.--04.           "  M0SM  ,Bus Master ID 0 Supervisor Mode Access Control." "rwx,r-x,rw-,M0UM"
  bitfld.long       0 02.               "  M0UM  ,M0UM_r" "-,r"
  bitfld.long       0 01.               ",M0UM_w" "-,w"
  bitfld.long       0 00.               ",M0UM_x" "-,x"
TEXTLINE "                "

tree.end

tree.end

endif


sif (cpu()=="MPC5632M")||(cpu()=="MPC5633M")||(cpu()=="MPC5634M")||(cpu()=="SPC563M54")||(cpu()=="SPC563M60")||(cpu()=="SPC563M64")||(CPUIS("MPC5674*"))
width 12.

tree "System Integration Unit (SIU)"

sif ((cpu()=="MPC5632M")||(cpu()=="MPC5633M")||(cpu()=="MPC5634M")||(cpu()=="SPC563M54")||(cpu()=="SPC563M60")||(cpu()=="SPC563M64"))

group.long 0xC3F90000++0x03
  line.long    0x00 "MIDR2,MCU ID Register 2"
  bitfld.long  0x00 31.                    "SF ,Manufacturer" "FSL,ST"
  bitfld.long  0x00 27.--30.             "  FLASH_SIZE_1 ,Coarse Granularity for Flash memory size" "16K,32K,64K,128K,256K,512K,1M,2M,4M,8M,16M,32M,64M,128M,256M,512M"
  bitfld.long  0x00 23.--26.             "  FLASH_SIZE_2 ,Fine Granularity for Flash memory size" "0/8,1/8,2/8,3/8,4/8,5/8,6/8,7/8,8/8"
TEXTLINE "                   "  
  bitfld.long  0x00 21.--22.             "  TEMP_RANGE ,Temp Range" "T0,T1,T2,T3"
  bitfld.long  0x00 18.--19.             "  MAX_FREQ   ,Define maximum device speed" "F0,F1,F2,F3"
  bitfld.long  0x00 16.                  "  SUPPLY     ,Defines if the part is 5V or 3V" "5V,3V"
TEXTLINE "                   "  
  hexmask.long.byte 0x00 08.--15.  1.    "  PARTNUM    ,ASCII character in MCU Part Number"
  bitfld.long  0x00 04.                  "  EE          ,Data Flash present" "0,1"
  bitfld.long  0x00 00.                  "  FR          ,FlexRay present" "0,1"
TEXTLINE ""  

endif


group.long 0xC3F90004++0x03
  line.long    0x00 "MIDR,MCU ID Register"
  hexmask.long.word 0x00 16.--31.   1.          "PARTNUM ,MCU part number"
  bitfld.long  0x00 15.                       "  CSP ,CSP configuration" "std,VertiCal"
  bitfld.long  0x00 10.--14.                  "  PKG ,Package Settings" "res(0),res(1),res(2),res(3),res(4),res(5),res(6),res(7),res(8),100-pin QFP,res(10),res(11),res(12),144-pin QFP,res(14),res(15),res(16),res(17),res(18),res(19),res(20),res(21),res(22),res(23),res(24),res(25),res(26),res(27),res(28),res(29),res(30),res(31)"
  hexmask.long.byte 0x00 04.--07.   1.        "  MAJOR_MASK ,Major Mask Revision"
  hexmask.long.byte 0x00 00.--03.   1.        "  MINOR_MASK ,Minor Mask Revision"
TEXTLINE ""  

group.long 0xC3F9000C++0x03
  line.long    0x00 "RSR,Reset Status Register"
  bitfld.long  0x00 31.                    "PORS    ,Power-on reset status" "0,1"
  bitfld.long  0x00 30.                  "  ERS     ,External reset status" "0,1"
  bitfld.long  0x00 29.                  "  LLRS    ,Loss of lock reset status" "0,1"
  bitfld.long  0x00 28.                  "  LCRS    ,Loss of clock reset status" "0,1"
TEXTLINE "                   "  
  bitfld.long  0x00 27.                  "  WDRS    ,Watchdog timer/debug reset status" "0,1"
  bitfld.long  0x00 26.                  "  CRS     ,Checkstop reset status" "0,1"
  bitfld.long  0x00 25.                  "  SWTRS   ,Checkstop reset status" "0,1"
  bitfld.long  0x00 17.                  "  SSRS    ,Software system reset status" "0,1"
TEXTLINE "                   "  
  bitfld.long  0x00 16.                  "  SERF    ,Software external reset flag" "0,1"
  bitfld.long  0x00 15.                  "  WKPCFG  ,Weak pull up configuration pin status" "0,1"
  bitfld.long  0x00 03.                  "  ABR     ,Auto Baud Rate" "0,1"
  bitfld.long  0x00 01.--02.             "  BOOTCFG ,Reset configuration pin status" "Int Flash,CAN/SCI,ExMem(no arb),ExMem(ex arb)"
TEXTLINE "                   "  
  bitfld.long  0x00 00.                  "  RGF     ,Reset glitch flag" "0,1"

  
group.long 0xC3F90010++0x03
  line.long    0x00 "SRCR,System Reset Control Register"
  bitfld.long  0x00 31.                    "SSR     ,Software system reset" "0,1"
  bitfld.long  0x00 30.                  "  SER     ,Software external reset" "0,1"
  bitfld.long  0x00 15.                  "  CRE     ,Checkstop reset enable" "0,1"
TEXTLINE ""  

group.long 0xC3F90014++0x03
  line.long    0x00 "EISR,SIU External Interrupt Status Register"
  bitfld.long  0x00 31.                    "NMI_SEL ,NMI Interrupt Platform Input Selection" "0,1"
  bitfld.long  0x00 23.                  "  SWT     ,Software Watch Dog Timer Interrupt Flag" "0,1"
TEXTLINE "                     "  
  bitfld.long  0x00 15.                  "EIF15-12  ,External interrupt request flag 15" "0,1"
  bitfld.long  0x00 14.                  ",External interrupt request flag 14" "0,1"
  bitfld.long  0x00 13.                  ",External interrupt request flag 13" "0,1"
  bitfld.long  0x00 12.                  ",External interrupt request flag 12" "0,1"

  bitfld.long  0x00 11.                  "  EIF11-08  ,External interrupt request flag 11" "0,1"
  bitfld.long  0x00 10.                  ",External interrupt request flag 10" "0,1"
  bitfld.long  0x00 09.                  ",External interrupt request flag 9" "0,1"
  bitfld.long  0x00 08.                  ",External interrupt request flag 8" "0,1"

  bitfld.long  0x00 07.                  "  EIF07-04  ,External interrupt request flag 7" "0,1"
  bitfld.long  0x00 06.                  ",External interrupt request flag 6" "0,1"
  bitfld.long  0x00 05.                  ",External interrupt request flag 5" "0,1"
  bitfld.long  0x00 04.                  ",External interrupt request flag 4" "0,1"

  bitfld.long  0x00 03.                  "  EIF03-00  ,External interrupt request flag 3" "0,1"
  bitfld.long  0x00 02.                  ",External interrupt request flag 2" "0,1"
  bitfld.long  0x00 01.                  ",External interrupt request flag 1" "0,1"
  bitfld.long  0x00 00.                  ",External interrupt request flag 0" "0,1"

group.long 0xC3F90018++0x03
  line.long    0x00 "DIRER,DMA/Interrupt Request Enable Register"
  bitfld.long  0x00 31.                  "NMI_SEL   ,NMI Interrupt Platform Input Selection" "0,1"
TEXTLINE "                     "  
  bitfld.long  0x00 15.                  "EIRE15-12 ,External interrupt request enable 15" "0,1"
  bitfld.long  0x00 14.                  ",External interrupt request enable 14" "0,1"
  bitfld.long  0x00 13.                  ",External interrupt request enable 13" "0,1"
  bitfld.long  0x00 12.                  ",External interrupt request enable 12" "0,1"

  bitfld.long  0x00 11.                  "  EIRE11-08 ,External interrupt request enable 11" "0,1"
  bitfld.long  0x00 10.                  ",External interrupt request enable 10" "0,1"
  bitfld.long  0x00 09.                  ",External interrupt request enable 9" "0,1"
  bitfld.long  0x00 08.                  ",External interrupt request enable 8" "0,1"

  bitfld.long  0x00 07.                  "  EIRE07-04 ,External interrupt request enable 7" "0,1"
  bitfld.long  0x00 06.                  ",External interrupt request enable 6" "0,1"
  bitfld.long  0x00 05.                  ",External interrupt request enable 5" "0,1"
  bitfld.long  0x00 04.                  ",External interrupt request enable 4" "0,1"

  bitfld.long  0x00 03.                  "  EIRE03-00 ,External interrupt request enable 3" "0,1"
  bitfld.long  0x00 02.                  ",External interrupt request enable 2" "0,1"
  bitfld.long  0x00 01.                  ",External interrupt request enable 1" "0,1"
  bitfld.long  0x00 00.                  ",External interrupt request enable 0" "0,1"

group.long 0xC3F9001C++0x03
  line.long    0x00 "DIRSR,DMA/Interrupt Request Select Register"
  bitfld.long  0x00 03.                  "DIRS03-00 ,DMA/Interrupt Request Select 3" "0,1"
  bitfld.long  0x00 02.                  ",DMA/Interrupt Request Select 2" "0,1"
  bitfld.long  0x00 01.                  ",DMA/Interrupt Request Select 1" "0,1"
  bitfld.long  0x00 00.                  ",DMA/Interrupt Request Select 0" "0,1"

group.long 0xC3F90020++0x03
  line.long    0x00 "OSR,Overrun Status Register"
  bitfld.long  0x00 15.                  "OVF15-12  ,Overrun flag 15" "0,1"
  bitfld.long  0x00 14.                  ",Overrun flag 14" "0,1"
  bitfld.long  0x00 13.                  ",Overrun flag 13" "0,1"
  bitfld.long  0x00 12.                  ",Overrun flag 12" "0,1"

  bitfld.long  0x00 11.                  "  OVF11-08  ,Overrun flag 11" "0,1"
  bitfld.long  0x00 10.                  ",Overrun flag 10" "0,1"
  bitfld.long  0x00 09.                  ",Overrun flag 9" "0,1"
  bitfld.long  0x00 08.                  ",Overrun flag 8" "0,1"

  bitfld.long  0x00 07.                  "  OVF07-04  ,Overrun flag 7" "0,1"
  bitfld.long  0x00 06.                  ",Overrun flag 6" "0,1"
  bitfld.long  0x00 05.                  ",Overrun flag 5" "0,1"
  bitfld.long  0x00 04.                  ",Overrun flag 4" "0,1"

  bitfld.long  0x00 03.                  "  OVF03-00  ,Overrun flag 3" "0,1"
  bitfld.long  0x00 02.                  ",Overrun flag 2" "0,1"
  bitfld.long  0x00 01.                  ",Overrun flag 1" "0,1"
  bitfld.long  0x00 00.                  ",Overrun flag 0" "0,1"

group.long 0xC3F90024++0x03
  line.long    0x00 "ORER,Overrun Request Enable Register"
  bitfld.long  0x00 15.                  "ORE15-12  ,Overrun request enable 15" "0,1"
  bitfld.long  0x00 14.                  ",Overrun request enable 14" "0,1"
  bitfld.long  0x00 13.                  ",Overrun request enable 13" "0,1"
  bitfld.long  0x00 12.                  ",Overrun request enable 12" "0,1"

  bitfld.long  0x00 11.                  "  ORE11-08  ,Overrun request enable 11" "0,1"
  bitfld.long  0x00 10.                  ",Overrun request enable 10" "0,1"
  bitfld.long  0x00 09.                  ",Overrun request enable 9" "0,1"
  bitfld.long  0x00 08.                  ",Overrun request enable 8" "0,1"

  bitfld.long  0x00 07.                  "  ORE07-04  ,Overrun request enable 7" "0,1"
  bitfld.long  0x00 06.                  ",Overrun request enable 6" "0,1"
  bitfld.long  0x00 05.                  ",Overrun request enable 5" "0,1"
  bitfld.long  0x00 04.                  ",Overrun request enable 4" "0,1"

  bitfld.long  0x00 03.                  "  ORE03-00  ,Overrun request enable 3" "0,1"
  bitfld.long  0x00 02.                  ",Overrun request enable 2" "0,1"
  bitfld.long  0x00 01.                  ",Overrun request enable 1" "0,1"
  bitfld.long  0x00 00.                  ",Overrun request enable 0" "0,1"

group.long 0xC3F90028++0x03
  line.long    0x00 "IREER,IRQ Rising-Edge Event Enable Register"
  bitfld.long  0x00 31.                  "NMIRE    ,NMI Rising-Edge Event Enable" "0,1"
TEXTLINE "                     "  
  bitfld.long  0x00 15.                  "IREE15-12 ,IRQ rising-edge event enable 15" "0,1"
  bitfld.long  0x00 14.                  ",IRQ rising-edge event enable 14" "0,1"
  bitfld.long  0x00 13.                  ",IRQ rising-edge event enable 13" "0,1"
  bitfld.long  0x00 12.                  ",IRQ rising-edge event enable 12" "0,1"

  bitfld.long  0x00 11.                  "  IREE11-08 ,IRQ rising-edge event enable 11" "0,1"
  bitfld.long  0x00 10.                  ",IRQ rising-edge event enable 10" "0,1"
  bitfld.long  0x00 09.                  ",IRQ rising-edge event enable 9" "0,1"
  bitfld.long  0x00 08.                  ",IRQ rising-edge event enable 8" "0,1"

  bitfld.long  0x00 07.                  "  IREE07-04 ,IRQ rising-edge event enable 7" "0,1"
  bitfld.long  0x00 06.                  ",IRQ rising-edge event enable 6" "0,1"
  bitfld.long  0x00 05.                  ",IRQ rising-edge event enable 5" "0,1"
  bitfld.long  0x00 04.                  ",IRQ rising-edge event enable 4" "0,1"

  bitfld.long  0x00 03.                  "  IREE03-00 ,IRQ rising-edge event enable 3" "0,1"
  bitfld.long  0x00 02.                  ",IRQ rising-edge event enable 2" "0,1"
  bitfld.long  0x00 01.                  ",IRQ rising-edge event enable 1" "0,1"
  bitfld.long  0x00 00.                  ",IRQ rising-edge event enable 0" "0,1"

group.long 0xC3F9002C++0x03
  line.long    0x00 "IFEER,IRQ Falling-Edge Event Enable Register"
  bitfld.long  0x00 31.                  "NMIFE    ,NMI Rising-Edge Event Enable" "0,1"
TEXTLINE "                     "  
  bitfld.long  0x00 15.                  "IFEE15-12 ,IRQ falling-edge event enable 15" "0,1"
  bitfld.long  0x00 14.                  ",IRQ falling-edge event enable 14" "0,1"
  bitfld.long  0x00 13.                  ",IRQ falling-edge event enable 13" "0,1"
  bitfld.long  0x00 12.                  ",IRQ falling-edge event enable 12" "0,1"

  bitfld.long  0x00 11.                  "  IFEE11-08 ,IRQ falling-edge event enable 11" "0,1"
  bitfld.long  0x00 10.                  ",IRQ falling-edge event enable 10" "0,1"
  bitfld.long  0x00 09.                  ",IRQ falling-edge event enable 9" "0,1"
  bitfld.long  0x00 08.                  ",IRQ falling-edge event enable 8" "0,1"

  bitfld.long  0x00 07.                  "  IFEE07-04 ,IRQ falling-edge event enable 7" "0,1"
  bitfld.long  0x00 06.                  ",IRQ falling-edge event enable 6" "0,1"
  bitfld.long  0x00 05.                  ",IRQ falling-edge event enable 5" "0,1"
  bitfld.long  0x00 04.                  ",IRQ falling-edge event enable 4" "0,1"

  bitfld.long  0x00 03.                  "  IFEE03-00 ,IRQ falling-edge event enable 3" "0,1"
  bitfld.long  0x00 02.                  ",IRQ falling-edge event enable 2" "0,1"
  bitfld.long  0x00 01.                  ",IRQ falling-edge event enable 1" "0,1"
  bitfld.long  0x00 00.                  ",IRQ falling-edge event enable 0" "0,1"

group.long 0xC3F90030++0x03
  line.long    0x00 "IDFR,IRQ Digital Filter Register"
  bitfld.long  0x00 00.--03.             "DFL ,Digital filter length" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"


TEXTLINE ""


group.long 0xC3F90980++0x03
  line.long    0x00 "CCR,Chip Configuration Register"
  bitfld.long  0x00 17.                  "MATCH ,Compare register match" "0,1"
  bitfld.long  0x00 16.                  "  DISNEX ,Disable Nexus" "0,1"
  bitfld.long  0x00 01.                  "  CSRE ,The CRSE bit enables the suppression of reflections from the EBIs calibration bus onto the non-calibration bus" "0,1"
  bitfld.long  0x00 00.                  "  TEST ,Test mode enable. The application should not change this bit from its negated state at reset" "0,1"
  
group.long 0xC3F90984++0x03
  line.long    0x00 "ECCR,External Clock Control Register"
  hexmask.long.byte 0x00 08.--15. 1.       "ENGDIV ,Engineering clock division factor"
  bitfld.long  0x00 07.                  "  ECSS ,Engineering clock (ENGCLK) source select." "system clock,external clock"
  bitfld.long  0x00 03.                  "  EBTS ,External bus tap select" "0,1"
  bitfld.long  0x00 00.--01.             "  EBDF ,External bus division factor" "res.,1/2,res.,1/4"
  
  
group.long 0xC3F90988++0x03
  line.long    0x00 "CARH,Compare A High Register"

group.long 0xC3F9098C++0x03
  line.long    0x00 "CARL,Compare A Low Register"
  
group.long 0xC3F90990++0x03
  line.long    0x00 "CBRH,Compare B High Register"

group.long 0xC3F90994++0x03
  line.long    0x00 "CBRL,Compare B Low Register"


sif CPUIS("MPC5674*")

group.long 0xC3F909A0++0x03
  line.long    0x00 "SYSDIV,System Clock Register"
  bitfld.long  0x00 08.--09.             "SYSCLKDIV  ,System Clock Divide"     "platform & peripherals = 1/2 CPU freq,res.,CPU & platform: full speed; peripherals = 1/2 CPU freq,CPU & platform & peripherals: full speed"
TEXTLINE "                   "

tree "Halt Registers"

group.long 0xC3F909A4++0x03
  line.long    0x00 "HLT,Halt Register"
  bitfld.long  0x00 31.                    "CPU/platf ,halt module" "0,1"
  bitfld.long  0x00 26.                  "  eTPU_A    ,halt module" "0,1"
  bitfld.long  0x00 25.                  "  NPC       ,halt module" "0,1"
  bitfld.long  0x00 24.                  "  EBI       ,halt module" "0,1"
TEXTLINE "                   "
  bitfld.long  0x00 23.                  "  eQADC     ,halt module" "0,1"
  bitfld.long  0x00 21.                  "  eMIOS_A   ,halt module" "0,1"
  bitfld.long  0x00 20.                  "  DECFILs   ,halt module" "0,1"
  bitfld.long  0x00 18.                  "  PIT       ,halt module" "0,1"
TEXTLINE "                   "
  bitfld.long  0x00 15.                  "  FLEXCAN_D ,halt module" "0,1"
  bitfld.long  0x00 14.                  "  FLEXCAN_C ,halt module" "0,1"
  bitfld.long  0x00 13.                  "  FLEXCAN_B ,halt module" "0,1"
  bitfld.long  0x00 12.                  "  FLEXCAN_A ,halt module" "0,1"
TEXTLINE "                   "
  bitfld.long  0x00 11.                  "  DSPI_D    ,halt module" "0,1"
  bitfld.long  0x00 10.                  "  DSPI_C    ,halt module" "0,1"
  bitfld.long  0x00 09.                  "  DSPI_B    ,halt module" "0,1"
  bitfld.long  0x00 08.                  "  DSPI_A    ,halt module" "0,1"
TEXTLINE "                   "
  bitfld.long  0x00 02.                  "  eSCI_C    ,halt module" "0,1"
  bitfld.long  0x00 01.                  "  eSCI_B    ,halt module" "0,1"
  bitfld.long  0x00 00.                  "  eSCI_A    ,halt module" "0,1"
TEXTLINE ""

group.long 0xC3F909A8++0x03
  line.long    0x00 "HLTACK,Halt Acknowledge Register"
  bitfld.long  0x00 31.                    "CPU/platf ,halt module" "0,1"
  bitfld.long  0x00 26.                  "  eTPU_A    ,halt module" "0,1"
  bitfld.long  0x00 25.                  "  NPC       ,halt module" "0,1"
  bitfld.long  0x00 24.                  "  EBI       ,halt module" "0,1"
TEXTLINE "                   "
  bitfld.long  0x00 23.                  "  eQADC     ,halt module" "0,1"
  bitfld.long  0x00 21.                  "  eMIOS_A   ,halt module" "0,1"
  bitfld.long  0x00 20.                  "  DECFILs   ,halt module" "0,1"
  bitfld.long  0x00 18.                  "  PIT       ,halt module" "0,1"
TEXTLINE "                   "
  bitfld.long  0x00 15.                  "  FLEXCAN_D ,halt module" "0,1"
  bitfld.long  0x00 14.                  "  FLEXCAN_C ,halt module" "0,1"
  bitfld.long  0x00 13.                  "  FLEXCAN_B ,halt module" "0,1"
  bitfld.long  0x00 12.                  "  FLEXCAN_A ,halt module" "0,1"
TEXTLINE "                   "
  bitfld.long  0x00 11.                  "  DSPI_D    ,halt module" "0,1"
  bitfld.long  0x00 10.                  "  DSPI_C    ,halt module" "0,1"
  bitfld.long  0x00 09.                  "  DSPI_B    ,halt module" "0,1"
  bitfld.long  0x00 08.                  "  DSPI_A    ,halt module" "0,1"
TEXTLINE "                   "
  bitfld.long  0x00 02.                  "  eSCI_C    ,halt module" "0,1"
  bitfld.long  0x00 01.                  "  eSCI_B    ,halt module" "0,1"
  bitfld.long  0x00 00.                  "  eSCI_A    ,halt module" "0,1"

tree.end

endif



tree "Pad Configuration Registers"

sif ((cpu()=="MPC5632M")||(cpu()=="MPC5633M")||(cpu()=="MPC5634M")||(cpu()=="SPC563M54")||(cpu()=="SPC563M60")||(cpu()=="SPC563M64"))

group 0xC3F900E6++0x03 "PCR083-084: CAN_A / eSCI_A"
  line.word 0x00 "PCR083,Pad Configuration Register 083"
  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "GPIO,CNTX_A,TXD_A,CNTX_A,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR084,Pad Configuration Register 084"
  bitfld.word 0x02 10.--13.       "PA , Pin assignment" "GPIO,CNRX_A,RXD_A,CNRX_A,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x02 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900EE++0x03 "PCR087-088: CAN_C"
  line.word 0x00 "PCR087,Pad Configuration Register 087"
  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "GPIO,CNTX_C,res.,CNTX_C,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR088,Pad Configuration Register 088"
  bitfld.word 0x02 10.--13.       "PA , Pin assignment" "GPIO,CNRX_C,res.,CNRX_C,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x02 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900F2++0x03 "PCR089-090: eSCI_A / eMIOS[13/15]"
  line.word 0x00 "PCR089,Pad Configuration Register 089"
  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "GPIO,TXD_A,eMIOS[13],TXD_A,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR090,Pad Configuration Register 090"
  bitfld.word 0x02 10.--13.       "PA , Pin assignment" "GPIO,RXD_A,eMIOS[15],RXD_A,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x02 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900F6++0x03 "PCR091-092: eSCI_B"
  line.word 0x00 "PCR091,Pad Configuration Register 091"
  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "GPIO,TXD_B,res.,TXD_B,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR092,Pad Configuration Register 092"
  bitfld.word 0x02 10.--13.       "PA , Pin assignment" "GPIO,RXD_B,res.,RXD_B,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x02 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F9010c++0x11 "PCR102-119: DSPI_B / DSPI_C"
  line.word 0x00 "PCR102,Pad Configuration Register 102"
  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "GPIO,SCK_B,PCS_C[1],SCK_B,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR103,Pad Configuration Register 103"
  bitfld.word 0x02 10.--13.       "PA , Pin assignment" "GPIO,SIN_B,PCS_C[2],SIN_B,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x02 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x04 "PCR104,Pad Configuration Register 104"
  bitfld.word 0x04 10.--13.       "PA , Pin assignment" "GPIO,SOUT_B,PCS_C[5],SOUT_B,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x04 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x04 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x04 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x04 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x04 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x04 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x04 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x06 "PCR105,Pad Configuration Register 105"
  bitfld.word 0x06 10.--13.       "PA , Pin assignment" "GPIO,PCS_B[0],res.,PCS_B[0],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x06 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x06 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x06 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x06 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x06 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x06 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x06 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x08 "PCR106,Pad Configuration Register 106"
  bitfld.word 0x08 10.--13.       "PA , Pin assignment" "GPIO,PCS_B[1],res.,PCS_B[1],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x08 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x08 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x08 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x08 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x08 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x08 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x08 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0a "PCR107,Pad Configuration Register 107"
  bitfld.word 0x0a 10.--13.       "PA , Pin assignment" "GPIO,PCS_B[2],SOUT_C,PCS_B[2],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x0a 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0a 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0a 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x0a 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0a 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x0a 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0a 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0c "PCR108,Pad Configuration Register 108"
  bitfld.word 0x0c 10.--13.       "PA , Pin assignment" "GPIO,PCS_B[3],SIN_C,PCS_B[3],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x0c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0c 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x0c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0c 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x0c 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0e "PCR109,Pad Configuration Register 109"
  bitfld.word 0x0e 10.--13.       "PA , Pin assignment" "GPIO,PCS_B[4],SCK_C,PCS_B[4],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x0e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0e 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x0e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0e 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x0e 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0e 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x10 "PCR110,Pad Configuration Register 110"
  bitfld.word 0x10 10.--13.       "PA , Pin assignment" "GPIO,PCS_B[5],PCS_C[0],PCS_B[5],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x10 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x10 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x10 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x10 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x10 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x10 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x10 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90124++0x09 "PCR114-118: eTPU_A"
  line.word 0x00 "PCR114,Pad Configuration Register 114"
  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "GPIO,eTPU_A[00],eTPU_A[12],eTPU_A[00],eTPU_A[19],res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR115,Pad Configuration Register 115"
  bitfld.word 0x02 10.--13.       "PA , Pin assignment" "GPIO,eTPU_A[01],eTPU_A[13],eTPU_A[01],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x02 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x04 "PCR116,Pad Configuration Register 116"
  bitfld.word 0x04 10.--13.       "PA , Pin assignment" "GPIO,eTPU_A[02],eTPU_A[14],eTPU_A[02],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x04 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x04 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x04 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x04 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x04 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x04 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x04 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x06 "PCR117,Pad Configuration Register 117"
  bitfld.word 0x06 10.--13.       "PA , Pin assignment" "GPIO,eTPU_A[03],eTPU_A[15],eTPU_A[03],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x06 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x06 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x06 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x06 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x06 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x06 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x06 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x08 "PCR118,Pad Configuration Register 118"
  bitfld.word 0x08 10.--13.       "PA , Pin assignment" "GPIO,eTPU_A[04],eTPU_A[16],eTPU_A[04],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x08 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x08 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x08 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x08 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x08 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x08 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x08 00.            "  WPS , Weak pull up/down select" "0,1"



group 0xC3F9012E++0x07 "PCR119-122: eTPU_A / DSPI_B LVDS"
  line.word 0x00 "PCR119,Pad Configuration Register 119"
  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "GPIO,eTPU_A[05],eTPU_A[17],eTPU_A[05],SCK_B_LVDS-,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR120,Pad Configuration Register 120"
  bitfld.word 0x02 10.--13.       "PA , Pin assignment" "GPIO,eTPU_A[06],eTPU_A[18],eTPU_A[06],SCK_B_LVDS+,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x02 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x04 "PCR121,Pad Configuration Register 121"
  bitfld.word 0x04 10.--13.       "PA , Pin assignment" "GPIO,eTPU_A[07],eTPU_A[19],eTPU_A[07],SOUT_B_LVDS-,res.,res.,res.           ,eTPU_A[6],res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x04 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x04 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x04 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x04 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x04 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x04 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x04 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x06 "PCR122,Pad Configuration Register 122"
  bitfld.word 0x06 10.--13.       "PA , Pin assignment" "GPIO,eTPU_A[08],eTPU_A[20],eTPU_A[08],SOUT_B_LVDS+,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x06 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x06 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x06 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x06 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x06 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x06 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x06 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90136++0x05 "PCR123-125: eTPU_A"
  line.word 0x00 "PCR123,Pad Configuration Register 123"
  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "GPIO,eTPU_A[09],eTPU_A[21],eTPU_A[09],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR124,Pad Configuration Register 124"
  bitfld.word 0x02 10.--13.       "PA , Pin assignment" "GPIO,eTPU_A[10],eTPU_A[22],eTPU_A[10],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x02 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x04 "PCR125,Pad Configuration Register 125"
  bitfld.word 0x04 10.--13.       "PA , Pin assignment" "GPIO,eTPU_A[11],eTPU_A[23],eTPU_A[11],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x04 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x04 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x04 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x04 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x04 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x04 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x04 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F9013C++0x07 "PCR126-129: eTPU_A / DSPI_B"
  line.word 0x00 "PCR126,Pad Configuration Register 126"
  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "GPIO,eTPU_A[12],PCS_B[1],eTPU_A[12],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR127,Pad Configuration Register 127"
  bitfld.word 0x02 10.--13.       "PA , Pin assignment" "GPIO,eTPU_A[13],PCS_B[3],eTPU_A[13],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x02 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x04 "PCR128,Pad Configuration Register 128"
  bitfld.word 0x04 10.--13.       "PA , Pin assignment" "GPIO,eTPU_A[14],PCS_B[4],eTPU_A[14],eTPU_A[9],res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x04 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x04 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x04 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x04 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x04 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x04 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x04 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x06 "PCR129,Pad Configuration Register 129"
  bitfld.word 0x06 10.--13.       "PA , Pin assignment" "GPIO,eTPU_A[15],PCS_B[5],eTPU_A[15],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x06 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x06 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x06 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x06 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x06 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x06 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x06 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90144++0x07 "PCR130-133: eTPU_A"
  line.word 0x00 "PCR130,Pad Configuration Register 130"
  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "GPIO,eTPU_A[16],res.,eTPU_A[16],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR131,Pad Configuration Register 131"
  bitfld.word 0x02 10.--13.       "PA , Pin assignment" "GPIO,eTPU_A[17],res.,eTPU_A[17],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x02 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x04 "PCR132,Pad Configuration Register 132"
  bitfld.word 0x04 10.--13.       "PA , Pin assignment" "GPIO,eTPU_A[18],res.,eTPU_A[18],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x04 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x04 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x04 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x04 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x04 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x04 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x04 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x06 "PCR133,Pad Configuration Register 133"
  bitfld.word 0x06 10.--13.       "PA , Pin assignment" "GPIO,eTPU_A[19],res.,eTPU_A[19],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x06 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x06 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x06 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x06 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x06 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x06 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x06 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F9014C++0x07 "PCR134-137: eTPU_A / IRQ"
  line.word 0x00 "PCR134,Pad Configuration Register 134"
  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "GPIO,eTPU_A[20],IRQ[08],eTPU_A[20],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR135,Pad Configuration Register 135"
  bitfld.word 0x02 10.--13.       "PA , Pin assignment" "GPIO,eTPU_A[21],IRQ[09],eTPU_A[21],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x02 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x04 "PCR136,Pad Configuration Register 136"
  bitfld.word 0x04 10.--13.       "PA , Pin assignment" "GPIO,eTPU_A[22],IRQ[10],eTPU_A[22],eTPU_A[17],res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x04 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x04 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x04 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x04 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x04 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x04 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x04 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x06 "PCR137,Pad Configuration Register 137"
  bitfld.word 0x06 10.--13.       "PA , Pin assignment" "GPIO,eTPU_A[23],IRQ[11],eTPU_A[23],eTPU_A[21],res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x06 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x06 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x06 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x06 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x06 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x06 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x06 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90154++0x07 "PCR138-141: eTPU_A / IRQ / DSPI_C LVDS"
  line.word 0x00 "PCR138,Pad Configuration Register 138"
  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "GPIO,eTPU_A[24],IRQ[12],eTPU_A[24],SCK_C_LVDS-,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR139,Pad Configuration Register 139"
  bitfld.word 0x02 10.--13.       "PA , Pin assignment" "GPIO,eTPU_A[25],IRQ[13],eTPU_A[25],SCK_C_LVDS+,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x02 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x04 "PCR140,Pad Configuration Register 140"
  bitfld.word 0x04 10.--13.       "PA , Pin assignment" "GPIO,eTPU_A[26],IRQ[14],eTPU_A[26],SOUT_C_LVDS-,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x04 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x04 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x04 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x04 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x04 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x04 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x04 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x06 "PCR141,Pad Configuration Register 141"
  bitfld.word 0x06 10.--13.       "PA , Pin assignment" "GPIO,eTPU_A[27],IRQ[15],eTPU_A[27],SOUT_C_LVDS+,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x06 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x06 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x06 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x06 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x06 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x06 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x06 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F9015C++0x07 "PCR142-145: eTPU_A / DSPI_C"
  line.word 0x00 "PCR142,Pad Configuration Register 142"
  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "GPIO,eTPU_A[28],PCS_C[1],eTPU_A[28],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR143,Pad Configuration Register 143"
  bitfld.word 0x02 10.--13.       "PA , Pin assignment" "GPIO,eTPU_A[29],PCS_C[2],eTPU_A[29],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x02 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x04 "PCR144,Pad Configuration Register 144"
  bitfld.word 0x04 10.--13.       "PA , Pin assignment" "GPIO,eTPU_A[30],PCS_C[3],eTPU_A[30],eTPU_A[11],res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x04 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x04 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x04 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x04 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x04 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x04 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x04 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x06 "PCR145,Pad Configuration Register 145"
  bitfld.word 0x06 10.--13.       "PA , Pin assignment" "GPIO,eTPU_A[31],PCS_C[4],eTPU_A[31],eTPU_A[13],res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x06 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x06 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x06 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x06 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x06 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x06 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x06 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F901A6++0x17 "PCR179-190: eMIOS / eTPU_A"
  line.word 0x00 "PCR179,Pad Configuration Register 179"
  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "GPIO,eMIOS[00],eTPU_A[00],eMIOS[00],eTPU_A[25],res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x04 "PCR181,Pad Configuration Register 181"
  bitfld.word 0x04 10.--13.       "PA , Pin assignment" "GPIO,eMIOS[02],eTPU_A[02],eMIOS[02],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x04 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x04 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x04 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x04 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x04 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x04 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x04 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x08 "PCR183,Pad Configuration Register 183"
  bitfld.word 0x08 10.--13.       "PA , Pin assignment" "GPIO,eMIOS[04],eTPU_A[04],eMIOS[04],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x08 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x08 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x08 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x08 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x08 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x08 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x08 00.            "  WPS , Weak pull up/down select" "0,1"

TEXTLINE "" 
  line.word 0x10 "PCR187,Pad Configuration Register 187"
  bitfld.word 0x10 10.--13.       "PA , Pin assignment" "GPIO,eMIOS[08],eTPU_A[08],eMIOS[08],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x10 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x10 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x10 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x10 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x10 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x10 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x10 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x12 "PCR188,Pad Configuration Register 188"
  bitfld.word 0x12 10.--13.       "PA , Pin assignment" "GPIO,eMIOS[09],eTPU_A[09],eMIOS[09],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x12 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x12 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x12 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x12 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x12 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x12 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x12 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x14 "PCR189,Pad Configuration Register 189"
  bitfld.word 0x14 10.--13.       "PA , Pin assignment" "GPIO,eMIOS[10],res.,eMIOS[10],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x14 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x14 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x14 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x14 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x14 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x14 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x14 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x16 "PCR190,Pad Configuration Register 190"
  bitfld.word 0x16 10.--13.       "PA , Pin assignment" "GPIO,eMIOS[11],res.,eMIOS[11],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x16 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x16 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x16 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x16 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x16 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x16 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x16 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F901BE++0x01 "PCR191: eMIOS / DSPI_C"
  line.word 0x00 "PCR191,Pad Configuration Register 191"
  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "GPIO,eMIOS[12],SOUT_C,eMIOS[12],eTPU_A[27],res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F901C2++0x01 "PCR193: eMIOS / IRQ / eTPU_A"
  line.word 0x00 "PCR193,Pad Configuration Register 193"
  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "GPIO,eMIOS[14],IRQ[00],eMIOS[14],eTPU_A[29],res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F901D4++0x01 "PCR202: eMIOS"
  line.word 0x00 "PCR202,Pad Configuration Register 202"
  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "GPIO,eMIOS[23],res.,eMIOS[23],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F901E0++0x01 "PCR208: PLLREF / IRQ[4] / ETRIG"
  line.word 0x00 "PCR208,Pad Configuration Register 208"
  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "GPIO,PLLREF,IRQ[04],PLLREF,ETRIG[0],res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F901E8++0x01 "PCR212: BOOTCFG[0:1] / IRQ[2:3]"
  line.word 0x00 "PCR212,Pad Configuration Register 212"
  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "GPIO,BOOTCFG1,IRQ[03],BOOTCFG1,ETRIG[1],res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F901EA++0x01 "PCR213: WKPCFG"
  line.word 0x00 "PCR213,Pad Configuration Register 213"
  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "GPIO,WKPCFG,NMI,WKPCFG,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F901EE++0x01 "PCR215: AN[12] / MA[0] / !SDS / eTPU_A"
  line.word 0x00 "PCR215,Pad Configuration Register 215"

  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "!SDS,eTPU_A[19],MA[0],AN[12],res.,res.,res.,res.      "
;  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
;  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
; bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
;  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
;  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
;  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F901F0++0x01 "PCR216: AN[13] / MA[1] / SDO / eTPU_A"
  line.word 0x00 "PCR216,Pad Configuration Register 216"

  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "SDO,eTPU_A[21],MA[1],AN[13],res.,res.,res.,res.      "
;  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
;  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
; bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
;  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
;  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
;  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F901F2++0x01 "PCR217: AN14 / MA2 / SDI"
  line.word 0x00 "PCR217,Pad Configuration Register 217"

  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "SDI,eTPU_A[27],MA[2],AN[14],res.,res.,res.,res.      "
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F901F4++0x01 "PCR218: AN15 / FCK"
  line.word 0x00 "PCR218,Pad Configuration Register 218"

  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "FCK,AN15,eTPU_A[29],res.,res.,res.,res.,res.      "
;  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
;  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
; bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
;  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
;  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
;  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F901F6++0x01 "PCR219: MCKO/CLKOUT"
  line.word 0x00 "PCR219,Pad Configuration Register 219"
  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "MCKO/GPIO,res.,res.,res.,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F901F8++0x09 "PCR220-223: MDO[0:3] / eTPU_A"
  line.word 0x00 "PCR220,Pad Configuration Register 220"
  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "MDO0/GPIO,eTPU_A[13],res.,eTPU_A[13],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR221,Pad Configuration Register 221"
  bitfld.word 0x02 10.--13.       "PA , Pin assignment" "MDO1/GPIO,eTPU_A[19],res.,eTPU_A[19],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x02 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x04 "PCR222,Pad Configuration Register 222"
  bitfld.word 0x04 10.--13.       "PA , Pin assignment" "MDO2/GPIO,eTPU_A[21],res.,eTPU_A[21],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x04 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x04 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x04 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x04 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x04 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x04 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x04 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x06 "PCR223,Pad Configuration Register 223"
  bitfld.word 0x06 10.--13.       "PA , Pin assignment" "MDO3/GPIO,eTPU_A[25],res.,eTPU_A[25],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x06 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x06 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x06 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x06 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x06 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x06 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x06 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90200++0x03 "PCR224-225: MSEO[0:1]"
  line.word 0x00 "PCR224,Pad Configuration Register 224"
  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "MSEO0/GPIO,eTPU_A[27],res.,eTPU_A[27],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR225,Pad Configuration Register 225"
  bitfld.word 0x02 10.--13.       "PA , Pin assignment" "MSEO1/GPIO,eTPU_A[29],res.,eTPU_A[29],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x02 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"



group 0xC3F90206++0x01 "PCR227: !EVTO / eTPU_A"
  line.word 0x00 "PCR227,Pad Configuration Register 227"
  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "EVTO/GPIO,eTPU_A[4],res.,eTPU_A[4],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90208++0x01 "PCR228: TDO / eMIOS"
  line.word 0x00 "PCR228,Pad Configuration Register 228"
  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "TDO/GPIO,eMOIS[6],res.,eMOIS[6],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F9020A++0x01 "PCR229: !CLKOUT"
  line.word 0x00 "PCR229,Pad Configuration Register 229"

; bitfld.word 0x00 10.--13.       "PA , Pin assignment" "   0,   1,   2,   3,   4,   5,   6,   7,   8,   9,   A,   B,   C,   D,   E,   F"
  bitfld.word 0x00 09.            "         OBE , Output buffer enable" "0,1"
; bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "         DSC , Drive strength control" "10pF,20pF,30pF,50pF"
; bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
; bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
; bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
; bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
; bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

group 0xC3F9020C++0x01 "PCR230: !RSTOUT"
  line.word 0x00 "PCR230,Pad Configuration Register 230"

;  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "   0,   1,   2,   3,   4,   5,   6,   7,   8,   9,   A,   B,   C,   D,   E,   F"
;  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
;  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
;  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
;  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
;  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "                                               SRC , Slew rate control" "Min,Med,res,Max"
;  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
;  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

group 0xC3F9020E++0x01 "PCR231: EVTI / eTPU_A"
  line.word 0x00 "PCR231,Pad Configuration Register 231"
  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "EVTI/GPIO,eTPU_A[2],res.,eTPU_A[2],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90210++0x01 "PCR231: TDI / eMIOS"
  line.word 0x00 "PCR232,Pad Configuration Register 232"
  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "TDI/GPIO,eMIOS[5],res.,eMIOS[5],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"



group 0xC3F902E0++0x13 "PCR336-345: CAL"
  line.word 0x00 "PCR336,Pad Configuration Register 336"
  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "!CAL_CS[0],res.,res.,res.,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x04 "PCR338,Pad Configuration Register 338"
  bitfld.word 0x04 10.--13.       "PA , Pin assignment" "!CAL_CS[2],CAL_ADDR[10],res.,CAL_ADDR[10],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x04 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x04 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x04 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x04 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x04 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x04 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x04 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x06 "PCR339,Pad Configuration Register 339"
  bitfld.word 0x06 10.--13.       "PA , Pin assignment" "!CAL_CS[3],CAL_ADDR[11],res.,CAL_ADDR[11],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x06 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x06 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x06 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x06 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x06 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x06 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x06 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x08 "PCR340,Pad Configuration Register 340"
  bitfld.word 0x08 10.--13.       "PA , Pin assignment" "CAL_ADDR[12-30],res.,res.,res.,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x08 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x08 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x08 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x08 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x08 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x08 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x08 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0A "PCR341,Pad Configuration Register 341"
  bitfld.word 0x0A 10.--13.       "PA , Pin assignment" "CAL_DATA[00-15],res.,res.,res.,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x0A 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0A 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0A 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x0A 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x0A 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0A 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0A 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0C "PCR342,Pad Configuration Register 342"
  bitfld.word 0x0C 10.--13.       "PA , Pin assignment" "CAL_RW_WE_OE,res.,res.,res.,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x0C 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0C 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0C 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x0C 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x0C 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0C 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0C 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0E "PCR343,Pad Configuration Register 343"
  bitfld.word 0x0E 10.--13.       "PA , Pin assignment" "CAL_TS_ALE,res.,res.,res.,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x0E 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0E 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0E 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x0E 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x0E 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0E 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0E 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x10 "PCR344,Pad Configuration Register 344"
  bitfld.word 0x10 10.--13.       "PA , Pin assignment" "CAL_EVTO_MCKO,res.,res.,res.,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x10 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x10 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x10 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x10 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x10 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x10 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x10 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x12 "PCR345,Pad Configuration Register 345"
  bitfld.word 0x12 10.--13.       "PA , Pin assignment" "CAL_NEXUS,res.,res.,res.,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x12 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x12 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x12 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x12 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x12 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x12 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x12 00.            "  WPS , Weak pull up/down select" "0,1"


endif

sif (CPUIS("MPC5674*"))
group 0xC3F900D6++0x0f "PCR075-082: NEXUS"
  line.word 0x00 "PCR075,Pad Configuration Register 075"
  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "MDO4/GPIO,res.,res.,res.,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR076,Pad Configuration Register 076"
  bitfld.word 0x02 10.--13.       "PA , Pin assignment" "MDO5/GPIO,res.,res.,res.,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x02 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x04 "PCR077,Pad Configuration Register 077"
  bitfld.word 0x04 10.--13.       "PA , Pin assignment" "MDO6/GPIO,res.,res.,res.,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x04 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x04 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x04 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x04 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x04 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x04 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x04 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x06 "PCR078,Pad Configuration Register 078"
  bitfld.word 0x06 10.--13.       "PA , Pin assignment" "MDO7/GPIO,res.,res.,res.,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x06 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x06 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x06 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x06 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x06 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x06 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x06 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x08 "PCR079,Pad Configuration Register 079"
  bitfld.word 0x08 10.--13.       "PA , Pin assignment" "MDO8/GPIO,res.,res.,res.,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x08 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x08 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x08 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x08 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x08 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x08 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x08 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0a "PCR080,Pad Configuration Register 080"
  bitfld.word 0x0a 10.--13.       "PA , Pin assignment" "MDO9/GPIO,res.,res.,res.,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x0a 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0a 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0a 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x0a 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x0a 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0a 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0a 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0c "PCR081,Pad Configuration Register 081"
  bitfld.word 0x0c 10.--13.       "PA , Pin assignment" "MDO10/GPIO,res.,res.,res.,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x0c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0c 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x0c 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x0c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0c 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0e "PCR082,Pad Configuration Register 082"
  bitfld.word 0x0e 10.--13.       "PA , Pin assignment" "MDO11/GPIO,res.,res.,res.,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x0e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0e 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x0e 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x0e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0e 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0e 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900E6++0x03 "PCR083-084: CAN_A / eSCI_A"
  line.word 0x00 "PCR083,Pad Configuration Register 083"
  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "GPIO,CNTX_A,TXD_A,CNTX_A,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR084,Pad Configuration Register 084"
  bitfld.word 0x02 10.--13.       "PA , Pin assignment" "GPIO,CNRX_A,RXD_A,CNRX_A,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x02 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900Ea++0x03 "PCR085-086: CAN_B / DSPI_C"
  line.word 0x00 "PCR085,Pad Configuration Register 085"
  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "GPIO,CNTX_B,PCS_C[3],CNTX_B,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR086,Pad Configuration Register 086"
  bitfld.word 0x02 10.--13.       "PA , Pin assignment" "GPIO,CNRX_B,PCS_C[4],CNRX_B,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x02 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900EE++0x03 "PCR087-088: CAN_C / DSPI_D"
  line.word 0x00 "PCR087,Pad Configuration Register 087"
  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "GPIO,CNTX_C,PCS_D[3],CNTX_C,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR088,Pad Configuration Register 088"
  bitfld.word 0x02 10.--13.       "PA , Pin assignment" "GPIO,CNRX_C,PCS_D[4],CNRX_C,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x02 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900F2++0x03 "PCR089-090: eSCI_A"
  line.word 0x00 "PCR089,Pad Configuration Register 089"
  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "GPIO,TXD_A,res.,TXD_A,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR090,Pad Configuration Register 090"
  bitfld.word 0x02 10.--13.       "PA , Pin assignment" "GPIO,RXD_A,res.,RXD_A,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x02 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900F6++0x03 "PCR091-092: eSCI_B"
  line.word 0x00 "PCR091,Pad Configuration Register 091"
  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "GPIO,TXD_B,PCS_D[1],TXD_B,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR092,Pad Configuration Register 092"
  bitfld.word 0x02 10.--13.       "PA , Pin assignment" "GPIO,RXD_B,PCS_D[5],RXD_B,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x02 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900FA++0x11 "PCR093-101: DSPI_A / DSPI_C / DSPI_D"
  line.word 0x00 "PCR093,Pad Configuration Register 093"
  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "GPIO,SCK_A,PCS_C[1],SCK_A,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR094,Pad Configuration Register 094"
  bitfld.word 0x02 10.--13.       "PA , Pin assignment" "GPIO,SIN_A,PCS_C[2],SIN_A,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x02 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x04 "PCR095,Pad Configuration Register 095"
  bitfld.word 0x04 10.--13.       "PA , Pin assignment" "GPIO,SOUT_A,PCS_C[5],SOUT_A,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x04 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x04 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x04 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x04 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x04 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x04 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x04 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x06 "PCR096,Pad Configuration Register 096"
  bitfld.word 0x06 10.--13.       "PA , Pin assignment" "GPIO,PCS_A[0],PCS_D[2],PCS_A[0],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x06 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x06 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x06 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x06 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x06 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x06 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x06 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x08 "PCR097,Pad Configuration Register 097"
  bitfld.word 0x08 10.--13.       "PA , Pin assignment" "GPIO,PCS_A[1],res.,PCS_A[1],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x08 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x08 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x08 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x08 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x08 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x08 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x08 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0a "PCR098,Pad Configuration Register 098"
  bitfld.word 0x0a 10.--13.       "PA , Pin assignment" "GPIO,PCS_A[2],res.,PCS_A[2],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x0a 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0a 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0a 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x0a 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0a 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x0a 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0a 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0c "PCR099,Pad Configuration Register 099"
  bitfld.word 0x0c 10.--13.       "PA , Pin assignment" "GPIO,PCS_A[3],res.,PCS_A[3],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x0c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0c 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x0c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0c 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x0c 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0e "PCR100,Pad Configuration Register 100"
  bitfld.word 0x0e 10.--13.       "PA , Pin assignment" "GPIO,PCS_A[4],res.,PCS_A[4],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x0e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0e 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x0e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0e 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x0e 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0e 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x10 "PCR101,Pad Configuration Register 101"
  bitfld.word 0x10 10.--13.       "PA , Pin assignment" "GPIO,PCS_A[5],ETRIG1,PCS_A[5],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x10 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x10 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x10 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x10 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x10 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x10 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x10 00.            "  WPS , Weak pull up/down select" "0,1"



group 0xC3F9010c++0x11 "PCR102-119: DSPI_B / DSPI_C / DSPI_D"
  line.word 0x00 "PCR102,Pad Configuration Register 102"
  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "GPIO,SCK_B,res.,SCK_B,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR103,Pad Configuration Register 103"
  bitfld.word 0x02 10.--13.       "PA , Pin assignment" "GPIO,SIN_B,res.,SIN_B,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x02 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x04 "PCR104,Pad Configuration Register 104"
  bitfld.word 0x04 10.--13.       "PA , Pin assignment" "GPIO,SOUT_B,res.,SOUT_B,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x04 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x04 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x04 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x04 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x04 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x04 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x04 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x06 "PCR105,Pad Configuration Register 105"
  bitfld.word 0x06 10.--13.       "PA , Pin assignment" "GPIO,PCS_B[0],PCS_D[2],PCS_B[0],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x06 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x06 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x06 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x06 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x06 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x06 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x06 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x08 "PCR106,Pad Configuration Register 106"
  bitfld.word 0x08 10.--13.       "PA , Pin assignment" "GPIO,PCS_B[1],PCS_D[0],PCS_B[1],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x08 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x08 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x08 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x08 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x08 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x08 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x08 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0a "PCR107,Pad Configuration Register 107"
  bitfld.word 0x0a 10.--13.       "PA , Pin assignment" "GPIO,PCS_B[2],SOUT_C,PCS_B[2],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x0a 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0a 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0a 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x0a 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0a 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x0a 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0a 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0c "PCR108,Pad Configuration Register 108"
  bitfld.word 0x0c 10.--13.       "PA , Pin assignment" "GPIO,PCS_B[3],SIN_C,PCS_B[3],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x0c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0c 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x0c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0c 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x0c 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0e "PCR109,Pad Configuration Register 109"
  bitfld.word 0x0e 10.--13.       "PA , Pin assignment" "GPIO,PCS_B[4],SCK_C,PCS_B[4],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x0e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0e 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x0e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0e 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x0e 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0e 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x10 "PCR110,Pad Configuration Register 110"
  bitfld.word 0x10 10.--13.       "PA , Pin assignment" "GPIO,PCS_B[5],PCS_C[0],PCS_B[5],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x10 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x10 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x10 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x10 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x10 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x10 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x10 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90122++0x01 "PCR113: TCRCLKA / IRQ7"
  line.word 0x00 "PCR113,Pad Configuration Register 113"
  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "GPIO,TCRCLKA,IRQ7,TCRCLKA,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90124++0x17 "PCR114-125: eTPU_A"
  line.word 0x00 "PCR114,Pad Configuration Register 114"
  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "GPIO,eTPU_A[00],eTPU_A[12],eTPU_A[00],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR115,Pad Configuration Register 115"
  bitfld.word 0x02 10.--13.       "PA , Pin assignment" "GPIO,eTPU_A[01],eTPU_A[13],eTPU_A[01],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x02 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x04 "PCR116,Pad Configuration Register 116"
  bitfld.word 0x04 10.--13.       "PA , Pin assignment" "GPIO,eTPU_A[02],eTPU_A[14],eTPU_A[02],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x04 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x04 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x04 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x04 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x04 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x04 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x04 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x06 "PCR117,Pad Configuration Register 117"
  bitfld.word 0x06 10.--13.       "PA , Pin assignment" "GPIO,eTPU_A[03],eTPU_A[15],eTPU_A[03],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x06 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x06 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x06 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x06 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x06 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x06 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x06 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x08 "PCR118,Pad Configuration Register 118"
  bitfld.word 0x08 10.--13.       "PA , Pin assignment" "GPIO,eTPU_A[04],eTPU_A[16],eTPU_A[04],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x08 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x08 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x08 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x08 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x08 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x08 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x08 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0a "PCR119,Pad Configuration Register 119"
  bitfld.word 0x0a 10.--13.       "PA , Pin assignment" "GPIO,eTPU_A[05],eTPU_A[17],eTPU_A[05],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x0a 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0a 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0a 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x0a 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0a 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x0a 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0a 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0c "PCR120,Pad Configuration Register 120"
  bitfld.word 0x0c 10.--13.       "PA , Pin assignment" "GPIO,eTPU_A[06],eTPU_A[18],eTPU_A[06],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x0c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0c 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x0c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0c 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x0c 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0e "PCR121,Pad Configuration Register 121"
  bitfld.word 0x0e 10.--13.       "PA , Pin assignment" "GPIO,eTPU_A[07],eTPU_A[19],eTPU_A[07],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x0e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0e 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x0e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0e 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x0e 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0e 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x10 "PCR122,Pad Configuration Register 122"
  bitfld.word 0x10 10.--13.       "PA , Pin assignment" "GPIO,eTPU_A[08],eTPU_A[20],eTPU_A[08],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x10 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x10 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x10 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x10 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x10 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x10 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x10 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x12 "PCR123,Pad Configuration Register 123"
  bitfld.word 0x12 10.--13.       "PA , Pin assignment" "GPIO,eTPU_A[09],eTPU_A[21],eTPU_A[09],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x12 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x12 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x12 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x12 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x12 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x12 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x12 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x14 "PCR124,Pad Configuration Register 124"
  bitfld.word 0x14 10.--13.       "PA , Pin assignment" "GPIO,eTPU_A[10],eTPU_A[22],eTPU_A[10],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x14 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x14 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x14 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x14 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x14 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x14 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x14 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x16 "PCR125,Pad Configuration Register 125"
  bitfld.word 0x16 10.--13.       "PA , Pin assignment" "GPIO,eTPU_A[11],eTPU_A[23],eTPU_A[11],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x16 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x16 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x16 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x16 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x16 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x16 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x16 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F9013C++0x07 "PCR126-129: eTPU_A / DSPI_B"
  line.word 0x00 "PCR126,Pad Configuration Register 126"
  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "GPIO,eTPU_A[12],PCS_B[1],eTPU_A[12],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR127,Pad Configuration Register 127"
  bitfld.word 0x02 10.--13.       "PA , Pin assignment" "GPIO,eTPU_A[13],PCS_B[3],eTPU_A[13],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x02 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x04 "PCR128,Pad Configuration Register 128"
  bitfld.word 0x04 10.--13.       "PA , Pin assignment" "GPIO,eTPU_A[14],PCS_B[4],eTPU_A[14],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x04 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x04 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x04 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x04 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x04 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x04 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x04 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x06 "PCR129,Pad Configuration Register 129"
  bitfld.word 0x06 10.--13.       "PA , Pin assignment" "GPIO,eTPU_A[15],PCS_B[5],eTPU_A[15],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x06 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x06 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x06 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x06 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x06 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x06 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x06 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90144++0x07 "PCR130-133: eTPU_A / DSPI_D"
  line.word 0x00 "PCR130,Pad Configuration Register 130"
  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "GPIO,eTPU_A[16],PCS_D[1],eTPU_A[16],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR131,Pad Configuration Register 131"
  bitfld.word 0x02 10.--13.       "PA , Pin assignment" "GPIO,eTPU_A[17],PCS_D[2],eTPU_A[17],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x02 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x04 "PCR132,Pad Configuration Register 132"
  bitfld.word 0x04 10.--13.       "PA , Pin assignment" "GPIO,eTPU_A[18],PCS_D[3],eTPU_A[18],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x04 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x04 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x04 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x04 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x04 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x04 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x04 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x06 "PCR133,Pad Configuration Register 133"
  bitfld.word 0x06 10.--13.       "PA , Pin assignment" "GPIO,eTPU_A[19],PCS_D[4],eTPU_A[19],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x06 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x06 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x06 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x06 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x06 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x06 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x06 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F9014C++0x0f "PCR134-141: eTPU_A / IRQ"
  line.word 0x00 "PCR134,Pad Configuration Register 134"
  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "GPIO,eTPU_A[20],IRQ[08],eTPU_A[20],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR135,Pad Configuration Register 135"
  bitfld.word 0x02 10.--13.       "PA , Pin assignment" "GPIO,eTPU_A[21],IRQ[09],eTPU_A[21],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x02 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x04 "PCR136,Pad Configuration Register 136"
  bitfld.word 0x04 10.--13.       "PA , Pin assignment" "GPIO,eTPU_A[22],IRQ[10],eTPU_A[22],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x04 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x04 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x04 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x04 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x04 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x04 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x04 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x06 "PCR137,Pad Configuration Register 137"
  bitfld.word 0x06 10.--13.       "PA , Pin assignment" "GPIO,eTPU_A[23],IRQ[11],eTPU_A[23],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x06 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x06 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x06 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x06 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x06 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x06 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x06 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x08 "PCR138,Pad Configuration Register 138"
  bitfld.word 0x08 10.--13.       "PA , Pin assignment" "GPIO,eTPU_A[24],IRQ[12],eTPU_A[24],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x08 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x08 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x08 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x08 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x08 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x08 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x08 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0a "PCR139,Pad Configuration Register 139"
  bitfld.word 0x0a 10.--13.       "PA , Pin assignment" "GPIO,eTPU_A[25],IRQ[13],eTPU_A[25],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x0a 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0a 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0a 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x0a 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0a 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x0a 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0a 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0c "PCR140,Pad Configuration Register 140"
  bitfld.word 0x0c 10.--13.       "PA , Pin assignment" "GPIO,eTPU_A[26],IRQ[14],eTPU_A[26],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x0c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0c 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x0c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0c 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x0c 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0e "PCR141,Pad Configuration Register 141"
  bitfld.word 0x0e 10.--13.       "PA , Pin assignment" "GPIO,eTPU_A[27],IRQ[15],eTPU_A[27],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x0e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0e 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x0e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0e 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x0e 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0e 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F9015C++0x07 "PCR142-145: eTPU_A / DSPI_C"
  line.word 0x00 "PCR142,Pad Configuration Register 142"
  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "GPIO,eTPU_A[28],PCS_C[1],eTPU_A[28],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR143,Pad Configuration Register 143"
  bitfld.word 0x02 10.--13.       "PA , Pin assignment" "GPIO,eTPU_A[29],PCS_C[2],eTPU_A[29],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x02 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x04 "PCR144,Pad Configuration Register 144"
  bitfld.word 0x04 10.--13.       "PA , Pin assignment" "GPIO,eTPU_A[30],PCS_C[3],eTPU_A[30],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x04 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x04 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x04 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x04 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x04 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x04 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x04 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x06 "PCR145,Pad Configuration Register 145"
  bitfld.word 0x06 10.--13.       "PA , Pin assignment" "GPIO,eTPU_A[31],PCS_C[4],eTPU_A[31],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x06 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x06 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x06 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x06 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x06 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x06 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x06 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90164++0x01 "PCR146: TCRCLKB / IRQ6"
  line.word 0x00 "PCR146,Pad Configuration Register 146"
  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "GPIO,TCRCLKB,IRQ6,TCRCLKB,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90166++0x1f "PCR147-162: eTPU_B"
  line.word 0x00 "PCR147,Pad Configuration Register 147"
  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "GPIO,eTPU_B[00],eTPU_B[16],eTPU_B[00],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR148,Pad Configuration Register 148"
  bitfld.word 0x02 10.--13.       "PA , Pin assignment" "GPIO,eTPU_B[01],eTPU_B[17],eTPU_B[01],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x02 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x04 "PCR149,Pad Configuration Register 149"
  bitfld.word 0x04 10.--13.       "PA , Pin assignment" "GPIO,eTPU_B[02],eTPU_B[18],eTPU_B[02],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x04 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x04 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x04 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x04 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x04 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x04 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x04 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x06 "PCR150,Pad Configuration Register 150"
  bitfld.word 0x06 10.--13.       "PA , Pin assignment" "GPIO,eTPU_B[03],eTPU_B[19],eTPU_B[03],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x06 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x06 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x06 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x06 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x06 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x06 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x06 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x08 "PCR151,Pad Configuration Register 151"
  bitfld.word 0x08 10.--13.       "PA , Pin assignment" "GPIO,eTPU_B[04],eTPU_B[20],eTPU_B[04],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x08 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x08 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x08 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x08 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x08 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x08 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x08 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0a "PCR152,Pad Configuration Register 152"
  bitfld.word 0x0a 10.--13.       "PA , Pin assignment" "GPIO,eTPU_B[05],eTPU_B[21],eTPU_B[05],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x0a 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0a 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0a 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x0a 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0a 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x0a 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0a 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0c "PCR153,Pad Configuration Register 153"
  bitfld.word 0x0c 10.--13.       "PA , Pin assignment" "GPIO,eTPU_B[06],eTPU_B[22],eTPU_B[06],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x0c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0c 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x0c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0c 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x0c 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0e "PCR154,Pad Configuration Register 154"
  bitfld.word 0x0e 10.--13.       "PA , Pin assignment" "GPIO,eTPU_B[07],eTPU_B[23],eTPU_B[07],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x0e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0e 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x0e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0e 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x0e 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0e 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x10 "PCR155,Pad Configuration Register 155"
  bitfld.word 0x10 10.--13.       "PA , Pin assignment" "GPIO,eTPU_B[08],eTPU_B[24],eTPU_B[08],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x10 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x10 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x10 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x10 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x10 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x10 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x10 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x12 "PCR156,Pad Configuration Register 156"
  bitfld.word 0x12 10.--13.       "PA , Pin assignment" "GPIO,eTPU_B[09],eTPU_B[25],eTPU_B[09],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x12 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x12 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x12 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x12 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x12 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x12 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x12 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x14 "PCR157,Pad Configuration Register 157"
  bitfld.word 0x14 10.--13.       "PA , Pin assignment" "GPIO,eTPU_B[10],eTPU_B[26],eTPU_B[10],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x14 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x14 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x14 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x14 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x14 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x14 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x14 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x16 "PCR158,Pad Configuration Register 158"
  bitfld.word 0x16 10.--13.       "PA , Pin assignment" "GPIO,eTPU_B[11],eTPU_B[27],eTPU_B[11],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x16 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x16 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x16 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x16 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x16 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x16 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x16 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x18 "PCR159,Pad Configuration Register 159"
  bitfld.word 0x18 10.--13.       "PA , Pin assignment" "GPIO,eTPU_B[12],eTPU_B[28],eTPU_B[12],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x18 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x18 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x18 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x18 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x18 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x18 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x18 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x1a "PCR160,Pad Configuration Register 160"
  bitfld.word 0x1a 10.--13.       "PA , Pin assignment" "GPIO,eTPU_B[13],eTPU_B[29],eTPU_B[13],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x1a 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x1a 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x1a 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x1a 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x1a 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x1a 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x1a 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x1c "PCR161,Pad Configuration Register 161"
  bitfld.word 0x1c 10.--13.       "PA , Pin assignment" "GPIO,eTPU_B[14],eTPU_B[30],eTPU_B[14],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x1c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x1c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x1c 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x1c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x1c 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x1c 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x1c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x1e "PCR162,Pad Configuration Register 162"
  bitfld.word 0x1e 10.--13.       "PA , Pin assignment" "GPIO,eTPU_B[15],eTPU_B[31],eTPU_B[15],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x1e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x1e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x1e 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x1e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x1e 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x1e 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x1e 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90186++0x07 "PCR163-166: eTPU_B / DSPI_A"
  line.word 0x00 "PCR163,Pad Configuration Register 163"
  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "GPIO,eTPU_B[16],PCS_A[1],eTPU_B[16],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR164,Pad Configuration Register 164"
  bitfld.word 0x02 10.--13.       "PA , Pin assignment" "GPIO,eTPU_B[17],PCS_A[2],eTPU_B[17],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x02 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x04 "PCR165,Pad Configuration Register 165"
  bitfld.word 0x04 10.--13.       "PA , Pin assignment" "GPIO,eTPU_B[18],PCS_A[3],eTPU_B[18],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x04 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x04 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x04 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x04 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x04 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x04 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x04 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x06 "PCR166,Pad Configuration Register 166"
  bitfld.word 0x06 10.--13.       "PA , Pin assignment" "GPIO,eTPU_B[19],PCS_A[4],eTPU_B[19],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x06 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x06 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x06 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x06 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x06 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x06 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x06 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F9018E++0x17 "PCR167-178: eTPU_B"
  line.word 0x00 "PCR167,Pad Configuration Register 167"
  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "GPIO,eTPU_B[20],res.,eTPU_B[20],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR168,Pad Configuration Register 168"
  bitfld.word 0x02 10.--13.       "PA , Pin assignment" "GPIO,eTPU_B[21],res.,eTPU_B[21],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x02 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x04 "PCR169,Pad Configuration Register 169"
  bitfld.word 0x04 10.--13.       "PA , Pin assignment" "GPIO,eTPU_B[22],res.,eTPU_B[22],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x04 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x04 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x04 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x04 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x04 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x04 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x04 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x06 "PCR170,Pad Configuration Register 170"
  bitfld.word 0x06 10.--13.       "PA , Pin assignment" "GPIO,eTPU_B[23],res.,eTPU_B[23],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x06 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x06 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x06 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x06 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x06 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x06 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x06 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x08 "PCR171,Pad Configuration Register 171"
  bitfld.word 0x08 10.--13.       "PA , Pin assignment" "GPIO,eTPU_B[24],res.,eTPU_B[24],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x08 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x08 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x08 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x08 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x08 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x08 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x08 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0a "PCR172,Pad Configuration Register 172"
  bitfld.word 0x0a 10.--13.       "PA , Pin assignment" "GPIO,eTPU_B[25],res.,eTPU_B[25],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x0a 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0a 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0a 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x0a 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0a 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x0a 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0a 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0c "PCR173,Pad Configuration Register 173"
  bitfld.word 0x0c 10.--13.       "PA , Pin assignment" "GPIO,eTPU_B[26],res.,eTPU_B[26],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x0c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0c 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x0c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0c 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x0c 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0e "PCR174,Pad Configuration Register 174"
  bitfld.word 0x0e 10.--13.       "PA , Pin assignment" "GPIO,eTPU_B[27],res.,eTPU_B[27],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x0e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0e 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x0e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0e 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x0e 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0e 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x10 "PCR175,Pad Configuration Register 175"
  bitfld.word 0x10 10.--13.       "PA , Pin assignment" "GPIO,eTPU_B[28],res.,eTPU_B[28],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x10 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x10 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x10 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x10 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x10 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x10 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x10 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x12 "PCR176,Pad Configuration Register 176"
  bitfld.word 0x12 10.--13.       "PA , Pin assignment" "GPIO,eTPU_B[29],res.,eTPU_B[29],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x12 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x12 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x12 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x12 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x12 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x12 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x12 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x14 "PCR177,Pad Configuration Register 177"
  bitfld.word 0x14 10.--13.       "PA , Pin assignment" "GPIO,eTPU_B[30],res.,eTPU_B[30],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x14 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x14 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x14 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x14 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x14 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x14 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x14 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x16 "PCR178,Pad Configuration Register 178"
  bitfld.word 0x16 10.--13.       "PA , Pin assignment" "GPIO,eTPU_B[31],res.,eTPU_B[31],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x16 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x16 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x16 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x16 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x16 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x16 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x16 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F901A6++0x13 "PCR179-188: eMIOS / eTPU_A"
  line.word 0x00 "PCR179,Pad Configuration Register 179"
  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "GPIO,eMIOS[00],eTPU_A[00],eMIOS[00],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR180,Pad Configuration Register 180"
  bitfld.word 0x02 10.--13.       "PA , Pin assignment" "GPIO,eMIOS[01],eTPU_A[01],eMIOS[01],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x02 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x04 "PCR181,Pad Configuration Register 181"
  bitfld.word 0x04 10.--13.       "PA , Pin assignment" "GPIO,eMIOS[02],eTPU_A[02],eMIOS[02],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x04 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x04 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x04 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x04 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x04 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x04 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x04 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x06 "PCR182,Pad Configuration Register 182"
  bitfld.word 0x06 10.--13.       "PA , Pin assignment" "GPIO,eMIOS[03],eTPU_A[03],eMIOS[03],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x06 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x06 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x06 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x06 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x06 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x06 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x06 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x08 "PCR183,Pad Configuration Register 183"
  bitfld.word 0x08 10.--13.       "PA , Pin assignment" "GPIO,eMIOS[04],eTPU_A[04],eMIOS[04],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x08 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x08 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x08 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x08 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x08 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x08 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x08 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0a "PCR184,Pad Configuration Register 184"
  bitfld.word 0x0a 10.--13.       "PA , Pin assignment" "GPIO,eMIOS[05],eTPU_A[05],eMIOS[05],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x0a 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0a 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0a 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x0a 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0a 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x0a 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0a 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0c "PCR185,Pad Configuration Register 185"
  bitfld.word 0x0c 10.--13.       "PA , Pin assignment" "GPIO,eMIOS[06],eTPU_A[06],eMIOS[06],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x0c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0c 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x0c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0c 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x0c 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0e "PCR186,Pad Configuration Register 186"
  bitfld.word 0x0e 10.--13.       "PA , Pin assignment" "GPIO,eMIOS[07],eTPU_A[07],eMIOS[07],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x0e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0e 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x0e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0e 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x0e 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0e 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x10 "PCR187,Pad Configuration Register 187"
  bitfld.word 0x10 10.--13.       "PA , Pin assignment" "GPIO,eMIOS[08],eTPU_A[08],eMIOS[08],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x10 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x10 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x10 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x10 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x10 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x10 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x10 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x12 "PCR188,Pad Configuration Register 188"
  bitfld.word 0x12 10.--13.       "PA , Pin assignment" "GPIO,eMIOS[09],eTPU_A[09],eMIOS[09],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x12 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x12 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x12 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x12 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x12 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x12 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x12 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F901BA++0x13 "PCR189-190: eMIOS / DSPI_C / DSPI_D"
  line.word 0x00 "PCR189,Pad Configuration Register 189"
  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "GPIO,eMIOS[10],SCK_D,eMIOS[10],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR190,Pad Configuration Register 190"
  bitfld.word 0x02 10.--13.       "PA , Pin assignment" "GPIO,eMIOS[11],SIN_D,eMIOS[11],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x02 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x04 "PCR191,Pad Configuration Register 191"
  bitfld.word 0x04 10.--13.       "PA , Pin assignment" "GPIO,eMIOS[12],SOUT_C,eMIOS[12],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x04 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x04 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x04 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x04 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x04 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x04 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x04 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x06 "PCR192,Pad Configuration Register 192"
  bitfld.word 0x06 10.--13.       "PA , Pin assignment" "GPIO,eMIOS[12],SOUT_D,eMIOS[12],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x06 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x06 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x06 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x06 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x06 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x06 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x06 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F901C2++0x03 "PCR193-194: eMIOS / IRQ / CAN_D"
  line.word 0x00 "PCR193,Pad Configuration Register 193"
  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "GPIO,eMIOS[14],IRQ[00],eMIOS[14],CNTX_D,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR194,Pad Configuration Register 194"
  bitfld.word 0x02 10.--13.       "PA , Pin assignment" "GPIO,eMIOS[15],IRQ[01],eMIOS[15],CNRX_D,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x02 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F901C6++0x07 "PCR195-198: eMIOS / eTPU_B / FlexRay"
  line.word 0x00 "PCR195,Pad Configuration Register 195"
  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "GPIO,eMIOS[16],ETPU_B[0],eMIOS[16],FR_DBG[3],res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR196,Pad Configuration Register 196"
  bitfld.word 0x02 10.--13.       "PA , Pin assignment" "GPIO,eMIOS[17],ETPU_B[1],eMIOS[17],FR_DBG[2],res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x02 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x04 "PCR197,Pad Configuration Register 197"
  bitfld.word 0x04 10.--13.       "PA , Pin assignment" "GPIO,eMIOS[18],ETPU_B[2],eMIOS[18],FR_DBG[1],res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x04 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x04 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x04 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x04 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x04 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x04 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x04 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x06 "PCR198,Pad Configuration Register 198"
  bitfld.word 0x06 10.--13.       "PA , Pin assignment" "GPIO,eMIOS[19],ETPU_B[3],eMIOS[19],FR_DBG[0],res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x06 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x06 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x06 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x06 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x06 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x06 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x06 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F901CE++0x07 "PCR199-202: eMIOS / eTPU_B"
  line.word 0x00 "PCR199,Pad Configuration Register 199"
  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "GPIO,eMIOS[20],ETPU_B[4],eMIOS[20],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR200,Pad Configuration Register 200"
  bitfld.word 0x02 10.--13.       "PA , Pin assignment" "GPIO,eMIOS[21],ETPU_B[5],eMIOS[21],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x02 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x04 "PCR201,Pad Configuration Register 201"
  bitfld.word 0x04 10.--13.       "PA , Pin assignment" "GPIO,eMIOS[22],ETPU_B[6],eMIOS[22],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x04 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x04 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x04 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x04 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x04 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x04 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x04 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x06 "PCR202,Pad Configuration Register 202"
  bitfld.word 0x06 10.--13.       "PA , Pin assignment" "GPIO,eMIOS[23],ETPU_B[7],eMIOS[23],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x06 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x06 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x06 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x06 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x06 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x06 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x06 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F901D6++0x03 "PCR203-204: eMIOS / DSPI_B"
  line.word 0x00 "PCR203,Pad Configuration Register 203"
  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "GPIO,eMIOS[24],PCSB[0],eMIOS[24],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR204,Pad Configuration Register 204"
  bitfld.word 0x02 10.--13.       "PA , Pin assignment" "GPIO,eMIOS[25],PCSB[1],eMIOS[25],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x02 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"



group 0xC3F901E0++0x03 "PCR208-209: PLLCFG / IRQ[4:5] / DSPI_D"
  line.word 0x00 "PCR208,Pad Configuration Register 208"
  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "GPIO,PLLCFG0,IRQ[04],PLLCFG0,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR209,Pad Configuration Register 209"
  bitfld.word 0x02 10.--13.       "PA , Pin assignment" "GPIO,PLLCFG1,IRQ[05],PLLCFG1,SOUTD,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x02 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"



group 0xC3F901E6++0x03 "PCR211-212: BOOTCFG[0:1] / IRQ[2:3]"
  line.word 0x00 "PCR211,Pad Configuration Register 211"
  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "GPIO,BOOTCFG0,IRQ[02],BOOTCFG0,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR212,Pad Configuration Register 212"
  bitfld.word 0x02 10.--13.       "PA , Pin assignment" "GPIO,BOOTCFG1,IRQ[03],BOOTCFG1,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x02 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F901EA++0x01 "PCR213: WKPCFG / NMI"
  line.word 0x00 "PCR213,Pad Configuration Register 213"
  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "GPIO,WKPCFG,NMI,WKPCFG,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F901EC++0x01 "PCR214: ENGCLK"
  line.word 0x00 "PCR214,Pad Configuration Register 214"
  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "GPIO,ENGCLK,res.,ENGCLK,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F901F6++0x01 "PCR219: MCKO "
  line.word 0x00 "PCR219,Pad Configuration Register 219"
  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "MCKO,MCKO,res.,MCKO,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F901F8++0x09 "PCR220-223: MDO[0:3]"
  line.word 0x00 "PCR220,Pad Configuration Register 220"
  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "MDO0/GPIO,res.,res.,res.,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR221,Pad Configuration Register 221"
  bitfld.word 0x02 10.--13.       "PA , Pin assignment" "MDO1/GPIO,res.,res.,res.,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x02 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x04 "PCR222,Pad Configuration Register 222"
  bitfld.word 0x04 10.--13.       "PA , Pin assignment" "MDO2/GPIO,res.,res.,res.,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x04 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x04 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x04 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x04 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x04 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x04 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x04 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x06 "PCR223,Pad Configuration Register 223"
  bitfld.word 0x06 10.--13.       "PA , Pin assignment" "MDO3/GPIO,res.,res.,res.,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x06 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x06 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x06 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x06 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x06 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x06 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x06 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90200++0x03 "PCR224-225: MSEO[0:1]"
  line.word 0x00 "PCR224,Pad Configuration Register 224"
  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "MSEO0/GPIO,res.,res.,res.,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR225,Pad Configuration Register 225"
  bitfld.word 0x02 10.--13.       "PA , Pin assignment" "MSEO1/GPIO,res.,res.,res.,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x02 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90204++0x01 "PCR226: RDY"
  line.word 0x00 "PCR226,Pad Configuration Register 226"
  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "RDY,RDY,res.,RDY,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90206++0x01 "PCR227: EVTO "
  line.word 0x00 "PCR227,Pad Configuration Register 227"
  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "EVTO/GPIO,res.,res.,res.,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90208++0x01 "PCR228: TDO / eMIOS"
  line.word 0x00 "PCR228,Pad Configuration Register 228"
  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "TDO,res.,res.,res.,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F9020A++0x01 "PCR229: D_CLKOUT"
  line.word 0x00 "PCR229,Pad Configuration Register 229"
  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "D_CLKOUT,res.,res.,res.,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F9020C++0x01 "PCR230: RSTOUT"
  line.word 0x00 "PCR230,Pad Configuration Register 230"
  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "RSTOUT,res.,res.,res.,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F9020E++0x07 "PCR231-234: MDO[12:15]"
  line.word 0x00 "PCR231,Pad Configuration Register 231"
  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "MDO12/GPIO,res.,res.,res.,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR232,Pad Configuration Register 232"
  bitfld.word 0x02 10.--13.       "PA , Pin assignment" "MDO13/GPIO,res.,res.,res.,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x02 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x04 "PCR233,Pad Configuration Register 233"
  bitfld.word 0x04 10.--13.       "PA , Pin assignment" "MDO14/GPIO,res.,res.,res.,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x04 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x04 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x04 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x04 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x04 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x04 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x04 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x06 "PCR234,Pad Configuration Register 234"
  bitfld.word 0x06 10.--13.       "PA , Pin assignment" "MDO15/GPIO,res.,res.,res.,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x06 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x06 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x06 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x06 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x06 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x06 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x06 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90216++0x11 "PCR235-243: DSPI_C / EQADC_A SSI"
  line.word 0x00 "PCR235,Pad Configuration Register 235"
  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "GPIO,SCK_C,SCK_C_LVDS+,SCK_C,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR236,Pad Configuration Register 236"
  bitfld.word 0x02 10.--13.       "PA , Pin assignment" "GPIO,SIN_C,SCK_C_LVDS-,SIN_C,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x02 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x04 "PCR237,Pad Configuration Register 237"
  bitfld.word 0x04 10.--13.       "PA , Pin assignment" "GPIO,SOUT_C,SOUT_C_LVDS+,SOUT_C,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x04 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x04 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x04 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x04 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x04 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x04 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x04 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x06 "PCR238,Pad Configuration Register 238"
  bitfld.word 0x06 10.--13.       "PA , Pin assignment" "GPIO,PCS_C[0],SOUT_C_LVDS-,PCS_C[0],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x06 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x06 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x06 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x06 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x06 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x06 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x06 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x08 "PCR239,Pad Configuration Register 239"
  bitfld.word 0x08 10.--13.       "PA , Pin assignment" "GPIO,PCS_C[1],res.,PCS_C[1],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x08 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x08 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x08 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x08 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x08 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x08 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x08 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0a "PCR240,Pad Configuration Register 240"
  bitfld.word 0x0a 10.--13.       "PA , Pin assignment" "GPIO,PCS_C[2],SDS,PCS_C[2],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x0a 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0a 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0a 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x0a 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0a 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x0a 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0a 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0c "PCR241,Pad Configuration Register 241"
  bitfld.word 0x0c 10.--13.       "PA , Pin assignment" "GPIO,PCS_C[3],SDO,PCS_C[3],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x0c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0c 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x0c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0c 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x0c 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0e "PCR242,Pad Configuration Register 242"
  bitfld.word 0x0e 10.--13.       "PA , Pin assignment" "GPIO,PCS_C[4],SDI,PCS_C[4],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x0e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0e 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x0e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0e 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x0e 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0e 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x10 "PCR243,Pad Configuration Register 243"
  bitfld.word 0x10 10.--13.       "PA , Pin assignment" "GPIO,PCS_C[5],FCK,PCS_C[5],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x10 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x10 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x10 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x10 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x10 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x10 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x10 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90228++0x03 "PCR244-245: eSCI_C / EQADC_A"
  line.word 0x00 "PCR244,Pad Configuration Register 244"
  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "GPIO,TXDC,ETRIG0,TXDC,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR245,Pad Configuration Register 245"
  bitfld.word 0x02 10.--13.       "PA , Pin assignment" "GPIO,RXDC,res.,RXDC,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x02 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F9022C++0x03 "PCR246-247: CAN_D / EQADC_A"
  line.word 0x00 "PCR246,Pad Configuration Register 246"
  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "GPIO,CNTXD,res.,CNTXD,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR247,Pad Configuration Register 247"
  bitfld.word 0x02 10.--13.       "PA , Pin assignment" "GPIO,CNRXD,res.,CNRXD,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x02 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90230++0x0b "PCR248-253: FlexRay"
  line.word 0x00 "PCR248,Pad Configuration Register 248"
  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "GPIO,FR_A_TX,res.,FR_A_TX,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR249,Pad Configuration Register 249"
  bitfld.word 0x02 10.--13.       "PA , Pin assignment" "GPIO,FR_A_RX,res.,FR_A_RX,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x02 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x04 "PCR250,Pad Configuration Register 250"
  bitfld.word 0x04 10.--13.       "PA , Pin assignment" "GPIO,FR_A_TX_EN,res.,FR_A_TX_EN,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x04 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x04 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x04 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x04 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x04 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x04 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x04 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x06 "PCR251,Pad Configuration Register 251"
  bitfld.word 0x06 10.--13.       "PA , Pin assignment" "GPIO,FR_B_TX,res.,FR_B_TX,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x06 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x06 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x06 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x06 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x06 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x06 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x06 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x08 "PCR252,Pad Configuration Register 252"
  bitfld.word 0x08 10.--13.       "PA , Pin assignment" "GPIO,FR_B_RX,res.,FR_B_RX,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x08 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x08 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x08 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x08 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x08 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x08 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x08 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0a "PCR253,Pad Configuration Register 253"
  bitfld.word 0x0a 10.--13.       "PA , Pin assignment" "GPIO,FR_B_TX_EN,res.,FR_B_TX_EN,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x0a 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0a 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0a 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x0a 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0a 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x0a 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0a 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90240++0x05 "PCR256-258: EBI CS"
  line.word 0x00 "PCR256,Pad Configuration Register 256"
  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "GPIO,D_CS0,res.,D_CS0,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR257,Pad Configuration Register 257"
  bitfld.word 0x02 10.--13.       "PA , Pin assignment" "GPIO,D_CS2,D_ADD_DAT31,D_CS2,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x02 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x04 "PCR258,Pad Configuration Register 258"
  bitfld.word 0x04 10.--13.       "PA , Pin assignment" "GPIO,D_CS3,D_TEA,D_CS3,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x04 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x04 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x04 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x04 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x04 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x04 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x04 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90246++0x45 "PCR259-293: EBI ADD/ADD_DAT"
  line.word 0x00 "PCR259,Pad Configuration Register 259"
  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "GPIO,D_ADD[12],res.,D_ADD[12],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR260,Pad Configuration Register 260"
  bitfld.word 0x02 10.--13.       "PA , Pin assignment" "GPIO,D_ADD[13],res.,D_ADD[13],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x02 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x04 "PCR261,Pad Configuration Register 261"
  bitfld.word 0x04 10.--13.       "PA , Pin assignment" "GPIO,D_ADD[14],res.,D_ADD[14],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x04 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x04 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x04 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x04 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x04 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x04 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x04 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x06 "PCR262,Pad Configuration Register 262"
  bitfld.word 0x06 10.--13.       "PA , Pin assignment" "GPIO,D_ADD[15],res.,D_ADD[15],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x06 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x06 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x06 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x06 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x06 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x06 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x06 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x08 "PCR263,Pad Configuration Register 263"
  bitfld.word 0x08 10.--13.       "PA , Pin assignment" "GPIO,D_ADD[16],D_ADD_DAT[16],D_ADD[16],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x08 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x08 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x08 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x08 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x08 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x08 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x08 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0a "PCR264,Pad Configuration Register 264"
  bitfld.word 0x0a 10.--13.       "PA , Pin assignment" "GPIO,D_ADD[17],D_ADD_DAT[17],D_ADD[17],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x0a 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0a 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0a 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x0a 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x0a 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0a 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0a 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0c "PCR265,Pad Configuration Register 265"
  bitfld.word 0x0c 10.--13.       "PA , Pin assignment" "GPIO,D_ADD[18],D_ADD_DAT[18],D_ADD[18],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x0c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0c 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x0c 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x0c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0c 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0e "PCR266,Pad Configuration Register 266"
  bitfld.word 0x0e 10.--13.       "PA , Pin assignment" "GPIO,D_ADD[19],D_ADD_DAT[19],D_ADD[19],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x0e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0e 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x0e 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x0e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0e 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0e 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x10 "PCR267,Pad Configuration Register 267"
  bitfld.word 0x10 10.--13.       "PA , Pin assignment" "GPIO,D_ADD[20],D_ADD_DAT[20],D_ADD[20],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x10 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x10 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x10 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x10 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x10 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x10 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x10 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x12 "PCR268,Pad Configuration Register 268"
  bitfld.word 0x12 10.--13.       "PA , Pin assignment" "GPIO,D_ADD[21],D_ADD_DAT[21],D_ADD[21],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x12 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x12 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x12 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x12 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x12 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x12 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x12 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x14 "PCR269,Pad Configuration Register 269"
  bitfld.word 0x14 10.--13.       "PA , Pin assignment" "GPIO,D_ADD[22],D_ADD_DAT[22],D_ADD[22],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x14 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x14 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x14 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x14 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x14 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x14 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x14 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x16 "PCR270,Pad Configuration Register 270"
  bitfld.word 0x16 10.--13.       "PA , Pin assignment" "GPIO,D_ADD[23],D_ADD_DAT[23],D_ADD[23],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x16 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x16 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x16 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x16 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x16 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x16 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x16 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x18 "PCR271,Pad Configuration Register 271"
  bitfld.word 0x18 10.--13.       "PA , Pin assignment" "GPIO,D_ADD[24],D_ADD_DAT[24],D_ADD[24],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x18 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x18 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x18 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x18 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x18 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x18 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x18 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x1a "PCR272,Pad Configuration Register 272"
  bitfld.word 0x1a 10.--13.       "PA , Pin assignment" "GPIO,D_ADD[25],D_ADD_DAT[25],D_ADD[25],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x1a 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x1a 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x1a 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x1a 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x1a 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x1a 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x1a 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x1c "PCR273,Pad Configuration Register 273"
  bitfld.word 0x1c 10.--13.       "PA , Pin assignment" "GPIO,D_ADD[26],D_ADD_DAT[26],D_ADD[26],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x1c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x1c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x1c 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x1c 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x1c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x1c 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x1c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x1e "PCR274,Pad Configuration Register 274"
  bitfld.word 0x1e 10.--13.       "PA , Pin assignment" "GPIO,D_ADD[27],D_ADD_DAT[27],D_ADD[27],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x1e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x1e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x1e 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x1e 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x1e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x1e 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x1e 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x20 "PCR275,Pad Configuration Register 275"
  bitfld.word 0x20 10.--13.       "PA , Pin assignment" "GPIO,D_ADD[28],D_ADD_DAT[28],D_ADD[28],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x20 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x20 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x20 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x20 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x20 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x20 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x20 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x22 "PCR276,Pad Configuration Register 276"
  bitfld.word 0x22 10.--13.       "PA , Pin assignment" "GPIO,D_ADD[29],D_ADD_DAT[29],D_ADD[29],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x22 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x22 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x22 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x22 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x22 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x22 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x22 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x24 "PCR277,Pad Configuration Register 277"
  bitfld.word 0x24 10.--13.       "PA , Pin assignment" "GPIO,D_ADD[30],D_ADD_DAT[30],D_ADD[30],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x24 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x24 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x24 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x24 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x24 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x24 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x24 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x26 "PCR278,Pad Configuration Register 278"
  bitfld.word 0x26 10.--13.       "PA , Pin assignment" "GPIO,D_ADD_DAT[00],res.,D_ADD_DAT[00],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x26 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x26 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x26 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x26 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x26 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x26 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x26 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x28 "PCR279,Pad Configuration Register 279"
  bitfld.word 0x28 10.--13.       "PA , Pin assignment" "GPIO,D_ADD_DAT[01],res.,D_ADD_DAT[01],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x28 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x28 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x28 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x28 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x28 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x28 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x28 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x2a "PCR280,Pad Configuration Register 280"
  bitfld.word 0x2a 10.--13.       "PA , Pin assignment" "GPIO,D_ADD_DAT[02],res.,D_ADD_DAT[02],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x2a 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x2a 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x2a 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x2a 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x2a 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x2a 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x2a 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x2c "PCR281,Pad Configuration Register 281"
  bitfld.word 0x2c 10.--13.       "PA , Pin assignment" "GPIO,D_ADD_DAT[03],res.,D_ADD_DAT[03],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x2c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x2c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x2c 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x2c 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x2c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x2c 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x2c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x2e "PCR282,Pad Configuration Register 282"
  bitfld.word 0x2e 10.--13.       "PA , Pin assignment" "GPIO,D_ADD_DAT[04],res.,D_ADD_DAT[04],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x2e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x2e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x2e 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x2e 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x2e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x2e 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x2e 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x30 "PCR283,Pad Configuration Register 283"
  bitfld.word 0x30 10.--13.       "PA , Pin assignment" "GPIO,D_ADD_DAT[05],res.,D_ADD_DAT[05],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x30 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x30 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x30 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x30 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x30 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x30 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x30 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x32 "PCR284,Pad Configuration Register 284"
  bitfld.word 0x32 10.--13.       "PA , Pin assignment" "GPIO,D_ADD_DAT[06],res.,D_ADD_DAT[06],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x32 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x32 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x32 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x32 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x32 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x32 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x32 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x34 "PCR285,Pad Configuration Register 285"
  bitfld.word 0x34 10.--13.       "PA , Pin assignment" "GPIO,D_ADD_DAT[07],res.,D_ADD_DAT[07],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x34 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x34 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x34 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x34 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x34 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x34 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x34 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x36 "PCR286,Pad Configuration Register 286"
  bitfld.word 0x36 10.--13.       "PA , Pin assignment" "GPIO,D_ADD_DAT[08],res.,D_ADD_DAT[08],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x36 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x36 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x36 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x36 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x36 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x36 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x36 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x38 "PCR287,Pad Configuration Register 287"
  bitfld.word 0x38 10.--13.       "PA , Pin assignment" "GPIO,D_ADD_DAT[09],res.,D_ADD_DAT[09],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x38 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x38 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x38 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x38 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x38 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x38 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x38 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x3a "PCR288,Pad Configuration Register 288"
  bitfld.word 0x3a 10.--13.       "PA , Pin assignment" "GPIO,D_ADD_DAT[10],res.,D_ADD_DAT[10],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x3a 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x3a 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x3a 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x3a 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x3a 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x3a 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x3a 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x3c "PCR289,Pad Configuration Register 289"
  bitfld.word 0x3c 10.--13.       "PA , Pin assignment" "GPIO,D_ADD_DAT[11],res.,D_ADD_DAT[11],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x3c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x3c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x3c 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x3c 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x3c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x3c 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x3c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x3e "PCR290,Pad Configuration Register 290"
  bitfld.word 0x3e 10.--13.       "PA , Pin assignment" "GPIO,D_ADD_DAT[12],res.,D_ADD_DAT[12],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x3e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x3e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x3e 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x3e 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x3e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x3e 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x3e 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x40 "PCR291,Pad Configuration Register 291"
  bitfld.word 0x40 10.--13.       "PA , Pin assignment" "GPIO,D_ADD_DAT[13],res.,D_ADD_DAT[13],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x40 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x40 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x40 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x40 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x40 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x40 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x40 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x42 "PCR292,Pad Configuration Register 292"
  bitfld.word 0x42 10.--13.       "PA , Pin assignment" "GPIO,D_ADD_DAT[14],res.,D_ADD_DAT[14],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x42 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x42 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x42 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x42 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x42 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x42 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x42 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x44 "PCR293,Pad Configuration Register 293"
  bitfld.word 0x44 10.--13.       "PA , Pin assignment" "GPIO,D_ADD_DAT[15],res.,D_ADD_DAT[15],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x44 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x44 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x44 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x44 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x44 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x44 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x44 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F9028C++0x15 "PCR294-304: EBI STAT"
  line.word 0x00 "PCR294,Pad Configuration Register 294"
  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "GPIO,D_RD_WR,res.,D_RD_WR,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR295,Pad Configuration Register 295"
  bitfld.word 0x02 10.--13.       "PA , Pin assignment" "GPIO,D_WE[0],res.,D_WE[0],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x02 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x04 "PCR296,Pad Configuration Register 296"
  bitfld.word 0x04 10.--13.       "PA , Pin assignment" "GPIO,D_WE[1],res.,D_WE[1],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x04 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x04 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x04 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x04 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x04 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x04 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x04 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x06 "PCR297,Pad Configuration Register 297"
  bitfld.word 0x06 10.--13.       "PA , Pin assignment" "GPIO,D_OE,res.,D_OE,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x06 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x06 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x06 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x06 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x06 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x06 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x06 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x08 "PCR298,Pad Configuration Register 298"
  bitfld.word 0x08 10.--13.       "PA , Pin assignment" "GPIO,D_TS,res.,D_TS,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x08 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x08 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x08 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x08 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x08 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x08 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x08 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0a "PCR299,Pad Configuration Register 299"
  bitfld.word 0x0a 10.--13.       "PA , Pin assignment" "GPIO,D_ALE,res.,D_ALE,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x0a 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0a 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0a 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x0a 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x0a 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0a 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0a 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0c "PCR300,Pad Configuration Register 300"
  bitfld.word 0x0c 10.--13.       "PA , Pin assignment" "GPIO,D_TA,res.,D_TA,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x0c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0c 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x0c 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x0c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0c 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0e "PCR301,Pad Configuration Register 301"
  bitfld.word 0x0e 10.--13.       "PA , Pin assignment" "GPIO,D_CS1,res.,D_CS1,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x0e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0e 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x0e 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x0e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0e 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0e 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x10 "PCR302,Pad Configuration Register 302"
  bitfld.word 0x10 10.--13.       "PA , Pin assignment" "GPIO,D_BDIP,res.,D_BDIP,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x10 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x10 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x10 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x10 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x10 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x10 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x10 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x12 "PCR303,Pad Configuration Register 303"
  bitfld.word 0x12 10.--13.       "PA , Pin assignment" "GPIO,D_WE[2],res.,D_WE[2],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x12 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x12 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x12 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x12 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x12 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x12 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x12 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x14 "PCR304,Pad Configuration Register 304"
  bitfld.word 0x14 10.--13.       "PA , Pin assignment" "GPIO,D_WE[3],res.,D_WE[3],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x14 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x14 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x14 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x14 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x14 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x14 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x14 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F902A2++0x05 "PCR305-307: EBI ADD"
  line.word 0x00 "PCR305,Pad Configuration Register 305"
  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "GPIO,D_ADD[09],res.,D_ADD[09],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR306,Pad Configuration Register 306"
  bitfld.word 0x02 10.--13.       "PA , Pin assignment" "GPIO,D_ADD[10],res.,D_ADD[10],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x02 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x04 "PCR307,Pad Configuration Register 307"
  bitfld.word 0x04 10.--13.       "PA , Pin assignment" "GPIO,D_ADD[11],res.,D_ADD[11],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x04 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x04 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x04 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x04 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x04 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x04 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x04 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F903A0++0x0b "PCR432-437: eMIOS / DSPI_B / DSPI_C"
  line.word 0x00 "PCR432,Pad Configuration Register 432"
  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "GPIO,EMIOS[26],PCS_B[2],EMIOS[26],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR433,Pad Configuration Register 433"
  bitfld.word 0x02 10.--13.       "PA , Pin assignment" "GPIO,EMIOS[27],PCS_B[3],EMIOS[27],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x02 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x04 "PCR434,Pad Configuration Register 434"
  bitfld.word 0x04 10.--13.       "PA , Pin assignment" "GPIO,EMIOS[28],PCS_C[0],EMIOS[28],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x04 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x04 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x04 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x04 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x04 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x04 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x04 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x06 "PCR435,Pad Configuration Register 435"
  bitfld.word 0x06 10.--13.       "PA , Pin assignment" "GPIO,EMIOS[29],PCS_C[1],EMIOS[29],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x06 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x06 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x06 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x06 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x06 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x06 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x06 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x08 "PCR436,Pad Configuration Register 436"
  bitfld.word 0x08 10.--13.       "PA , Pin assignment" "GPIO,EMIOS[30],PCS_C[2],EMIOS[30],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x08 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x08 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x08 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x08 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x08 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x08 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x08 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0a "PCR437,Pad Configuration Register 437"
  bitfld.word 0x0a 10.--13.       "PA , Pin assignment" "GPIO,EMIOS[31],PCS_C[5],EMIOS[31],res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x0a 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0a 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0a 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x0a 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0a 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x0a 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0a 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F903B0++0x01 "PCR440: TCRCLKC"
  line.word 0x00 "PCR440,Pad Configuration Register 440"
  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "GPIO,TCRCLKC,res.,TCRCLKC,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F903B2++0x11 "PCR441-449: GPIO only"
  line.word 0x00 "PCR441,Pad Configuration Register 441"
  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "GPIO,res.,res.,res.,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR442,Pad Configuration Register 442"
  bitfld.word 0x02 10.--13.       "PA , Pin assignment" "GPIO,res.,res.,res.,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x02 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x04 "PCR443,Pad Configuration Register 443"
  bitfld.word 0x04 10.--13.       "PA , Pin assignment" "GPIO,res.,res.,res.,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x04 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x04 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x04 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x04 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x04 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x04 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x04 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x06 "PCR444,Pad Configuration Register 444"
  bitfld.word 0x06 10.--13.       "PA , Pin assignment" "GPIO,res.,res.,res.,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x06 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x06 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x06 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x06 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x06 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x06 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x06 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x08 "PCR445,Pad Configuration Register 445"
  bitfld.word 0x08 10.--13.       "PA , Pin assignment" "GPIO,res.,res.,res.,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x08 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x08 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x08 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x08 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x08 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x08 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x08 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0a "PCR446,Pad Configuration Register 446"
  bitfld.word 0x0a 10.--13.       "PA , Pin assignment" "GPIO,res.,res.,res.,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x0a 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0a 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0a 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x0a 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0a 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x0a 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0a 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0c "PCR447,Pad Configuration Register 447"
  bitfld.word 0x0c 10.--13.       "PA , Pin assignment" "GPIO,res.,res.,res.,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x0c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0c 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x0c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0c 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x0c 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0e "PCR448,Pad Configuration Register 448"
  bitfld.word 0x0e 10.--13.       "PA , Pin assignment" "GPIO,res.,res.,res.,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x0e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0e 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x0e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0e 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x0e 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0e 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x10 "PCR449,Pad Configuration Register 449"
  bitfld.word 0x10 10.--13.       "PA , Pin assignment" "GPIO,res.,res.,res.,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x10 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x10 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x10 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x10 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x10 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x10 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x10 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F903C4++0x0d "PCR450-456: IRQ[0:5]"
  line.word 0x00 "PCR450,Pad Configuration Register 450"
  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "GPIO,res.,IRQ[0],res.,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR451,Pad Configuration Register 451"
  bitfld.word 0x02 10.--13.       "PA , Pin assignment" "GPIO,res.,IRQ[1],res.,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x02 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x04 "PCR452,Pad Configuration Register 452"
  bitfld.word 0x04 10.--13.       "PA , Pin assignment" "GPIO,res.,IRQ[2],res.,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x04 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x04 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x04 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x04 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x04 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x04 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x04 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x06 "PCR453,Pad Configuration Register 453"
  bitfld.word 0x06 10.--13.       "PA , Pin assignment" "GPIO,res.,IRQ[3],res.,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x06 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x06 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x06 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x06 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x06 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x06 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x06 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x08 "PCR454,Pad Configuration Register 454"
  bitfld.word 0x08 10.--13.       "PA , Pin assignment" "GPIO,res.,IRQ[4],res.,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x08 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x08 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x08 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x08 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x08 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x08 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x08 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0a "PCR455,Pad Configuration Register 455"
  bitfld.word 0x0a 10.--13.       "PA , Pin assignment" "GPIO,res.,IRQ[5],res.,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x0a 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0a 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0a 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x0a 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0a 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x0a 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0a 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0c "PCR456,Pad Configuration Register 456"
  bitfld.word 0x0c 10.--13.       "PA , Pin assignment" "GPIO,res.,res.,res.,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x0c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0c 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x0c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0c 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x0c 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0c 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F903d2++0x05 "PCR457-459: FlexRay"
  line.word 0x00 "PCR457,Pad Configuration Register 457"
  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "GPIO,res.,FR_A_TX,res.,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR458,Pad Configuration Register 458"
  bitfld.word 0x02 10.--13.       "PA , Pin assignment" "GPIO,res.,FR_A_RX,res.,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x02 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x04 "PCR459,Pad Configuration Register 459"
  bitfld.word 0x04 10.--13.       "PA , Pin assignment" "GPIO,res.,FR_A_TX_EN,res.,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x04 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x04 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x04 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x04 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x04 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x04 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x04 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F903d8++0x07 "PCR460-463: eSCI_A"
  line.word 0x00 "PCR460,Pad Configuration Register 460"
  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "GPIO,res.,TXDA,res.,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR461,Pad Configuration Register 461"
  bitfld.word 0x02 10.--13.       "PA , Pin assignment" "GPIO,res.,RXDA,res.,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x02 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x04 "PCR462,Pad Configuration Register 462"
  bitfld.word 0x04 10.--13.       "PA , Pin assignment" "GPIO,res.,TXDB,res.,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x04 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x04 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x04 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x04 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x04 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x04 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x04 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x06 "PCR463,Pad Configuration Register 463"
  bitfld.word 0x06 10.--13.       "PA , Pin assignment" "GPIO,res.,RXDB,res.,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x06 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x06 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x06 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x06 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x06 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x06 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x06 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F903e0++0x11 "PCR464-472: DSPI_D / MA"
  line.word 0x00 "PCR464,Pad Configuration Register 464"
  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "GPIO,res.,PCS_D[5],res.,MA_A[0],res.,res.,res.           ,MA_B[0],res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR465,Pad Configuration Register 465"
  bitfld.word 0x02 10.--13.       "PA , Pin assignment" "GPIO,res.,PCS_D[4],res.,MA_A[1],res.,res.,res.           ,MA_B[1],res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x02 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x04 "PCR466,Pad Configuration Register 466"
  bitfld.word 0x04 10.--13.       "PA , Pin assignment" "GPIO,res.,PCS_D[3],res.,MA_A[2],res.,res.,res.           ,MA_B[2],res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x04 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x04 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x04 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x04 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x04 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x04 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x04 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x06 "PCR467,Pad Configuration Register 467"
  bitfld.word 0x06 10.--13.       "PA , Pin assignment" "GPIO,res.,PCS_D[2],res.,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x06 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x06 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x06 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x06 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x06 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x06 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x06 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x08 "PCR468,Pad Configuration Register 468"
  bitfld.word 0x08 10.--13.       "PA , Pin assignment" "GPIO,res.,PCS_D[1],res.,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x08 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x08 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x08 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x08 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x08 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x08 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x08 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0a "PCR469,Pad Configuration Register 469"
  bitfld.word 0x0a 10.--13.       "PA , Pin assignment" "GPIO,res.,PCS_D[0],res.,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x0a 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0a 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0a 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x0a 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0a 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x0a 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0a 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0c "PCR470,Pad Configuration Register 470"
  bitfld.word 0x0c 10.--13.       "PA , Pin assignment" "GPIO,res.,SCKD,res.,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x0c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0c 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x0c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0c 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x0c 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0e "PCR471,Pad Configuration Register 471"
  bitfld.word 0x0e 10.--13.       "PA , Pin assignment" "GPIO,res.,SOUTD,res.,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x0e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0e 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x0e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0e 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x0e 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0e 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x10 "PCR472,Pad Configuration Register 472"
  bitfld.word 0x10 10.--13.       "PA , Pin assignment" "GPIO,res.,SIND,res.,res.,res.,res.,res.           ,res.,res.,res.,res.,res.,res.,res.,res."
  bitfld.word 0x10 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x10 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x10 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x10 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x10 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x10 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x10 00.            "  WPS , Weak pull up/down select" "0,1"



endif

tree.end


tree "GPIO Pin Data Output Registers"

group.long 0xC3F90600++0x03
  line.long    0x00 "000-003,GPIO Pin Data Out Register 000-003"
  bitfld.long  0x00 24.                  "PDO000 ,Pin 000 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO001 ,Pin 001 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO002 ,Pin 002 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO003 ,Pin 003 data out" "L,H"
group.long 0xC3F90604++0x03
  line.long    0x00 "004-007,GPIO Pin Data Out Register 004-007"
  bitfld.long  0x00 24.                  "PDO004 ,Pin 004 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO005 ,Pin 005 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO006 ,Pin 006 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO007 ,Pin 007 data out" "L,H"
group.long 0xC3F90608++0x03
  line.long    0x00 "008-011,GPIO Pin Data Out Register 008-011"
  bitfld.long  0x00 24.                  "PDO008 ,Pin 008 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO009 ,Pin 009 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO010 ,Pin 010 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO011 ,Pin 011 data out" "L,H"
group.long 0xC3F9060c++0x03
  line.long    0x00 "012-015,GPIO Pin Data Out Register 012-015"
  bitfld.long  0x00 24.                  "PDO012 ,Pin 012 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO013 ,Pin 013 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO014 ,Pin 014 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO015 ,Pin 015 data out" "L,H"
group.long 0xC3F90610++0x03
  line.long    0x00 "016-019,GPIO Pin Data Out Register 016-019"
  bitfld.long  0x00 24.                  "PDO016 ,Pin 016 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO017 ,Pin 017 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO018 ,Pin 018 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO019 ,Pin 019 data out" "L,H"
group.long 0xC3F90614++0x03
  line.long    0x00 "020-023,GPIO Pin Data Out Register 020-023"
  bitfld.long  0x00 24.                  "PDO020 ,Pin 020 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO021 ,Pin 021 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO022 ,Pin 022 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO023 ,Pin 023 data out" "L,H"
group.long 0xC3F90618++0x03
  line.long    0x00 "024-027,GPIO Pin Data Out Register 024-027"
  bitfld.long  0x00 24.                  "PDO024 ,Pin 024 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO025 ,Pin 025 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO026 ,Pin 026 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO027 ,Pin 027 data out" "L,H"
group.long 0xC3F9061c++0x03
  line.long    0x00 "028-031,GPIO Pin Data Out Register 028-031"
  bitfld.long  0x00 24.                  "PDO028 ,Pin 028 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO029 ,Pin 029 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO030 ,Pin 030 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO031 ,Pin 031 data out" "L,H"
group.long 0xC3F90620++0x03
  line.long    0x00 "032-035,GPIO Pin Data Out Register 032-035"
  bitfld.long  0x00 24.                  "PDO032 ,Pin 032 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO033 ,Pin 033 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO034 ,Pin 034 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO035 ,Pin 035 data out" "L,H"
group.long 0xC3F90624++0x03
  line.long    0x00 "036-039,GPIO Pin Data Out Register 036-039"
  bitfld.long  0x00 24.                  "PDO036 ,Pin 036 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO037 ,Pin 037 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO038 ,Pin 038 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO039 ,Pin 039 data out" "L,H"
group.long 0xC3F90628++0x03
  line.long    0x00 "040-043,GPIO Pin Data Out Register 040-043"
  bitfld.long  0x00 24.                  "PDO040 ,Pin 040 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO041 ,Pin 041 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO042 ,Pin 042 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO043 ,Pin 043 data out" "L,H"
group.long 0xC3F9062c++0x03
  line.long    0x00 "044-047,GPIO Pin Data Out Register 044-047"
  bitfld.long  0x00 24.                  "PDO044 ,Pin 044 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO045 ,Pin 045 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO046 ,Pin 046 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO047 ,Pin 047 data out" "L,H"
group.long 0xC3F90630++0x03
  line.long    0x00 "048-051,GPIO Pin Data Out Register 048-051"
  bitfld.long  0x00 24.                  "PDO048 ,Pin 048 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO049 ,Pin 049 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO050 ,Pin 050 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO051 ,Pin 051 data out" "L,H"
group.long 0xC3F90634++0x03
  line.long    0x00 "052-055,GPIO Pin Data Out Register 052-055"
  bitfld.long  0x00 24.                  "PDO052 ,Pin 052 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO053 ,Pin 053 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO054 ,Pin 054 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO055 ,Pin 055 data out" "L,H"
group.long 0xC3F90638++0x03
  line.long    0x00 "056-059,GPIO Pin Data Out Register 056-059"
  bitfld.long  0x00 24.                  "PDO056 ,Pin 056 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO057 ,Pin 057 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO058 ,Pin 058 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO059 ,Pin 059 data out" "L,H"
group.long 0xC3F9063c++0x03
  line.long    0x00 "060-063,GPIO Pin Data Out Register 060-063"
  bitfld.long  0x00 24.                  "PDO060 ,Pin 060 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO061 ,Pin 061 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO062 ,Pin 062 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO063 ,Pin 063 data out" "L,H"
group.long 0xC3F90640++0x03
  line.long    0x00 "064-067,GPIO Pin Data Out Register 064-067"
  bitfld.long  0x00 24.                  "PDO064 ,Pin 064 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO065 ,Pin 065 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO066 ,Pin 066 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO067 ,Pin 067 data out" "L,H"
group.long 0xC3F90644++0x03
  line.long    0x00 "068-071,GPIO Pin Data Out Register 068-071"
  bitfld.long  0x00 24.                  "PDO068 ,Pin 068 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO069 ,Pin 069 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO070 ,Pin 070 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO071 ,Pin 071 data out" "L,H"
group.long 0xC3F90648++0x03
  line.long    0x00 "072-075,GPIO Pin Data Out Register 072-075"
  bitfld.long  0x00 24.                  "PDO072 ,Pin 072 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO073 ,Pin 073 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO074 ,Pin 074 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO075 ,Pin 075 data out" "L,H"
group.long 0xC3F9064c++0x03
  line.long    0x00 "076-079,GPIO Pin Data Out Register 076-079"
  bitfld.long  0x00 24.                  "PDO076 ,Pin 076 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO077 ,Pin 077 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO078 ,Pin 078 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO079 ,Pin 079 data out" "L,H"
group.long 0xC3F90650++0x03
  line.long    0x00 "080-083,GPIO Pin Data Out Register 080-083"
  bitfld.long  0x00 24.                  "PDO080 ,Pin 080 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO081 ,Pin 081 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO082 ,Pin 082 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO083 ,Pin 083 data out" "L,H"
group.long 0xC3F90654++0x03
  line.long    0x00 "084-087,GPIO Pin Data Out Register 084-087"
  bitfld.long  0x00 24.                  "PDO084 ,Pin 084 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO085 ,Pin 085 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO086 ,Pin 086 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO087 ,Pin 087 data out" "L,H"
group.long 0xC3F90658++0x03
  line.long    0x00 "088-091,GPIO Pin Data Out Register 088-091"
  bitfld.long  0x00 24.                  "PDO088 ,Pin 088 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO089 ,Pin 089 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO090 ,Pin 090 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO091 ,Pin 091 data out" "L,H"
group.long 0xC3F9065c++0x03
  line.long    0x00 "092-095,GPIO Pin Data Out Register 092-095"
  bitfld.long  0x00 24.                  "PDO092 ,Pin 092 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO093 ,Pin 093 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO094 ,Pin 094 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO095 ,Pin 095 data out" "L,H"
group.long 0xC3F90660++0x03
  line.long    0x00 "096-099,GPIO Pin Data Out Register 096-099"
  bitfld.long  0x00 24.                  "PDO096 ,Pin 096 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO097 ,Pin 097 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO098 ,Pin 098 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO099 ,Pin 099 data out" "L,H"

group.long 0xC3F90664++0x03
  line.long    0x00 "100-103,GPIO Pin Data Out Register 100-103"
  bitfld.long  0x00 24.                  "PDO100 ,Pin 100 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO101 ,Pin 101 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO102 ,Pin 102 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO103 ,Pin 103 data out" "L,H"
group.long 0xC3F90668++0x03
  line.long    0x00 "104-107,GPIO Pin Data Out Register 104-107"
  bitfld.long  0x00 24.                  "PDO104 ,Pin 104 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO105 ,Pin 105 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO106 ,Pin 106 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO107 ,Pin 107 data out" "L,H"
group.long 0xC3F9066C++0x03
  line.long    0x00 "108-111,GPIO Pin Data Out Register 108-111"
  bitfld.long  0x00 24.                  "PDO108 ,Pin 108 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO109 ,Pin 109 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO110 ,Pin 110 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO111 ,Pin 111 data out" "L,H"
group.long 0xC3F90670++0x03
  line.long    0x00 "112-115,GPIO Pin Data Out Register 112-115"
  bitfld.long  0x00 24.                  "PDO112 ,Pin 112 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO113 ,Pin 113 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO114 ,Pin 114 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO115 ,Pin 115 data out" "L,H"
group.long 0xC3F90674++0x03
  line.long    0x00 "116-119,GPIO Pin Data Out Register 116-119"
  bitfld.long  0x00 24.                  "PDO116 ,Pin 116 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO117 ,Pin 117 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO118 ,Pin 118 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO119 ,Pin 119 data out" "L,H"
group.long 0xC3F90678++0x03
  line.long    0x00 "120-123,GPIO Pin Data Out Register 120-123"
  bitfld.long  0x00 24.                  "PDO120 ,Pin 120 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO121 ,Pin 121 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO122 ,Pin 122 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO123 ,Pin 123 data out" "L,H"
group.long 0xC3F9067C++0x03
  line.long    0x00 "124-127,GPIO Pin Data Out Register 124-127"
  bitfld.long  0x00 24.                  "PDO124 ,Pin 124 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO125 ,Pin 125 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO126 ,Pin 126 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO127 ,Pin 127 data out" "L,H"
group.long 0xC3F90680++0x03
  line.long    0x00 "128-131,GPIO Pin Data Out Register 128-131"
  bitfld.long  0x00 24.                  "PDO128 ,Pin 128 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO129 ,Pin 129 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO130 ,Pin 130 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO131 ,Pin 131 data out" "L,H"
group.long 0xC3F90684++0x03
  line.long    0x00 "132-135,GPIO Pin Data Out Register 132-135"
  bitfld.long  0x00 24.                  "PDO132 ,Pin 132 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO133 ,Pin 133 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO134 ,Pin 134 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO135 ,Pin 135 data out" "L,H"
group.long 0xC3F90688++0x03
  line.long    0x00 "136-139,GPIO Pin Data Out Register 136-139"
  bitfld.long  0x00 24.                  "PDO136 ,Pin 136 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO137 ,Pin 137 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO138 ,Pin 138 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO139 ,Pin 139 data out" "L,H"
group.long 0xC3F9068C++0x03
  line.long    0x00 "140-143,GPIO Pin Data Out Register 140-143"
  bitfld.long  0x00 24.                  "PDO140 ,Pin 140 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO141 ,Pin 141 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO142 ,Pin 142 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO143 ,Pin 143 data out" "L,H"
group.long 0xC3F90690++0x03
  line.long    0x00 "144-147,GPIO Pin Data Out Register 144-147"
  bitfld.long  0x00 24.                  "PDO144 ,Pin 144 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO145 ,Pin 145 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO146 ,Pin 146 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO147 ,Pin 147 data out" "L,H"
group.long 0xC3F90694++0x03
  line.long    0x00 "148-151,GPIO Pin Data Out Register 148-151"
  bitfld.long  0x00 24.                  "PDO148 ,Pin 148 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO149 ,Pin 149 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO150 ,Pin 150 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO151 ,Pin 151 data out" "L,H"
group.long 0xC3F90698++0x03
  line.long    0x00 "152-155,GPIO Pin Data Out Register 152-155"
  bitfld.long  0x00 24.                  "PDO152 ,Pin 152 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO153 ,Pin 153 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO154 ,Pin 154 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO155 ,Pin 155 data out" "L,H"
group.long 0xC3F9069C++0x03
  line.long    0x00 "156-159,GPIO Pin Data Out Register 156-159"
  bitfld.long  0x00 24.                  "PDO156 ,Pin 156 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO157 ,Pin 157 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO158 ,Pin 158 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO159 ,Pin 159 data out" "L,H"
group.long 0xC3F906A0++0x03
  line.long    0x00 "160-163,GPIO Pin Data Out Register 160-163"
  bitfld.long  0x00 24.                  "PDO160 ,Pin 160 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO161 ,Pin 161 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO162 ,Pin 162 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO163 ,Pin 163 data out" "L,H"
group.long 0xC3F906A4++0x03
  line.long    0x00 "164-167,GPIO Pin Data Out Register 164-167"
  bitfld.long  0x00 24.                  "PDO164 ,Pin 164 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO165 ,Pin 165 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO166 ,Pin 166 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO167 ,Pin 167 data out" "L,H"
group.long 0xC3F906A8++0x03
  line.long    0x00 "168-171,GPIO Pin Data Out Register 168-171"
  bitfld.long  0x00 24.                  "PDO168 ,Pin 168 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO169 ,Pin 169 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO170 ,Pin 170 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO171 ,Pin 171 data out" "L,H"
group.long 0xC3F906AC++0x03
  line.long    0x00 "172-175,GPIO Pin Data Out Register 172-175"
  bitfld.long  0x00 24.                  "PDO172 ,Pin 172 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO173 ,Pin 173 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO174 ,Pin 174 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO175 ,Pin 175 data out" "L,H"
group.long 0xC3F906B0++0x03
  line.long    0x00 "176-179,GPIO Pin Data Out Register 176-179"
  bitfld.long  0x00 24.                  "PDO176 ,Pin 176 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO177 ,Pin 177 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO178 ,Pin 178 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO179 ,Pin 179 data out" "L,H"
group.long 0xC3F906B4++0x03
  line.long    0x00 "180-183,GPIO Pin Data Out Register 180-183"
  bitfld.long  0x00 24.                  "PDO180 ,Pin 180 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO181 ,Pin 181 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO182 ,Pin 182 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO183 ,Pin 183 data out" "L,H"
group.long 0xC3F906B8++0x03
  line.long    0x00 "184-187,GPIO Pin Data Out Register 184-187"
  bitfld.long  0x00 24.                  "PDO184 ,Pin 184 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO185 ,Pin 185 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO186 ,Pin 186 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO187 ,Pin 187 data out" "L,H"
group.long 0xC3F906BC++0x03
  line.long    0x00 "188-191,GPIO Pin Data Out Register 188-191"
  bitfld.long  0x00 24.                  "PDO188 ,Pin 188 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO189 ,Pin 189 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO190 ,Pin 190 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO191 ,Pin 191 data out" "L,H"
group.long 0xC3F906C0++0x03
  line.long    0x00 "192-195,GPIO Pin Data Out Register 192-195"
  bitfld.long  0x00 24.                  "PDO192 ,Pin 192 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO193 ,Pin 193 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO194 ,Pin 194 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO195 ,Pin 195 data out" "L,H"
group.long 0xC3F906C4++0x03
  line.long    0x00 "196-199,GPIO Pin Data Out Register 196-199"
  bitfld.long  0x00 24.                  "PDO196 ,Pin 196 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO197 ,Pin 197 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO198 ,Pin 198 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO199 ,Pin 199 data out" "L,H"
group.long 0xC3F906C8++0x03
  line.long    0x00 "200-203,GPIO Pin Data Out Register 200-203"
  bitfld.long  0x00 24.                  "PDO200 ,Pin 200 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO201 ,Pin 201 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO202 ,Pin 202 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO203 ,Pin 203 data out" "L,H"
group.long 0xC3F906CC++0x03
  line.long    0x00 "204-207,GPIO Pin Data Out Register 204-207"
  bitfld.long  0x00 24.                  "PDO204 ,Pin 204 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO205 ,Pin 205 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO206 ,Pin 206 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO207 ,Pin 207 data out" "L,H"
group.long 0xC3F906D0++0x03
  line.long    0x00 "208-211,GPIO Pin Data Out Register 208-211"
  bitfld.long  0x00 24.                  "PDO208 ,Pin 208 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO209 ,Pin 209 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO210 ,Pin 210 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO211 ,Pin 211 data out" "L,H"
group.long 0xC3F906D4++0x03
  line.long    0x00 "212-215,GPIO Pin Data Out Register 212-215"
  bitfld.long  0x00 24.                  "PDO212 ,Pin 212 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO213 ,Pin 213 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO214 ,Pin 214 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO215 ,Pin 215 data out" "L,H"
group.long 0xC3F906D8++0x03
  line.long    0x00 "216-219,GPIO Pin Data Out Register 216-219"
  bitfld.long  0x00 24.                  "PDO216 ,Pin 216 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO217 ,Pin 217 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO218 ,Pin 218 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO219 ,Pin 219 data out" "L,H"
group.long 0xC3F906DC++0x03
  line.long    0x00 "220-223,GPIO Pin Data Out Register 220-223"
  bitfld.long  0x00 24.                  "PDO220 ,Pin 220 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO221 ,Pin 221 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO222 ,Pin 222 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO223 ,Pin 223 data out" "L,H"
group.long 0xC3F906E0++0x03
  line.long    0x00 "224-227,GPIO Pin Data Out Register 224-227"
  bitfld.long  0x00 24.                  "PDO224 ,Pin 224 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO225 ,Pin 225 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO226 ,Pin 226 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO227 ,Pin 227 data out" "L,H"
group.long 0xC3F906E4++0x03
  line.long    0x00 "228-231,GPIO Pin Data Out Register 228-231"
  bitfld.long  0x00 24.                  "PDO228 ,Pin 228 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO229 ,Pin 229 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO230 ,Pin 230 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO231 ,Pin 231 data out" "L,H"
group.long 0xC3F906E8++0x03
  line.long    0x00 "232-235,GPIO Pin Data Out Register 232-235"
  bitfld.long  0x00 24.                  "PDO232 ,Pin 232 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO233 ,Pin 233 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO234 ,Pin 234 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO235 ,Pin 235 data out" "L,H"
group.long 0xC3F906EC++0x03
  line.long    0x00 "236-239,GPIO Pin Data Out Register 236-239"
  bitfld.long  0x00 24.                  "PDO236 ,Pin 236 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO237 ,Pin 237 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO238 ,Pin 238 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO239 ,Pin 239 data out" "L,H"
group.long 0xC3F906F0++0x03
  line.long    0x00 "240-243,GPIO Pin Data Out Register 240-243"
  bitfld.long  0x00 24.                  "PDO240 ,Pin 240 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO241 ,Pin 241 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO242 ,Pin 242 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO243 ,Pin 243 data out" "L,H"
group.long 0xC3F906F4++0x03
  line.long    0x00 "244-247,GPIO Pin Data Out Register 244-247"
  bitfld.long  0x00 24.                  "PDO244 ,Pin 244 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO245 ,Pin 245 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO246 ,Pin 246 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO247 ,Pin 247 data out" "L,H"
group.long 0xC3F906F8++0x03
  line.long    0x00 "248-251,GPIO Pin Data Out Register 248-251"
  bitfld.long  0x00 24.                  "PDO248 ,Pin 248 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO249 ,Pin 249 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO250 ,Pin 250 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO251 ,Pin 251 data out" "L,H"
group.long 0xC3F906FC++0x03
  line.long    0x00 "252-255,GPIO Pin Data Out Register 252-255"
  bitfld.long  0x00 24.                  "PDO252 ,Pin 252 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO253 ,Pin 253 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO254 ,Pin 254 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO255 ,Pin 255 data out" "L,H"

group.long 0xC3F90700++0x03
  line.long    0x00 "256-259,GPIO Pin Data Out Register 256-259"
  bitfld.long  0x00 24.                  "PDO256 ,Pin 256 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO257 ,Pin 257 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO258 ,Pin 258 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO259 ,Pin 259 data out" "L,H"
group.long 0xC3F90704++0x03
  line.long    0x00 "260-263,GPIO Pin Data Out Register 260-263"
  bitfld.long  0x00 24.                  "PDO260 ,Pin 260 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO261 ,Pin 261 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO262 ,Pin 262 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO263 ,Pin 263 data out" "L,H"
group.long 0xC3F90708++0x03
  line.long    0x00 "264-267,GPIO Pin Data Out Register 264-267"
  bitfld.long  0x00 24.                  "PDO264 ,Pin 264 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO265 ,Pin 265 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO266 ,Pin 266 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO267 ,Pin 267 data out" "L,H"
group.long 0xC3F9070C++0x03
  line.long    0x00 "268-271,GPIO Pin Data Out Register 268-271"
  bitfld.long  0x00 24.                  "PDO268 ,Pin 268 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO269 ,Pin 269 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO270 ,Pin 270 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO271 ,Pin 271 data out" "L,H"
group.long 0xC3F90710++0x03
  line.long    0x00 "272-275,GPIO Pin Data Out Register 272-275"
  bitfld.long  0x00 24.                  "PDO272 ,Pin 272 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO273 ,Pin 273 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO274 ,Pin 274 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO275 ,Pin 275 data out" "L,H"
group.long 0xC3F90714++0x03
  line.long    0x00 "276-279,GPIO Pin Data Out Register 276-279"
  bitfld.long  0x00 24.                  "PDO276 ,Pin 276 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO277 ,Pin 277 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO278 ,Pin 278 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO279 ,Pin 279 data out" "L,H"
group.long 0xC3F90718++0x03
  line.long    0x00 "280-283,GPIO Pin Data Out Register 280-283"
  bitfld.long  0x00 24.                  "PDO280 ,Pin 280 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO281 ,Pin 281 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO282 ,Pin 282 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO283 ,Pin 283 data out" "L,H"
group.long 0xC3F9071C++0x03
  line.long    0x00 "284-287,GPIO Pin Data Out Register 284-287"
  bitfld.long  0x00 24.                  "PDO284 ,Pin 284 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO285 ,Pin 285 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO286 ,Pin 286 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO287 ,Pin 287 data out" "L,H"
group.long 0xC3F90720++0x03
  line.long    0x00 "288-291,GPIO Pin Data Out Register 288-291"
  bitfld.long  0x00 24.                  "PDO288 ,Pin 288 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO289 ,Pin 289 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO290 ,Pin 290 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO291 ,Pin 291 data out" "L,H"
group.long 0xC3F90724++0x03
  line.long    0x00 "292-295,GPIO Pin Data Out Register 292-295"
  bitfld.long  0x00 24.                  "PDO292 ,Pin 292 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO293 ,Pin 293 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO294 ,Pin 294 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO295 ,Pin 295 data out" "L,H"
group.long 0xC3F90728++0x03
  line.long    0x00 "296-299,GPIO Pin Data Out Register 296-299"
  bitfld.long  0x00 24.                  "PDO296 ,Pin 296 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO297 ,Pin 297 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO298 ,Pin 298 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO299 ,Pin 299 data out" "L,H"
group.long 0xC3F9072C++0x03
  line.long    0x00 "300-303,GPIO Pin Data Out Register 300-303"
  bitfld.long  0x00 24.                  "PDO300 ,Pin 300 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO301 ,Pin 301 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO302 ,Pin 302 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO303 ,Pin 303 data out" "L,H"
group.long 0xC3F90730++0x03
  line.long    0x00 "304-307,GPIO Pin Data Out Register 304-307"
  bitfld.long  0x00 24.                  "PDO304 ,Pin 304 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO305 ,Pin 305 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO306 ,Pin 306 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO307 ,Pin 307 data out" "L,H"
group.long 0xC3F90734++0x03
  line.long    0x00 "308-311,GPIO Pin Data Out Register 308-311"
  bitfld.long  0x00 24.                  "PDO308 ,Pin 308 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO309 ,Pin 309 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO310 ,Pin 310 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO311 ,Pin 311 data out" "L,H"
group.long 0xC3F90738++0x03
  line.long    0x00 "312-315,GPIO Pin Data Out Register 312-315"
  bitfld.long  0x00 24.                  "PDO312 ,Pin 312 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO313 ,Pin 313 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO314 ,Pin 314 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO315 ,Pin 315 data out" "L,H"
group.long 0xC3F9073C++0x03
  line.long    0x00 "316-319,GPIO Pin Data Out Register 316-319"
  bitfld.long  0x00 24.                  "PDO316 ,Pin 316 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO317 ,Pin 317 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO318 ,Pin 318 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO319 ,Pin 319 data out" "L,H"
group.long 0xC3F90740++0x03
  line.long    0x00 "320-323,GPIO Pin Data Out Register 320-323"
  bitfld.long  0x00 24.                  "PDO320 ,Pin 320 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO321 ,Pin 321 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO322 ,Pin 322 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO323 ,Pin 323 data out" "L,H"
group.long 0xC3F90744++0x03
  line.long    0x00 "324-327,GPIO Pin Data Out Register 324-327"
  bitfld.long  0x00 24.                  "PDO324 ,Pin 324 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO325 ,Pin 325 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO326 ,Pin 326 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO327 ,Pin 327 data out" "L,H"
group.long 0xC3F90748++0x03
  line.long    0x00 "328-331,GPIO Pin Data Out Register 328-331"
  bitfld.long  0x00 24.                  "PDO328 ,Pin 328 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO329 ,Pin 329 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO330 ,Pin 330 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO331 ,Pin 331 data out" "L,H"
group.long 0xC3F9074C++0x03
  line.long    0x00 "332-335,GPIO Pin Data Out Register 332-335"
  bitfld.long  0x00 24.                  "PDO332 ,Pin 332 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO333 ,Pin 333 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO334 ,Pin 334 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO335 ,Pin 335 data out" "L,H"
group.long 0xC3F90750++0x03
  line.long    0x00 "336-339,GPIO Pin Data Out Register 336-339"
  bitfld.long  0x00 24.                  "PDO336 ,Pin 336 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO337 ,Pin 337 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO338 ,Pin 338 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO339 ,Pin 339 data out" "L,H"
group.long 0xC3F90754++0x03
  line.long    0x00 "340-343,GPIO Pin Data Out Register 340-343"
  bitfld.long  0x00 24.                  "PDO340 ,Pin 340 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO341 ,Pin 341 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO342 ,Pin 342 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO343 ,Pin 343 data out" "L,H"
group.long 0xC3F90758++0x03
  line.long    0x00 "344-347,GPIO Pin Data Out Register 344-347"
  bitfld.long  0x00 24.                  "PDO344 ,Pin 344 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO345 ,Pin 345 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO346 ,Pin 346 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO347 ,Pin 347 data out" "L,H"
group.long 0xC3F9075C++0x03
  line.long    0x00 "348-351,GPIO Pin Data Out Register 348-351"
  bitfld.long  0x00 24.                  "PDO348 ,Pin 348 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO349 ,Pin 349 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO350 ,Pin 350 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO351 ,Pin 351 data out" "L,H"
group.long 0xC3F90760++0x03
  line.long    0x00 "352-355,GPIO Pin Data Out Register 352-355"
  bitfld.long  0x00 24.                  "PDO352 ,Pin 352 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO353 ,Pin 353 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO354 ,Pin 354 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO355 ,Pin 355 data out" "L,H"
group.long 0xC3F90764++0x03
  line.long    0x00 "356-359,GPIO Pin Data Out Register 356-359"
  bitfld.long  0x00 24.                  "PDO356 ,Pin 356 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO357 ,Pin 357 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO358 ,Pin 358 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO359 ,Pin 359 data out" "L,H"
group.long 0xC3F90768++0x03
  line.long    0x00 "360-363,GPIO Pin Data Out Register 360-363"
  bitfld.long  0x00 24.                  "PDO360 ,Pin 360 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO361 ,Pin 361 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO362 ,Pin 362 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO363 ,Pin 363 data out" "L,H"
group.long 0xC3F9076C++0x03
  line.long    0x00 "364-367,GPIO Pin Data Out Register 364-367"
  bitfld.long  0x00 24.                  "PDO364 ,Pin 364 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO365 ,Pin 365 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO366 ,Pin 366 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO367 ,Pin 367 data out" "L,H"
group.long 0xC3F90770++0x03
  line.long    0x00 "368-371,GPIO Pin Data Out Register 368-371"
  bitfld.long  0x00 24.                  "PDO368 ,Pin 368 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO369 ,Pin 369 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO370 ,Pin 370 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO371 ,Pin 371 data out" "L,H"
group.long 0xC3F90774++0x03
  line.long    0x00 "372-375,GPIO Pin Data Out Register 372-375"
  bitfld.long  0x00 24.                  "PDO372 ,Pin 372 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO373 ,Pin 373 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO374 ,Pin 374 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO375 ,Pin 375 data out" "L,H"
group.long 0xC3F90778++0x03
  line.long    0x00 "376-379,GPIO Pin Data Out Register 376-379"
  bitfld.long  0x00 24.                  "PDO376 ,Pin 376 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO377 ,Pin 377 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO378 ,Pin 378 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO379 ,Pin 379 data out" "L,H"
group.long 0xC3F9077C++0x03
  line.long    0x00 "380-383,GPIO Pin Data Out Register 380-383"
  bitfld.long  0x00 24.                  "PDO380 ,Pin 380 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO381 ,Pin 381 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO382 ,Pin 382 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO383 ,Pin 383 data out" "L,H"
group.long 0xC3F90780++0x03
  line.long    0x00 "384-387,GPIO Pin Data Out Register 384-387"
  bitfld.long  0x00 24.                  "PDO384 ,Pin 384 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO385 ,Pin 385 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO386 ,Pin 386 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO387 ,Pin 387 data out" "L,H"
group.long 0xC3F90784++0x03
  line.long    0x00 "388-391,GPIO Pin Data Out Register 388-391"
  bitfld.long  0x00 24.                  "PDO388 ,Pin 388 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO389 ,Pin 389 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO390 ,Pin 390 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO391 ,Pin 391 data out" "L,H"
group.long 0xC3F90788++0x03
  line.long    0x00 "392-395,GPIO Pin Data Out Register 392-395"
  bitfld.long  0x00 24.                  "PDO392 ,Pin 392 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO393 ,Pin 393 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO394 ,Pin 394 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO395 ,Pin 395 data out" "L,H"
group.long 0xC3F9078C++0x03
  line.long    0x00 "396-399,GPIO Pin Data Out Register 396-399"
  bitfld.long  0x00 24.                  "PDO396 ,Pin 396 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO397 ,Pin 397 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO398 ,Pin 398 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO399 ,Pin 399 data out" "L,H"
group.long 0xC3F90790++0x03
  line.long    0x00 "400-403,GPIO Pin Data Out Register 400-403"
  bitfld.long  0x00 24.                  "PDO400 ,Pin 400 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO401 ,Pin 401 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO402 ,Pin 402 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO403 ,Pin 403 data out" "L,H"
group.long 0xC3F90794++0x03
  line.long    0x00 "404-407,GPIO Pin Data Out Register 404-407"
  bitfld.long  0x00 24.                  "PDO404 ,Pin 404 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO405 ,Pin 405 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO406 ,Pin 406 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO407 ,Pin 407 data out" "L,H"
group.long 0xC3F90798++0x03
  line.long    0x00 "408-411,GPIO Pin Data Out Register 408-411"
  bitfld.long  0x00 24.                  "PDO408 ,Pin 408 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO409 ,Pin 409 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO410 ,Pin 410 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO411 ,Pin 411 data out" "L,H"
group.long 0xC3F9079C++0x03
  line.long    0x00 "412-415,GPIO Pin Data Out Register 412-415"
  bitfld.long  0x00 24.                  "PDO412 ,Pin 412 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO413 ,Pin 413 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO414 ,Pin 414 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO415 ,Pin 415 data out" "L,H"
group.long 0xC3F907A0++0x03
  line.long    0x00 "416-419,GPIO Pin Data Out Register 416-419"
  bitfld.long  0x00 24.                  "PDO416 ,Pin 416 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO417 ,Pin 417 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO418 ,Pin 418 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO419 ,Pin 419 data out" "L,H"
group.long 0xC3F907A4++0x03
  line.long    0x00 "420-423,GPIO Pin Data Out Register 420-423"
  bitfld.long  0x00 24.                  "PDO420 ,Pin 420 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO421 ,Pin 421 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO422 ,Pin 422 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO423 ,Pin 423 data out" "L,H"
group.long 0xC3F907A8++0x03
  line.long    0x00 "424-427,GPIO Pin Data Out Register 424-427"
  bitfld.long  0x00 24.                  "PDO424 ,Pin 424 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO425 ,Pin 425 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO426 ,Pin 426 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO427 ,Pin 427 data out" "L,H"
group.long 0xC3F907AC++0x03
  line.long    0x00 "428-431,GPIO Pin Data Out Register 428-431"
  bitfld.long  0x00 24.                  "PDO428 ,Pin 428 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO429 ,Pin 429 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO430 ,Pin 430 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO431 ,Pin 431 data out" "L,H"
group.long 0xC3F907B0++0x03
  line.long    0x00 "432-435,GPIO Pin Data Out Register 432-435"
  bitfld.long  0x00 24.                  "PDO432 ,Pin 432 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO433 ,Pin 433 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO434 ,Pin 434 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO435 ,Pin 435 data out" "L,H"
group.long 0xC3F907B4++0x03
  line.long    0x00 "436-439,GPIO Pin Data Out Register 436-439"
  bitfld.long  0x00 24.                  "PDO436 ,Pin 436 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO437 ,Pin 437 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO438 ,Pin 438 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO439 ,Pin 439 data out" "L,H"
group.long 0xC3F907B8++0x03
  line.long    0x00 "440-443,GPIO Pin Data Out Register 440-443"
  bitfld.long  0x00 24.                  "PDO440 ,Pin 440 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO441 ,Pin 441 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO442 ,Pin 442 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO443 ,Pin 443 data out" "L,H"
group.long 0xC3F907BC++0x03
  line.long    0x00 "444-447,GPIO Pin Data Out Register 444-447"
  bitfld.long  0x00 24.                  "PDO444 ,Pin 444 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO445 ,Pin 445 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO446 ,Pin 446 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO447 ,Pin 447 data out" "L,H"
group.long 0xC3F907C0++0x03
  line.long    0x00 "448-451,GPIO Pin Data Out Register 448-451"
  bitfld.long  0x00 24.                  "PDO448 ,Pin 448 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO449 ,Pin 449 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO450 ,Pin 450 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO451 ,Pin 451 data out" "L,H"
group.long 0xC3F907C4++0x03
  line.long    0x00 "452-455,GPIO Pin Data Out Register 452-455"
  bitfld.long  0x00 24.                  "PDO452 ,Pin 452 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO453 ,Pin 453 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO454 ,Pin 454 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO455 ,Pin 455 data out" "L,H"
group.long 0xC3F907C8++0x03
  line.long    0x00 "456-459,GPIO Pin Data Out Register 456-459"
  bitfld.long  0x00 24.                  "PDO456 ,Pin 456 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO457 ,Pin 457 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO458 ,Pin 458 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO459 ,Pin 459 data out" "L,H"
group.long 0xC3F907CC++0x03
  line.long    0x00 "460-463,GPIO Pin Data Out Register 460-463"
  bitfld.long  0x00 24.                  "PDO460 ,Pin 460 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO461 ,Pin 461 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO462 ,Pin 462 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO463 ,Pin 463 data out" "L,H"
group.long 0xC3F907D0++0x03
  line.long    0x00 "464-467,GPIO Pin Data Out Register 464-467"
  bitfld.long  0x00 24.                  "PDO464 ,Pin 464 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO465 ,Pin 465 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO466 ,Pin 466 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO467 ,Pin 467 data out" "L,H"
group.long 0xC3F907D4++0x03
  line.long    0x00 "468-471,GPIO Pin Data Out Register 468-471"
  bitfld.long  0x00 24.                  "PDO468 ,Pin 468 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO469 ,Pin 469 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO470 ,Pin 470 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO471 ,Pin 471 data out" "L,H"
group.long 0xC3F907D8++0x03
  line.long    0x00 "472-475,GPIO Pin Data Out Register 472-475"
  bitfld.long  0x00 24.                  "PDO472 ,Pin 472 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO473 ,Pin 473 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO474 ,Pin 474 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO475 ,Pin 475 data out" "L,H"
group.long 0xC3F907DC++0x03
  line.long    0x00 "476-479,GPIO Pin Data Out Register 476-479"
  bitfld.long  0x00 24.                  "PDO476 ,Pin 476 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO477 ,Pin 477 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO478 ,Pin 478 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO479 ,Pin 479 data out" "L,H"
group.long 0xC3F907E0++0x03
  line.long    0x00 "480-483,GPIO Pin Data Out Register 480-483"
  bitfld.long  0x00 24.                  "PDO480 ,Pin 480 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO481 ,Pin 481 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO482 ,Pin 482 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO483 ,Pin 483 data out" "L,H"
group.long 0xC3F907E4++0x03
  line.long    0x00 "484-487,GPIO Pin Data Out Register 484-487"
  bitfld.long  0x00 24.                  "PDO484 ,Pin 484 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO485 ,Pin 485 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO486 ,Pin 486 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO487 ,Pin 487 data out" "L,H"
group.long 0xC3F907E8++0x03
  line.long    0x00 "488-491,GPIO Pin Data Out Register 488-491"
  bitfld.long  0x00 24.                  "PDO488 ,Pin 488 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO489 ,Pin 489 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO490 ,Pin 490 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO491 ,Pin 491 data out" "L,H"
group.long 0xC3F907EC++0x03
  line.long    0x00 "492-495,GPIO Pin Data Out Register 492-495"
  bitfld.long  0x00 24.                  "PDO492 ,Pin 492 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO493 ,Pin 493 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO494 ,Pin 494 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO495 ,Pin 495 data out" "L,H"
group.long 0xC3F907F0++0x03
  line.long    0x00 "496-499,GPIO Pin Data Out Register 496-499"
  bitfld.long  0x00 24.                  "PDO496 ,Pin 496 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO497 ,Pin 497 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO498 ,Pin 498 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO499 ,Pin 499 data out" "L,H"
group.long 0xC3F907F4++0x03
  line.long    0x00 "500-503,GPIO Pin Data Out Register 500-503"
  bitfld.long  0x00 24.                  "PDO500 ,Pin 500 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO501 ,Pin 501 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO502 ,Pin 502 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO503 ,Pin 503 data out" "L,H"
group.long 0xC3F907F8++0x03
  line.long    0x00 "504-507,GPIO Pin Data Out Register 504-507"
  bitfld.long  0x00 24.                  "PDO504 ,Pin 504 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO505 ,Pin 505 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO506 ,Pin 506 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO507 ,Pin 507 data out" "L,H"
group.long 0xC3F907FC++0x03
  line.long    0x00 "508-511,GPIO Pin Data Out Register 508-511"
  bitfld.long  0x00 24.                  "PDO508 ,Pin 508 data out" "L,H"
  bitfld.long  0x00 16.                  "  PDO509 ,Pin 509 data out" "L,H"
  bitfld.long  0x00 08.                  "  PDO510 ,Pin 510 data out" "L,H"
  bitfld.long  0x00 00.                  "  PDO511 ,Pin 511 data out" "L,H"

tree.end

sif CPUIS("MPC5674*")

tree "GPIO Pin Data Input Registers"
group.long 0xC3F90E00++0x03
  line.long    0x00 "000-003,GPIO Pin Data In Register 000-003"
  bitfld.long  0x00 24.                  "PDI000 ,Pin 000 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI001 ,Pin 001 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI002 ,Pin 002 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI003 ,Pin 003 data in" "L,H"
group.long 0xC3F90E04++0x03
  line.long    0x00 "004-007,GPIO Pin Data In Register 004-007"
  bitfld.long  0x00 24.                  "PDI004 ,Pin 004 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI005 ,Pin 005 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI006 ,Pin 006 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI007 ,Pin 007 data in" "L,H"
group.long 0xC3F90E08++0x03
  line.long    0x00 "008-011,GPIO Pin Data In Register 008-011"
  bitfld.long  0x00 24.                  "PDI008 ,Pin 008 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI009 ,Pin 009 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI010 ,Pin 010 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI011 ,Pin 011 data in" "L,H"
group.long 0xC3F90E0c++0x03
  line.long    0x00 "012-015,GPIO Pin Data In Register 012-015"
  bitfld.long  0x00 24.                  "PDI012 ,Pin 012 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI013 ,Pin 013 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI014 ,Pin 014 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI015 ,Pin 015 data in" "L,H"
group.long 0xC3F90E10++0x03
  line.long    0x00 "016-019,GPIO Pin Data In Register 016-019"
  bitfld.long  0x00 24.                  "PDI016 ,Pin 016 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI017 ,Pin 017 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI018 ,Pin 018 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI019 ,Pin 019 data in" "L,H"
group.long 0xC3F90E14++0x03
  line.long    0x00 "020-023,GPIO Pin Data In Register 020-023"
  bitfld.long  0x00 24.                  "PDI020 ,Pin 020 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI021 ,Pin 021 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI022 ,Pin 022 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI023 ,Pin 023 data in" "L,H"
group.long 0xC3F90E18++0x03
  line.long    0x00 "024-027,GPIO Pin Data In Register 024-027"
  bitfld.long  0x00 24.                  "PDI024 ,Pin 024 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI025 ,Pin 025 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI026 ,Pin 026 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI027 ,Pin 027 data in" "L,H"
group.long 0xC3F90E1c++0x03
  line.long    0x00 "028-031,GPIO Pin Data In Register 028-031"
  bitfld.long  0x00 24.                  "PDI028 ,Pin 028 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI029 ,Pin 029 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI030 ,Pin 030 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI031 ,Pin 031 data in" "L,H"
group.long 0xC3F90E20++0x03
  line.long    0x00 "032-035,GPIO Pin Data In Register 032-035"
  bitfld.long  0x00 24.                  "PDI032 ,Pin 032 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI033 ,Pin 033 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI034 ,Pin 034 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI035 ,Pin 035 data in" "L,H"
group.long 0xC3F90E24++0x03
  line.long    0x00 "036-039,GPIO Pin Data In Register 036-039"
  bitfld.long  0x00 24.                  "PDI036 ,Pin 036 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI037 ,Pin 037 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI038 ,Pin 038 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI039 ,Pin 039 data in" "L,H"
group.long 0xC3F90E28++0x03
  line.long    0x00 "040-043,GPIO Pin Data In Register 040-043"
  bitfld.long  0x00 24.                  "PDI040 ,Pin 040 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI041 ,Pin 041 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI042 ,Pin 042 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI043 ,Pin 043 data in" "L,H"
group.long 0xC3F90E2c++0x03
  line.long    0x00 "044-047,GPIO Pin Data In Register 044-047"
  bitfld.long  0x00 24.                  "PDI044 ,Pin 044 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI045 ,Pin 045 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI046 ,Pin 046 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI047 ,Pin 047 data in" "L,H"
group.long 0xC3F90E30++0x03
  line.long    0x00 "048-051,GPIO Pin Data In Register 048-051"
  bitfld.long  0x00 24.                  "PDI048 ,Pin 048 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI049 ,Pin 049 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI050 ,Pin 050 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI051 ,Pin 051 data in" "L,H"
group.long 0xC3F90E34++0x03
  line.long    0x00 "052-055,GPIO Pin Data In Register 052-055"
  bitfld.long  0x00 24.                  "PDI052 ,Pin 052 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI053 ,Pin 053 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI054 ,Pin 054 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI055 ,Pin 055 data in" "L,H"
group.long 0xC3F90E38++0x03
  line.long    0x00 "056-059,GPIO Pin Data In Register 056-059"
  bitfld.long  0x00 24.                  "PDI056 ,Pin 056 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI057 ,Pin 057 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI058 ,Pin 058 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI059 ,Pin 059 data in" "L,H"
group.long 0xC3F90E3c++0x03
  line.long    0x00 "060-063,GPIO Pin Data In Register 060-063"
  bitfld.long  0x00 24.                  "PDI060 ,Pin 060 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI061 ,Pin 061 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI062 ,Pin 062 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI063 ,Pin 063 data in" "L,H"
group.long 0xC3F90E40++0x03
  line.long    0x00 "064-067,GPIO Pin Data In Register 064-067"
  bitfld.long  0x00 24.                  "PDI064 ,Pin 064 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI065 ,Pin 065 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI066 ,Pin 066 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI067 ,Pin 067 data in" "L,H"
group.long 0xC3F90E44++0x03
  line.long    0x00 "068-071,GPIO Pin Data In Register 068-071"
  bitfld.long  0x00 24.                  "PDI068 ,Pin 068 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI069 ,Pin 069 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI070 ,Pin 070 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI071 ,Pin 071 data in" "L,H"
group.long 0xC3F90E48++0x03
  line.long    0x00 "072-075,GPIO Pin Data In Register 072-075"
  bitfld.long  0x00 24.                  "PDI072 ,Pin 072 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI073 ,Pin 073 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI074 ,Pin 074 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI075 ,Pin 075 data in" "L,H"
group.long 0xC3F90E4c++0x03
  line.long    0x00 "076-079,GPIO Pin Data In Register 076-079"
  bitfld.long  0x00 24.                  "PDI076 ,Pin 076 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI077 ,Pin 077 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI078 ,Pin 078 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI079 ,Pin 079 data in" "L,H"
group.long 0xC3F90E50++0x03
  line.long    0x00 "080-083,GPIO Pin Data In Register 080-083"
  bitfld.long  0x00 24.                  "PDI080 ,Pin 080 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI081 ,Pin 081 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI082 ,Pin 082 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI083 ,Pin 083 data in" "L,H"
group.long 0xC3F90E54++0x03
  line.long    0x00 "084-087,GPIO Pin Data In Register 084-087"
  bitfld.long  0x00 24.                  "PDI084 ,Pin 084 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI085 ,Pin 085 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI086 ,Pin 086 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI087 ,Pin 087 data in" "L,H"
group.long 0xC3F90E58++0x03
  line.long    0x00 "088-091,GPIO Pin Data In Register 088-091"
  bitfld.long  0x00 24.                  "PDI088 ,Pin 088 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI089 ,Pin 089 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI090 ,Pin 090 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI091 ,Pin 091 data in" "L,H"
group.long 0xC3F90E5c++0x03
  line.long    0x00 "092-095,GPIO Pin Data In Register 092-095"
  bitfld.long  0x00 24.                  "PDI092 ,Pin 092 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI093 ,Pin 093 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI094 ,Pin 094 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI095 ,Pin 095 data in" "L,H"
group.long 0xC3F90E60++0x03
  line.long    0x00 "096-099,GPIO Pin Data In Register 096-099"
  bitfld.long  0x00 24.                  "PDI096 ,Pin 096 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI097 ,Pin 097 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI098 ,Pin 098 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI099 ,Pin 099 data in" "L,H"

group.long 0xC3F90E64++0x03
  line.long    0x00 "100-103,GPIO Pin Data In Register 100-103"
  bitfld.long  0x00 24.                  "PDI100 ,Pin 100 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI101 ,Pin 101 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI102 ,Pin 102 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI103 ,Pin 103 data in" "L,H"
group.long 0xC3F90E68++0x03
  line.long    0x00 "104-107,GPIO Pin Data In Register 104-107"
  bitfld.long  0x00 24.                  "PDI104 ,Pin 104 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI105 ,Pin 105 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI106 ,Pin 106 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI107 ,Pin 107 data in" "L,H"
group.long 0xC3F90E6C++0x03
  line.long    0x00 "108-111,GPIO Pin Data In Register 108-111"
  bitfld.long  0x00 24.                  "PDI108 ,Pin 108 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI109 ,Pin 109 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI110 ,Pin 110 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI111 ,Pin 111 data in" "L,H"
group.long 0xC3F90E70++0x03
  line.long    0x00 "112-115,GPIO Pin Data In Register 112-115"
  bitfld.long  0x00 24.                  "PDI112 ,Pin 112 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI113 ,Pin 113 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI114 ,Pin 114 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI115 ,Pin 115 data in" "L,H"
group.long 0xC3F90E74++0x03
  line.long    0x00 "116-119,GPIO Pin Data In Register 116-119"
  bitfld.long  0x00 24.                  "PDI116 ,Pin 116 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI117 ,Pin 117 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI118 ,Pin 118 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI119 ,Pin 119 data in" "L,H"
group.long 0xC3F90E78++0x03
  line.long    0x00 "120-123,GPIO Pin Data In Register 120-123"
  bitfld.long  0x00 24.                  "PDI120 ,Pin 120 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI121 ,Pin 121 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI122 ,Pin 122 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI123 ,Pin 123 data in" "L,H"
group.long 0xC3F90E7C++0x03
  line.long    0x00 "124-127,GPIO Pin Data In Register 124-127"
  bitfld.long  0x00 24.                  "PDI124 ,Pin 124 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI125 ,Pin 125 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI126 ,Pin 126 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI127 ,Pin 127 data in" "L,H"
group.long 0xC3F90E80++0x03
  line.long    0x00 "128-131,GPIO Pin Data In Register 128-131"
  bitfld.long  0x00 24.                  "PDI128 ,Pin 128 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI129 ,Pin 129 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI130 ,Pin 130 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI131 ,Pin 131 data in" "L,H"
group.long 0xC3F90E84++0x03
  line.long    0x00 "132-135,GPIO Pin Data In Register 132-135"
  bitfld.long  0x00 24.                  "PDI132 ,Pin 132 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI133 ,Pin 133 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI134 ,Pin 134 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI135 ,Pin 135 data in" "L,H"
group.long 0xC3F90E88++0x03
  line.long    0x00 "136-139,GPIO Pin Data In Register 136-139"
  bitfld.long  0x00 24.                  "PDI136 ,Pin 136 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI137 ,Pin 137 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI138 ,Pin 138 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI139 ,Pin 139 data in" "L,H"
group.long 0xC3F90E8C++0x03
  line.long    0x00 "140-143,GPIO Pin Data In Register 140-143"
  bitfld.long  0x00 24.                  "PDI140 ,Pin 140 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI141 ,Pin 141 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI142 ,Pin 142 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI143 ,Pin 143 data in" "L,H"
group.long 0xC3F90E90++0x03
  line.long    0x00 "144-147,GPIO Pin Data In Register 144-147"
  bitfld.long  0x00 24.                  "PDI144 ,Pin 144 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI145 ,Pin 145 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI146 ,Pin 146 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI147 ,Pin 147 data in" "L,H"
group.long 0xC3F90E94++0x03
  line.long    0x00 "148-151,GPIO Pin Data In Register 148-151"
  bitfld.long  0x00 24.                  "PDI148 ,Pin 148 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI149 ,Pin 149 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI150 ,Pin 150 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI151 ,Pin 151 data in" "L,H"
group.long 0xC3F90E98++0x03
  line.long    0x00 "152-155,GPIO Pin Data In Register 152-155"
  bitfld.long  0x00 24.                  "PDI152 ,Pin 152 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI153 ,Pin 153 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI154 ,Pin 154 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI155 ,Pin 155 data in" "L,H"
group.long 0xC3F90E9C++0x03
  line.long    0x00 "156-159,GPIO Pin Data In Register 156-159"
  bitfld.long  0x00 24.                  "PDI156 ,Pin 156 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI157 ,Pin 157 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI158 ,Pin 158 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI159 ,Pin 159 data in" "L,H"
group.long 0xC3F90EA0++0x03
  line.long    0x00 "160-163,GPIO Pin Data In Register 160-163"
  bitfld.long  0x00 24.                  "PDI160 ,Pin 160 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI161 ,Pin 161 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI162 ,Pin 162 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI163 ,Pin 163 data in" "L,H"
group.long 0xC3F90EA4++0x03
  line.long    0x00 "164-167,GPIO Pin Data In Register 164-167"
  bitfld.long  0x00 24.                  "PDI164 ,Pin 164 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI165 ,Pin 165 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI166 ,Pin 166 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI167 ,Pin 167 data in" "L,H"
group.long 0xC3F90EA8++0x03
  line.long    0x00 "168-171,GPIO Pin Data In Register 168-171"
  bitfld.long  0x00 24.                  "PDI168 ,Pin 168 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI169 ,Pin 169 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI170 ,Pin 170 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI171 ,Pin 171 data in" "L,H"
group.long 0xC3F90EAC++0x03
  line.long    0x00 "172-175,GPIO Pin Data In Register 172-175"
  bitfld.long  0x00 24.                  "PDI172 ,Pin 172 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI173 ,Pin 173 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI174 ,Pin 174 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI175 ,Pin 175 data in" "L,H"
group.long 0xC3F90EB0++0x03
  line.long    0x00 "176-179,GPIO Pin Data In Register 176-179"
  bitfld.long  0x00 24.                  "PDI176 ,Pin 176 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI177 ,Pin 177 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI178 ,Pin 178 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI179 ,Pin 179 data in" "L,H"
group.long 0xC3F90EB4++0x03
  line.long    0x00 "180-183,GPIO Pin Data In Register 180-183"
  bitfld.long  0x00 24.                  "PDI180 ,Pin 180 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI181 ,Pin 181 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI182 ,Pin 182 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI183 ,Pin 183 data in" "L,H"
group.long 0xC3F90EB8++0x03
  line.long    0x00 "184-187,GPIO Pin Data In Register 184-187"
  bitfld.long  0x00 24.                  "PDI184 ,Pin 184 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI185 ,Pin 185 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI186 ,Pin 186 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI187 ,Pin 187 data in" "L,H"
group.long 0xC3F90EBC++0x03
  line.long    0x00 "188-191,GPIO Pin Data In Register 188-191"
  bitfld.long  0x00 24.                  "PDI188 ,Pin 188 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI189 ,Pin 189 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI190 ,Pin 190 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI191 ,Pin 191 data in" "L,H"
group.long 0xC3F90EC0++0x03
  line.long    0x00 "192-195,GPIO Pin Data In Register 192-195"
  bitfld.long  0x00 24.                  "PDI192 ,Pin 192 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI193 ,Pin 193 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI194 ,Pin 194 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI195 ,Pin 195 data in" "L,H"
group.long 0xC3F90EC4++0x03
  line.long    0x00 "196-199,GPIO Pin Data In Register 196-199"
  bitfld.long  0x00 24.                  "PDI196 ,Pin 196 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI197 ,Pin 197 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI198 ,Pin 198 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI199 ,Pin 199 data in" "L,H"
group.long 0xC3F90EC8++0x03
  line.long    0x00 "200-203,GPIO Pin Data In Register 200-203"
  bitfld.long  0x00 24.                  "PDI200 ,Pin 200 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI201 ,Pin 201 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI202 ,Pin 202 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI203 ,Pin 203 data in" "L,H"
group.long 0xC3F90ECC++0x03
  line.long    0x00 "204-207,GPIO Pin Data In Register 204-207"
  bitfld.long  0x00 24.                  "PDI204 ,Pin 204 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI205 ,Pin 205 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI206 ,Pin 206 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI207 ,Pin 207 data in" "L,H"
group.long 0xC3F90ED0++0x03
  line.long    0x00 "208-211,GPIO Pin Data In Register 208-211"
  bitfld.long  0x00 24.                  "PDI208 ,Pin 208 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI209 ,Pin 209 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI210 ,Pin 210 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI211 ,Pin 211 data in" "L,H"
group.long 0xC3F90ED4++0x03
  line.long    0x00 "212-215,GPIO Pin Data In Register 212-215"
  bitfld.long  0x00 24.                  "PDI212 ,Pin 212 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI213 ,Pin 213 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI214 ,Pin 214 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI215 ,Pin 215 data in" "L,H"
group.long 0xC3F90ED8++0x03
  line.long    0x00 "216-219,GPIO Pin Data In Register 216-219"
  bitfld.long  0x00 24.                  "PDI216 ,Pin 216 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI217 ,Pin 217 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI218 ,Pin 218 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI219 ,Pin 219 data in" "L,H"
group.long 0xC3F90EDC++0x03
  line.long    0x00 "220-223,GPIO Pin Data In Register 220-223"
  bitfld.long  0x00 24.                  "PDI220 ,Pin 220 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI221 ,Pin 221 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI222 ,Pin 222 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI223 ,Pin 223 data in" "L,H"
group.long 0xC3F90EE0++0x03
  line.long    0x00 "224-227,GPIO Pin Data In Register 224-227"
  bitfld.long  0x00 24.                  "PDI224 ,Pin 224 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI225 ,Pin 225 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI226 ,Pin 226 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI227 ,Pin 227 data in" "L,H"
group.long 0xC3F90EE4++0x03
  line.long    0x00 "228-231,GPIO Pin Data In Register 228-231"
  bitfld.long  0x00 24.                  "PDI228 ,Pin 228 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI229 ,Pin 229 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI230 ,Pin 230 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI231 ,Pin 231 data in" "L,H"
group.long 0xC3F90EE8++0x03
  line.long    0x00 "232-235,GPIO Pin Data In Register 232-235"
  bitfld.long  0x00 24.                  "PDI232 ,Pin 232 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI233 ,Pin 233 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI234 ,Pin 234 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI235 ,Pin 235 data in" "L,H"
group.long 0xC3F90EEC++0x03
  line.long    0x00 "236-239,GPIO Pin Data In Register 236-239"
  bitfld.long  0x00 24.                  "PDI236 ,Pin 236 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI237 ,Pin 237 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI238 ,Pin 238 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI239 ,Pin 239 data in" "L,H"
group.long 0xC3F90EF0++0x03
  line.long    0x00 "240-243,GPIO Pin Data In Register 240-243"
  bitfld.long  0x00 24.                  "PDI240 ,Pin 240 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI241 ,Pin 241 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI242 ,Pin 242 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI243 ,Pin 243 data in" "L,H"
group.long 0xC3F90EF4++0x03
  line.long    0x00 "244-247,GPIO Pin Data In Register 244-247"
  bitfld.long  0x00 24.                  "PDI244 ,Pin 244 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI245 ,Pin 245 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI246 ,Pin 246 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI247 ,Pin 247 data in" "L,H"
group.long 0xC3F90EF8++0x03
  line.long    0x00 "248-251,GPIO Pin Data In Register 248-251"
  bitfld.long  0x00 24.                  "PDI248 ,Pin 248 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI249 ,Pin 249 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI250 ,Pin 250 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI251 ,Pin 251 data in" "L,H"
group.long 0xC3F90EFC++0x03
  line.long    0x00 "252-255,GPIO Pin Data In Register 252-255"
  bitfld.long  0x00 24.                  "PDI252 ,Pin 252 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI253 ,Pin 253 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI254 ,Pin 254 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI255 ,Pin 255 data in" "L,H"

group.long 0xC3F90F00++0x03
  line.long    0x00 "256-259,GPIO Pin Data In Register 256-259"
  bitfld.long  0x00 24.                  "PDI256 ,Pin 256 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI257 ,Pin 257 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI258 ,Pin 258 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI259 ,Pin 259 data in" "L,H"
group.long 0xC3F90F04++0x03
  line.long    0x00 "260-263,GPIO Pin Data In Register 260-263"
  bitfld.long  0x00 24.                  "PDI260 ,Pin 260 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI261 ,Pin 261 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI262 ,Pin 262 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI263 ,Pin 263 data in" "L,H"
group.long 0xC3F90F08++0x03
  line.long    0x00 "264-267,GPIO Pin Data In Register 264-267"
  bitfld.long  0x00 24.                  "PDI264 ,Pin 264 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI265 ,Pin 265 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI266 ,Pin 266 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI267 ,Pin 267 data in" "L,H"
group.long 0xC3F90F0C++0x03
  line.long    0x00 "268-271,GPIO Pin Data In Register 268-271"
  bitfld.long  0x00 24.                  "PDI268 ,Pin 268 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI269 ,Pin 269 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI270 ,Pin 270 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI271 ,Pin 271 data in" "L,H"
group.long 0xC3F90F10++0x03
  line.long    0x00 "272-275,GPIO Pin Data In Register 272-275"
  bitfld.long  0x00 24.                  "PDI272 ,Pin 272 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI273 ,Pin 273 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI274 ,Pin 274 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI275 ,Pin 275 data in" "L,H"
group.long 0xC3F90F14++0x03
  line.long    0x00 "276-279,GPIO Pin Data In Register 276-279"
  bitfld.long  0x00 24.                  "PDI276 ,Pin 276 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI277 ,Pin 277 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI278 ,Pin 278 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI279 ,Pin 279 data in" "L,H"
group.long 0xC3F90F18++0x03
  line.long    0x00 "280-283,GPIO Pin Data In Register 280-283"
  bitfld.long  0x00 24.                  "PDI280 ,Pin 280 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI281 ,Pin 281 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI282 ,Pin 282 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI283 ,Pin 283 data in" "L,H"
group.long 0xC3F90F1C++0x03
  line.long    0x00 "284-287,GPIO Pin Data In Register 284-287"
  bitfld.long  0x00 24.                  "PDI284 ,Pin 284 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI285 ,Pin 285 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI286 ,Pin 286 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI287 ,Pin 287 data in" "L,H"
group.long 0xC3F90F20++0x03
  line.long    0x00 "288-291,GPIO Pin Data In Register 288-291"
  bitfld.long  0x00 24.                  "PDI288 ,Pin 288 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI289 ,Pin 289 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI290 ,Pin 290 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI291 ,Pin 291 data in" "L,H"
group.long 0xC3F90F24++0x03
  line.long    0x00 "292-295,GPIO Pin Data In Register 292-295"
  bitfld.long  0x00 24.                  "PDI292 ,Pin 292 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI293 ,Pin 293 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI294 ,Pin 294 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI295 ,Pin 295 data in" "L,H"
group.long 0xC3F90F28++0x03
  line.long    0x00 "296-299,GPIO Pin Data In Register 296-299"
  bitfld.long  0x00 24.                  "PDI296 ,Pin 296 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI297 ,Pin 297 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI298 ,Pin 298 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI299 ,Pin 299 data in" "L,H"
group.long 0xC3F90F2C++0x03
  line.long    0x00 "300-303,GPIO Pin Data In Register 300-303"
  bitfld.long  0x00 24.                  "PDI300 ,Pin 300 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI301 ,Pin 301 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI302 ,Pin 302 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI303 ,Pin 303 data in" "L,H"
group.long 0xC3F90F30++0x03
  line.long    0x00 "304-307,GPIO Pin Data In Register 304-307"
  bitfld.long  0x00 24.                  "PDI304 ,Pin 304 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI305 ,Pin 305 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI306 ,Pin 306 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI307 ,Pin 307 data in" "L,H"
group.long 0xC3F90F34++0x03
  line.long    0x00 "308-311,GPIO Pin Data In Register 308-311"
  bitfld.long  0x00 24.                  "PDI308 ,Pin 308 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI309 ,Pin 309 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI310 ,Pin 310 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI311 ,Pin 311 data in" "L,H"
group.long 0xC3F90F38++0x03
  line.long    0x00 "312-315,GPIO Pin Data In Register 312-315"
  bitfld.long  0x00 24.                  "PDI312 ,Pin 312 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI313 ,Pin 313 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI314 ,Pin 314 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI315 ,Pin 315 data in" "L,H"
group.long 0xC3F90F3C++0x03
  line.long    0x00 "316-319,GPIO Pin Data In Register 316-319"
  bitfld.long  0x00 24.                  "PDI316 ,Pin 316 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI317 ,Pin 317 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI318 ,Pin 318 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI319 ,Pin 319 data in" "L,H"
group.long 0xC3F90F40++0x03
  line.long    0x00 "320-323,GPIO Pin Data In Register 320-323"
  bitfld.long  0x00 24.                  "PDI320 ,Pin 320 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI321 ,Pin 321 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI322 ,Pin 322 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI323 ,Pin 323 data in" "L,H"
group.long 0xC3F90F44++0x03
  line.long    0x00 "324-327,GPIO Pin Data In Register 324-327"
  bitfld.long  0x00 24.                  "PDI324 ,Pin 324 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI325 ,Pin 325 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI326 ,Pin 326 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI327 ,Pin 327 data in" "L,H"
group.long 0xC3F90F48++0x03
  line.long    0x00 "328-331,GPIO Pin Data In Register 328-331"
  bitfld.long  0x00 24.                  "PDI328 ,Pin 328 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI329 ,Pin 329 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI330 ,Pin 330 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI331 ,Pin 331 data in" "L,H"
group.long 0xC3F90F4C++0x03
  line.long    0x00 "332-335,GPIO Pin Data In Register 332-335"
  bitfld.long  0x00 24.                  "PDI332 ,Pin 332 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI333 ,Pin 333 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI334 ,Pin 334 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI335 ,Pin 335 data in" "L,H"
group.long 0xC3F90F50++0x03
  line.long    0x00 "336-339,GPIO Pin Data In Register 336-339"
  bitfld.long  0x00 24.                  "PDI336 ,Pin 336 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI337 ,Pin 337 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI338 ,Pin 338 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI339 ,Pin 339 data in" "L,H"
group.long 0xC3F90F54++0x03
  line.long    0x00 "340-343,GPIO Pin Data In Register 340-343"
  bitfld.long  0x00 24.                  "PDI340 ,Pin 340 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI341 ,Pin 341 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI342 ,Pin 342 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI343 ,Pin 343 data in" "L,H"
group.long 0xC3F90F58++0x03
  line.long    0x00 "344-347,GPIO Pin Data In Register 344-347"
  bitfld.long  0x00 24.                  "PDI344 ,Pin 344 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI345 ,Pin 345 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI346 ,Pin 346 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI347 ,Pin 347 data in" "L,H"
group.long 0xC3F90F5C++0x03
  line.long    0x00 "348-351,GPIO Pin Data In Register 348-351"
  bitfld.long  0x00 24.                  "PDI348 ,Pin 348 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI349 ,Pin 349 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI350 ,Pin 350 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI351 ,Pin 351 data in" "L,H"
group.long 0xC3F90F60++0x03
  line.long    0x00 "352-355,GPIO Pin Data In Register 352-355"
  bitfld.long  0x00 24.                  "PDI352 ,Pin 352 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI353 ,Pin 353 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI354 ,Pin 354 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI355 ,Pin 355 data in" "L,H"
group.long 0xC3F90F64++0x03
  line.long    0x00 "356-359,GPIO Pin Data In Register 356-359"
  bitfld.long  0x00 24.                  "PDI356 ,Pin 356 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI357 ,Pin 357 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI358 ,Pin 358 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI359 ,Pin 359 data in" "L,H"
group.long 0xC3F90F68++0x03
  line.long    0x00 "360-363,GPIO Pin Data In Register 360-363"
  bitfld.long  0x00 24.                  "PDI360 ,Pin 360 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI361 ,Pin 361 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI362 ,Pin 362 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI363 ,Pin 363 data in" "L,H"
group.long 0xC3F90F6C++0x03
  line.long    0x00 "364-367,GPIO Pin Data In Register 364-367"
  bitfld.long  0x00 24.                  "PDI364 ,Pin 364 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI365 ,Pin 365 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI366 ,Pin 366 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI367 ,Pin 367 data in" "L,H"
group.long 0xC3F90F70++0x03
  line.long    0x00 "368-371,GPIO Pin Data In Register 368-371"
  bitfld.long  0x00 24.                  "PDI368 ,Pin 368 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI369 ,Pin 369 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI370 ,Pin 370 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI371 ,Pin 371 data in" "L,H"
group.long 0xC3F90F74++0x03
  line.long    0x00 "372-375,GPIO Pin Data In Register 372-375"
  bitfld.long  0x00 24.                  "PDI372 ,Pin 372 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI373 ,Pin 373 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI374 ,Pin 374 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI375 ,Pin 375 data in" "L,H"
group.long 0xC3F90F78++0x03
  line.long    0x00 "376-379,GPIO Pin Data In Register 376-379"
  bitfld.long  0x00 24.                  "PDI376 ,Pin 376 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI377 ,Pin 377 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI378 ,Pin 378 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI379 ,Pin 379 data in" "L,H"
group.long 0xC3F90F7C++0x03
  line.long    0x00 "380-383,GPIO Pin Data In Register 380-383"
  bitfld.long  0x00 24.                  "PDI380 ,Pin 380 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI381 ,Pin 381 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI382 ,Pin 382 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI383 ,Pin 383 data in" "L,H"
group.long 0xC3F90F80++0x03
  line.long    0x00 "384-387,GPIO Pin Data In Register 384-387"
  bitfld.long  0x00 24.                  "PDI384 ,Pin 384 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI385 ,Pin 385 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI386 ,Pin 386 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI387 ,Pin 387 data in" "L,H"
group.long 0xC3F90F84++0x03
  line.long    0x00 "388-391,GPIO Pin Data In Register 388-391"
  bitfld.long  0x00 24.                  "PDI388 ,Pin 388 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI389 ,Pin 389 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI390 ,Pin 390 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI391 ,Pin 391 data in" "L,H"
group.long 0xC3F90F88++0x03
  line.long    0x00 "392-395,GPIO Pin Data In Register 392-395"
  bitfld.long  0x00 24.                  "PDI392 ,Pin 392 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI393 ,Pin 393 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI394 ,Pin 394 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI395 ,Pin 395 data in" "L,H"
group.long 0xC3F90F8C++0x03
  line.long    0x00 "396-399,GPIO Pin Data In Register 396-399"
  bitfld.long  0x00 24.                  "PDI396 ,Pin 396 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI397 ,Pin 397 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI398 ,Pin 398 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI399 ,Pin 399 data in" "L,H"
group.long 0xC3F90F90++0x03
  line.long    0x00 "400-403,GPIO Pin Data In Register 400-403"
  bitfld.long  0x00 24.                  "PDI400 ,Pin 400 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI401 ,Pin 401 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI402 ,Pin 402 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI403 ,Pin 403 data in" "L,H"
group.long 0xC3F90F94++0x03
  line.long    0x00 "404-407,GPIO Pin Data In Register 404-407"
  bitfld.long  0x00 24.                  "PDI404 ,Pin 404 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI405 ,Pin 405 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI406 ,Pin 406 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI407 ,Pin 407 data in" "L,H"
group.long 0xC3F90F98++0x03
  line.long    0x00 "408-411,GPIO Pin Data In Register 408-411"
  bitfld.long  0x00 24.                  "PDI408 ,Pin 408 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI409 ,Pin 409 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI410 ,Pin 410 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI411 ,Pin 411 data in" "L,H"
group.long 0xC3F90F9C++0x03
  line.long    0x00 "412-415,GPIO Pin Data In Register 412-415"
  bitfld.long  0x00 24.                  "PDI412 ,Pin 412 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI413 ,Pin 413 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI414 ,Pin 414 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI415 ,Pin 415 data in" "L,H"
group.long 0xC3F90FA0++0x03
  line.long    0x00 "416-419,GPIO Pin Data In Register 416-419"
  bitfld.long  0x00 24.                  "PDI416 ,Pin 416 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI417 ,Pin 417 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI418 ,Pin 418 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI419 ,Pin 419 data in" "L,H"
group.long 0xC3F90FA4++0x03
  line.long    0x00 "420-423,GPIO Pin Data In Register 420-423"
  bitfld.long  0x00 24.                  "PDI420 ,Pin 420 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI421 ,Pin 421 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI422 ,Pin 422 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI423 ,Pin 423 data in" "L,H"
group.long 0xC3F90FA8++0x03
  line.long    0x00 "424-427,GPIO Pin Data In Register 424-427"
  bitfld.long  0x00 24.                  "PDI424 ,Pin 424 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI425 ,Pin 425 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI426 ,Pin 426 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI427 ,Pin 427 data in" "L,H"
group.long 0xC3F90FAC++0x03
  line.long    0x00 "428-431,GPIO Pin Data In Register 428-431"
  bitfld.long  0x00 24.                  "PDI428 ,Pin 428 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI429 ,Pin 429 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI430 ,Pin 430 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI431 ,Pin 431 data in" "L,H"
group.long 0xC3F90FB0++0x03
  line.long    0x00 "432-435,GPIO Pin Data In Register 432-435"
  bitfld.long  0x00 24.                  "PDI432 ,Pin 432 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI433 ,Pin 433 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI434 ,Pin 434 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI435 ,Pin 435 data in" "L,H"
group.long 0xC3F90FB4++0x03
  line.long    0x00 "436-439,GPIO Pin Data In Register 436-439"
  bitfld.long  0x00 24.                  "PDI436 ,Pin 436 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI437 ,Pin 437 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI438 ,Pin 438 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI439 ,Pin 439 data in" "L,H"
group.long 0xC3F90FB8++0x03
  line.long    0x00 "440-443,GPIO Pin Data In Register 440-443"
  bitfld.long  0x00 24.                  "PDI440 ,Pin 440 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI441 ,Pin 441 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI442 ,Pin 442 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI443 ,Pin 443 data in" "L,H"
group.long 0xC3F90FBC++0x03
  line.long    0x00 "444-447,GPIO Pin Data In Register 444-447"
  bitfld.long  0x00 24.                  "PDI444 ,Pin 444 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI445 ,Pin 445 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI446 ,Pin 446 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI447 ,Pin 447 data in" "L,H"
group.long 0xC3F90FC0++0x03
  line.long    0x00 "448-451,GPIO Pin Data In Register 448-451"
  bitfld.long  0x00 24.                  "PDI448 ,Pin 448 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI449 ,Pin 449 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI450 ,Pin 450 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI451 ,Pin 451 data in" "L,H"
group.long 0xC3F90FC4++0x03
  line.long    0x00 "452-455,GPIO Pin Data In Register 452-455"
  bitfld.long  0x00 24.                  "PDI452 ,Pin 452 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI453 ,Pin 453 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI454 ,Pin 454 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI455 ,Pin 455 data in" "L,H"
group.long 0xC3F90FC8++0x03
  line.long    0x00 "456-459,GPIO Pin Data In Register 456-459"
  bitfld.long  0x00 24.                  "PDI456 ,Pin 456 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI457 ,Pin 457 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI458 ,Pin 458 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI459 ,Pin 459 data in" "L,H"
group.long 0xC3F90FCC++0x03
  line.long    0x00 "460-463,GPIO Pin Data In Register 460-463"
  bitfld.long  0x00 24.                  "PDI460 ,Pin 460 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI461 ,Pin 461 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI462 ,Pin 462 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI463 ,Pin 463 data in" "L,H"
group.long 0xC3F90FD0++0x03
  line.long    0x00 "464-467,GPIO Pin Data In Register 464-467"
  bitfld.long  0x00 24.                  "PDI464 ,Pin 464 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI465 ,Pin 465 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI466 ,Pin 466 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI467 ,Pin 467 data in" "L,H"
group.long 0xC3F90FD4++0x03
  line.long    0x00 "468-471,GPIO Pin Data In Register 468-471"
  bitfld.long  0x00 24.                  "PDI468 ,Pin 468 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI469 ,Pin 469 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI470 ,Pin 470 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI471 ,Pin 471 data in" "L,H"
group.long 0xC3F90FD8++0x03
  line.long    0x00 "472-475,GPIO Pin Data In Register 472-475"
  bitfld.long  0x00 24.                  "PDI472 ,Pin 472 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI473 ,Pin 473 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI474 ,Pin 474 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI475 ,Pin 475 data in" "L,H"
group.long 0xC3F90FDC++0x03
  line.long    0x00 "476-479,GPIO Pin Data In Register 476-479"
  bitfld.long  0x00 24.                  "PDI476 ,Pin 476 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI477 ,Pin 477 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI478 ,Pin 478 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI479 ,Pin 479 data in" "L,H"
group.long 0xC3F90FE0++0x03
  line.long    0x00 "480-483,GPIO Pin Data In Register 480-483"
  bitfld.long  0x00 24.                  "PDI480 ,Pin 480 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI481 ,Pin 481 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI482 ,Pin 482 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI483 ,Pin 483 data in" "L,H"
group.long 0xC3F90FE4++0x03
  line.long    0x00 "484-487,GPIO Pin Data In Register 484-487"
  bitfld.long  0x00 24.                  "PDI484 ,Pin 484 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI485 ,Pin 485 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI486 ,Pin 486 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI487 ,Pin 487 data in" "L,H"
group.long 0xC3F90FE8++0x03
  line.long    0x00 "488-491,GPIO Pin Data In Register 488-491"
  bitfld.long  0x00 24.                  "PDI488 ,Pin 488 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI489 ,Pin 489 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI490 ,Pin 490 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI491 ,Pin 491 data in" "L,H"
group.long 0xC3F90FEC++0x03
  line.long    0x00 "492-495,GPIO Pin Data In Register 492-495"
  bitfld.long  0x00 24.                  "PDI492 ,Pin 492 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI493 ,Pin 493 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI494 ,Pin 494 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI495 ,Pin 495 data in" "L,H"
group.long 0xC3F90FF0++0x03
  line.long    0x00 "496-499,GPIO Pin Data In Register 496-499"
  bitfld.long  0x00 24.                  "PDI496 ,Pin 496 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI497 ,Pin 497 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI498 ,Pin 498 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI499 ,Pin 499 data in" "L,H"
group.long 0xC3F90FF4++0x03
  line.long    0x00 "500-503,GPIO Pin Data In Register 500-503"
  bitfld.long  0x00 24.                  "PDI500 ,Pin 500 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI501 ,Pin 501 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI502 ,Pin 502 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI503 ,Pin 503 data in" "L,H"
group.long 0xC3F90FF8++0x03
  line.long    0x00 "504-507,GPIO Pin Data In Register 504-507"
  bitfld.long  0x00 24.                  "PDI504 ,Pin 504 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI505 ,Pin 505 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI506 ,Pin 506 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI507 ,Pin 507 data in" "L,H"
group.long 0xC3F90FFC++0x03
  line.long    0x00 "508-511,GPIO Pin Data In Register 508-511"
  bitfld.long  0x00 24.                  "PDI508 ,Pin 508 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI509 ,Pin 509 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI510 ,Pin 510 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI511 ,Pin 511 data in" "L,H"
tree.end

else

tree "GPIO Pin Data Input Registers"
group.long 0xC3F90800++0x03
  line.long    0x00 "000-003,GPIO Pin Data In Register 000-003"
  bitfld.long  0x00 24.                  "PDI000 ,Pin 000 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI001 ,Pin 001 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI002 ,Pin 002 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI003 ,Pin 003 data in" "L,H"
group.long 0xC3F90804++0x03
  line.long    0x00 "004-007,GPIO Pin Data In Register 004-007"
  bitfld.long  0x00 24.                  "PDI004 ,Pin 004 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI005 ,Pin 005 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI006 ,Pin 006 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI007 ,Pin 007 data in" "L,H"
group.long 0xC3F90808++0x03
  line.long    0x00 "008-011,GPIO Pin Data In Register 008-011"
  bitfld.long  0x00 24.                  "PDI008 ,Pin 008 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI009 ,Pin 009 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI010 ,Pin 010 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI011 ,Pin 011 data in" "L,H"
group.long 0xC3F9080c++0x03
  line.long    0x00 "012-015,GPIO Pin Data In Register 012-015"
  bitfld.long  0x00 24.                  "PDI012 ,Pin 012 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI013 ,Pin 013 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI014 ,Pin 014 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI015 ,Pin 015 data in" "L,H"
group.long 0xC3F90810++0x03
  line.long    0x00 "016-019,GPIO Pin Data In Register 016-019"
  bitfld.long  0x00 24.                  "PDI016 ,Pin 016 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI017 ,Pin 017 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI018 ,Pin 018 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI019 ,Pin 019 data in" "L,H"
group.long 0xC3F90814++0x03
  line.long    0x00 "020-023,GPIO Pin Data In Register 020-023"
  bitfld.long  0x00 24.                  "PDI020 ,Pin 020 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI021 ,Pin 021 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI022 ,Pin 022 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI023 ,Pin 023 data in" "L,H"
group.long 0xC3F90818++0x03
  line.long    0x00 "024-027,GPIO Pin Data In Register 024-027"
  bitfld.long  0x00 24.                  "PDI024 ,Pin 024 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI025 ,Pin 025 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI026 ,Pin 026 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI027 ,Pin 027 data in" "L,H"
group.long 0xC3F9081c++0x03
  line.long    0x00 "028-031,GPIO Pin Data In Register 028-031"
  bitfld.long  0x00 24.                  "PDI028 ,Pin 028 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI029 ,Pin 029 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI030 ,Pin 030 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI031 ,Pin 031 data in" "L,H"
group.long 0xC3F90820++0x03
  line.long    0x00 "032-035,GPIO Pin Data In Register 032-035"
  bitfld.long  0x00 24.                  "PDI032 ,Pin 032 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI033 ,Pin 033 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI034 ,Pin 034 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI035 ,Pin 035 data in" "L,H"
group.long 0xC3F90824++0x03
  line.long    0x00 "036-039,GPIO Pin Data In Register 036-039"
  bitfld.long  0x00 24.                  "PDI036 ,Pin 036 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI037 ,Pin 037 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI038 ,Pin 038 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI039 ,Pin 039 data in" "L,H"
group.long 0xC3F90828++0x03
  line.long    0x00 "040-043,GPIO Pin Data In Register 040-043"
  bitfld.long  0x00 24.                  "PDI040 ,Pin 040 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI041 ,Pin 041 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI042 ,Pin 042 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI043 ,Pin 043 data in" "L,H"
group.long 0xC3F9082c++0x03
  line.long    0x00 "044-047,GPIO Pin Data In Register 044-047"
  bitfld.long  0x00 24.                  "PDI044 ,Pin 044 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI045 ,Pin 045 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI046 ,Pin 046 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI047 ,Pin 047 data in" "L,H"
group.long 0xC3F90830++0x03
  line.long    0x00 "048-051,GPIO Pin Data In Register 048-051"
  bitfld.long  0x00 24.                  "PDI048 ,Pin 048 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI049 ,Pin 049 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI050 ,Pin 050 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI051 ,Pin 051 data in" "L,H"
group.long 0xC3F90834++0x03
  line.long    0x00 "052-055,GPIO Pin Data In Register 052-055"
  bitfld.long  0x00 24.                  "PDI052 ,Pin 052 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI053 ,Pin 053 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI054 ,Pin 054 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI055 ,Pin 055 data in" "L,H"
group.long 0xC3F90838++0x03
  line.long    0x00 "056-059,GPIO Pin Data In Register 056-059"
  bitfld.long  0x00 24.                  "PDI056 ,Pin 056 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI057 ,Pin 057 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI058 ,Pin 058 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI059 ,Pin 059 data in" "L,H"
group.long 0xC3F9083c++0x03
  line.long    0x00 "060-063,GPIO Pin Data In Register 060-063"
  bitfld.long  0x00 24.                  "PDI060 ,Pin 060 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI061 ,Pin 061 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI062 ,Pin 062 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI063 ,Pin 063 data in" "L,H"
group.long 0xC3F90840++0x03
  line.long    0x00 "064-067,GPIO Pin Data In Register 064-067"
  bitfld.long  0x00 24.                  "PDI064 ,Pin 064 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI065 ,Pin 065 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI066 ,Pin 066 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI067 ,Pin 067 data in" "L,H"
group.long 0xC3F90844++0x03
  line.long    0x00 "068-071,GPIO Pin Data In Register 068-071"
  bitfld.long  0x00 24.                  "PDI068 ,Pin 068 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI069 ,Pin 069 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI070 ,Pin 070 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI071 ,Pin 071 data in" "L,H"
group.long 0xC3F90848++0x03
  line.long    0x00 "072-075,GPIO Pin Data In Register 072-075"
  bitfld.long  0x00 24.                  "PDI072 ,Pin 072 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI073 ,Pin 073 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI074 ,Pin 074 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI075 ,Pin 075 data in" "L,H"
group.long 0xC3F9084c++0x03
  line.long    0x00 "076-079,GPIO Pin Data In Register 076-079"
  bitfld.long  0x00 24.                  "PDI076 ,Pin 076 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI077 ,Pin 077 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI078 ,Pin 078 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI079 ,Pin 079 data in" "L,H"
group.long 0xC3F90850++0x03
  line.long    0x00 "080-083,GPIO Pin Data In Register 080-083"
  bitfld.long  0x00 24.                  "PDI080 ,Pin 080 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI081 ,Pin 081 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI082 ,Pin 082 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI083 ,Pin 083 data in" "L,H"
group.long 0xC3F90854++0x03
  line.long    0x00 "084-087,GPIO Pin Data In Register 084-087"
  bitfld.long  0x00 24.                  "PDI084 ,Pin 084 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI085 ,Pin 085 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI086 ,Pin 086 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI087 ,Pin 087 data in" "L,H"
group.long 0xC3F90858++0x03
  line.long    0x00 "088-091,GPIO Pin Data In Register 088-091"
  bitfld.long  0x00 24.                  "PDI088 ,Pin 088 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI089 ,Pin 089 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI090 ,Pin 090 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI091 ,Pin 091 data in" "L,H"
group.long 0xC3F9085c++0x03
  line.long    0x00 "092-095,GPIO Pin Data In Register 092-095"
  bitfld.long  0x00 24.                  "PDI092 ,Pin 092 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI093 ,Pin 093 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI094 ,Pin 094 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI095 ,Pin 095 data in" "L,H"
group.long 0xC3F90860++0x03
  line.long    0x00 "096-099,GPIO Pin Data In Register 096-099"
  bitfld.long  0x00 24.                  "PDI096 ,Pin 096 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI097 ,Pin 097 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI098 ,Pin 098 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI099 ,Pin 099 data in" "L,H"

group.long 0xC3F90864++0x03
  line.long    0x00 "100-103,GPIO Pin Data In Register 100-103"
  bitfld.long  0x00 24.                  "PDI100 ,Pin 100 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI101 ,Pin 101 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI102 ,Pin 102 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI103 ,Pin 103 data in" "L,H"
group.long 0xC3F90868++0x03
  line.long    0x00 "104-107,GPIO Pin Data In Register 104-107"
  bitfld.long  0x00 24.                  "PDI104 ,Pin 104 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI105 ,Pin 105 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI106 ,Pin 106 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI107 ,Pin 107 data in" "L,H"
group.long 0xC3F9086C++0x03
  line.long    0x00 "108-111,GPIO Pin Data In Register 108-111"
  bitfld.long  0x00 24.                  "PDI108 ,Pin 108 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI109 ,Pin 109 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI110 ,Pin 110 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI111 ,Pin 111 data in" "L,H"
group.long 0xC3F90870++0x03
  line.long    0x00 "112-115,GPIO Pin Data In Register 112-115"
  bitfld.long  0x00 24.                  "PDI112 ,Pin 112 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI113 ,Pin 113 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI114 ,Pin 114 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI115 ,Pin 115 data in" "L,H"
group.long 0xC3F90874++0x03
  line.long    0x00 "116-119,GPIO Pin Data In Register 116-119"
  bitfld.long  0x00 24.                  "PDI116 ,Pin 116 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI117 ,Pin 117 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI118 ,Pin 118 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI119 ,Pin 119 data in" "L,H"
group.long 0xC3F90878++0x03
  line.long    0x00 "120-123,GPIO Pin Data In Register 120-123"
  bitfld.long  0x00 24.                  "PDI120 ,Pin 120 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI121 ,Pin 121 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI122 ,Pin 122 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI123 ,Pin 123 data in" "L,H"
group.long 0xC3F9087C++0x03
  line.long    0x00 "124-127,GPIO Pin Data In Register 124-127"
  bitfld.long  0x00 24.                  "PDI124 ,Pin 124 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI125 ,Pin 125 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI126 ,Pin 126 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI127 ,Pin 127 data in" "L,H"
group.long 0xC3F90880++0x03
  line.long    0x00 "128-131,GPIO Pin Data In Register 128-131"
  bitfld.long  0x00 24.                  "PDI128 ,Pin 128 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI129 ,Pin 129 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI130 ,Pin 130 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI131 ,Pin 131 data in" "L,H"
group.long 0xC3F90884++0x03
  line.long    0x00 "132-135,GPIO Pin Data In Register 132-135"
  bitfld.long  0x00 24.                  "PDI132 ,Pin 132 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI133 ,Pin 133 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI134 ,Pin 134 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI135 ,Pin 135 data in" "L,H"
group.long 0xC3F90888++0x03
  line.long    0x00 "136-139,GPIO Pin Data In Register 136-139"
  bitfld.long  0x00 24.                  "PDI136 ,Pin 136 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI137 ,Pin 137 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI138 ,Pin 138 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI139 ,Pin 139 data in" "L,H"
group.long 0xC3F9088C++0x03
  line.long    0x00 "140-143,GPIO Pin Data In Register 140-143"
  bitfld.long  0x00 24.                  "PDI140 ,Pin 140 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI141 ,Pin 141 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI142 ,Pin 142 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI143 ,Pin 143 data in" "L,H"
group.long 0xC3F90890++0x03
  line.long    0x00 "144-147,GPIO Pin Data In Register 144-147"
  bitfld.long  0x00 24.                  "PDI144 ,Pin 144 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI145 ,Pin 145 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI146 ,Pin 146 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI147 ,Pin 147 data in" "L,H"
group.long 0xC3F90894++0x03
  line.long    0x00 "148-151,GPIO Pin Data In Register 148-151"
  bitfld.long  0x00 24.                  "PDI148 ,Pin 148 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI149 ,Pin 149 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI150 ,Pin 150 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI151 ,Pin 151 data in" "L,H"
group.long 0xC3F90898++0x03
  line.long    0x00 "152-155,GPIO Pin Data In Register 152-155"
  bitfld.long  0x00 24.                  "PDI152 ,Pin 152 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI153 ,Pin 153 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI154 ,Pin 154 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI155 ,Pin 155 data in" "L,H"
group.long 0xC3F9089C++0x03
  line.long    0x00 "156-159,GPIO Pin Data In Register 156-159"
  bitfld.long  0x00 24.                  "PDI156 ,Pin 156 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI157 ,Pin 157 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI158 ,Pin 158 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI159 ,Pin 159 data in" "L,H"
group.long 0xC3F908A0++0x03
  line.long    0x00 "160-163,GPIO Pin Data In Register 160-163"
  bitfld.long  0x00 24.                  "PDI160 ,Pin 160 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI161 ,Pin 161 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI162 ,Pin 162 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI163 ,Pin 163 data in" "L,H"
group.long 0xC3F908A4++0x03
  line.long    0x00 "164-167,GPIO Pin Data In Register 164-167"
  bitfld.long  0x00 24.                  "PDI164 ,Pin 164 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI165 ,Pin 165 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI166 ,Pin 166 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI167 ,Pin 167 data in" "L,H"
group.long 0xC3F908A8++0x03
  line.long    0x00 "168-171,GPIO Pin Data In Register 168-171"
  bitfld.long  0x00 24.                  "PDI168 ,Pin 168 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI169 ,Pin 169 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI170 ,Pin 170 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI171 ,Pin 171 data in" "L,H"
group.long 0xC3F908AC++0x03
  line.long    0x00 "172-175,GPIO Pin Data In Register 172-175"
  bitfld.long  0x00 24.                  "PDI172 ,Pin 172 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI173 ,Pin 173 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI174 ,Pin 174 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI175 ,Pin 175 data in" "L,H"
group.long 0xC3F908B0++0x03
  line.long    0x00 "176-179,GPIO Pin Data In Register 176-179"
  bitfld.long  0x00 24.                  "PDI176 ,Pin 176 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI177 ,Pin 177 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI178 ,Pin 178 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI179 ,Pin 179 data in" "L,H"
group.long 0xC3F908B4++0x03
  line.long    0x00 "180-183,GPIO Pin Data In Register 180-183"
  bitfld.long  0x00 24.                  "PDI180 ,Pin 180 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI181 ,Pin 181 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI182 ,Pin 182 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI183 ,Pin 183 data in" "L,H"
group.long 0xC3F908B8++0x03
  line.long    0x00 "184-187,GPIO Pin Data In Register 184-187"
  bitfld.long  0x00 24.                  "PDI184 ,Pin 184 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI185 ,Pin 185 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI186 ,Pin 186 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI187 ,Pin 187 data in" "L,H"
group.long 0xC3F908BC++0x03
  line.long    0x00 "188-191,GPIO Pin Data In Register 188-191"
  bitfld.long  0x00 24.                  "PDI188 ,Pin 188 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI189 ,Pin 189 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI190 ,Pin 190 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI191 ,Pin 191 data in" "L,H"
group.long 0xC3F908C0++0x03
  line.long    0x00 "192-195,GPIO Pin Data In Register 192-195"
  bitfld.long  0x00 24.                  "PDI192 ,Pin 192 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI193 ,Pin 193 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI194 ,Pin 194 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI195 ,Pin 195 data in" "L,H"
group.long 0xC3F908C4++0x03
  line.long    0x00 "196-199,GPIO Pin Data In Register 196-199"
  bitfld.long  0x00 24.                  "PDI196 ,Pin 196 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI197 ,Pin 197 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI198 ,Pin 198 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI199 ,Pin 199 data in" "L,H"
group.long 0xC3F908C8++0x03
  line.long    0x00 "200-203,GPIO Pin Data In Register 200-203"
  bitfld.long  0x00 24.                  "PDI200 ,Pin 200 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI201 ,Pin 201 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI202 ,Pin 202 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI203 ,Pin 203 data in" "L,H"
group.long 0xC3F908CC++0x03
  line.long    0x00 "204-207,GPIO Pin Data In Register 204-207"
  bitfld.long  0x00 24.                  "PDI204 ,Pin 204 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI205 ,Pin 205 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI206 ,Pin 206 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI207 ,Pin 207 data in" "L,H"
group.long 0xC3F908D0++0x03
  line.long    0x00 "208-211,GPIO Pin Data In Register 208-211"
  bitfld.long  0x00 24.                  "PDI208 ,Pin 208 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI209 ,Pin 209 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI210 ,Pin 210 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI211 ,Pin 211 data in" "L,H"
group.long 0xC3F908D4++0x03
  line.long    0x00 "212-215,GPIO Pin Data In Register 212-215"
  bitfld.long  0x00 24.                  "PDI212 ,Pin 212 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI213 ,Pin 213 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI214 ,Pin 214 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI215 ,Pin 215 data in" "L,H"
group.long 0xC3F908D8++0x03
  line.long    0x00 "216-219,GPIO Pin Data In Register 216-219"
  bitfld.long  0x00 24.                  "PDI216 ,Pin 216 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI217 ,Pin 217 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI218 ,Pin 218 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI219 ,Pin 219 data in" "L,H"
group.long 0xC3F908DC++0x03
  line.long    0x00 "220-223,GPIO Pin Data In Register 220-223"
  bitfld.long  0x00 24.                  "PDI220 ,Pin 220 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI221 ,Pin 221 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI222 ,Pin 222 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI223 ,Pin 223 data in" "L,H"
group.long 0xC3F908E0++0x03
  line.long    0x00 "224-227,GPIO Pin Data In Register 224-227"
  bitfld.long  0x00 24.                  "PDI224 ,Pin 224 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI225 ,Pin 225 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI226 ,Pin 226 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI227 ,Pin 227 data in" "L,H"
group.long 0xC3F908E4++0x03
  line.long    0x00 "228-231,GPIO Pin Data In Register 228-231"
  bitfld.long  0x00 24.                  "PDI228 ,Pin 228 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI229 ,Pin 229 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI230 ,Pin 230 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI231 ,Pin 231 data in" "L,H"
group.long 0xC3F908E8++0x03
  line.long    0x00 "232-235,GPIO Pin Data In Register 232-235"
  bitfld.long  0x00 24.                  "PDI232 ,Pin 232 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI233 ,Pin 233 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI234 ,Pin 234 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI235 ,Pin 235 data in" "L,H"
group.long 0xC3F908EC++0x03
  line.long    0x00 "236-239,GPIO Pin Data In Register 236-239"
  bitfld.long  0x00 24.                  "PDI236 ,Pin 236 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI237 ,Pin 237 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI238 ,Pin 238 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI239 ,Pin 239 data in" "L,H"
group.long 0xC3F908F0++0x03
  line.long    0x00 "240-243,GPIO Pin Data In Register 240-243"
  bitfld.long  0x00 24.                  "PDI240 ,Pin 240 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI241 ,Pin 241 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI242 ,Pin 242 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI243 ,Pin 243 data in" "L,H"
group.long 0xC3F908F4++0x03
  line.long    0x00 "244-247,GPIO Pin Data In Register 244-247"
  bitfld.long  0x00 24.                  "PDI244 ,Pin 244 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI245 ,Pin 245 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI246 ,Pin 246 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI247 ,Pin 247 data in" "L,H"
group.long 0xC3F908F8++0x03
  line.long    0x00 "248-251,GPIO Pin Data In Register 248-251"
  bitfld.long  0x00 24.                  "PDI248 ,Pin 248 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI249 ,Pin 249 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI250 ,Pin 250 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI251 ,Pin 251 data in" "L,H"
group.long 0xC3F908FC++0x03
  line.long    0x00 "252-255,GPIO Pin Data In Register 252-255"
  bitfld.long  0x00 24.                  "PDI252 ,Pin 252 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI253 ,Pin 253 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI254 ,Pin 254 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI255 ,Pin 255 data in" "L,H"

group.long 0xC3F90900++0x03
  line.long    0x00 "256-259,GPIO Pin Data In Register 256-259"
  bitfld.long  0x00 24.                  "PDI256 ,Pin 256 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI257 ,Pin 257 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI258 ,Pin 258 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI259 ,Pin 259 data in" "L,H"
group.long 0xC3F90904++0x03
  line.long    0x00 "260-263,GPIO Pin Data In Register 260-263"
  bitfld.long  0x00 24.                  "PDI260 ,Pin 260 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI261 ,Pin 261 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI262 ,Pin 262 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI263 ,Pin 263 data in" "L,H"
group.long 0xC3F90908++0x03
  line.long    0x00 "264-267,GPIO Pin Data In Register 264-267"
  bitfld.long  0x00 24.                  "PDI264 ,Pin 264 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI265 ,Pin 265 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI266 ,Pin 266 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI267 ,Pin 267 data in" "L,H"
group.long 0xC3F9090C++0x03
  line.long    0x00 "268-271,GPIO Pin Data In Register 268-271"
  bitfld.long  0x00 24.                  "PDI268 ,Pin 268 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI269 ,Pin 269 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI270 ,Pin 270 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI271 ,Pin 271 data in" "L,H"
group.long 0xC3F90910++0x03
  line.long    0x00 "272-275,GPIO Pin Data In Register 272-275"
  bitfld.long  0x00 24.                  "PDI272 ,Pin 272 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI273 ,Pin 273 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI274 ,Pin 274 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI275 ,Pin 275 data in" "L,H"
group.long 0xC3F90914++0x03
  line.long    0x00 "276-279,GPIO Pin Data In Register 276-279"
  bitfld.long  0x00 24.                  "PDI276 ,Pin 276 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI277 ,Pin 277 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI278 ,Pin 278 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI279 ,Pin 279 data in" "L,H"
group.long 0xC3F90918++0x03
  line.long    0x00 "280-283,GPIO Pin Data In Register 280-283"
  bitfld.long  0x00 24.                  "PDI280 ,Pin 280 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI281 ,Pin 281 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI282 ,Pin 282 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI283 ,Pin 283 data in" "L,H"
group.long 0xC3F9091C++0x03
  line.long    0x00 "284-287,GPIO Pin Data In Register 284-287"
  bitfld.long  0x00 24.                  "PDI284 ,Pin 284 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI285 ,Pin 285 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI286 ,Pin 286 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI287 ,Pin 287 data in" "L,H"
group.long 0xC3F90920++0x03
  line.long    0x00 "288-291,GPIO Pin Data In Register 288-291"
  bitfld.long  0x00 24.                  "PDI288 ,Pin 288 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI289 ,Pin 289 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI290 ,Pin 290 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI291 ,Pin 291 data in" "L,H"
group.long 0xC3F90924++0x03
  line.long    0x00 "292-295,GPIO Pin Data In Register 292-295"
  bitfld.long  0x00 24.                  "PDI292 ,Pin 292 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI293 ,Pin 293 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI294 ,Pin 294 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI295 ,Pin 295 data in" "L,H"
group.long 0xC3F90928++0x03
  line.long    0x00 "296-299,GPIO Pin Data In Register 296-299"
  bitfld.long  0x00 24.                  "PDI296 ,Pin 296 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI297 ,Pin 297 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI298 ,Pin 298 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI299 ,Pin 299 data in" "L,H"
group.long 0xC3F9092C++0x03
  line.long    0x00 "300-303,GPIO Pin Data In Register 300-303"
  bitfld.long  0x00 24.                  "PDI300 ,Pin 300 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI301 ,Pin 301 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI302 ,Pin 302 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI303 ,Pin 303 data in" "L,H"
group.long 0xC3F90930++0x03
  line.long    0x00 "304-307,GPIO Pin Data In Register 304-307"
  bitfld.long  0x00 24.                  "PDI304 ,Pin 304 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI305 ,Pin 305 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI306 ,Pin 306 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI307 ,Pin 307 data in" "L,H"
group.long 0xC3F90934++0x03
  line.long    0x00 "308-311,GPIO Pin Data In Register 308-311"
  bitfld.long  0x00 24.                  "PDI308 ,Pin 308 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI309 ,Pin 309 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI310 ,Pin 310 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI311 ,Pin 311 data in" "L,H"
group.long 0xC3F90938++0x03
  line.long    0x00 "312-315,GPIO Pin Data In Register 312-315"
  bitfld.long  0x00 24.                  "PDI312 ,Pin 312 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI313 ,Pin 313 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI314 ,Pin 314 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI315 ,Pin 315 data in" "L,H"
group.long 0xC3F9093C++0x03
  line.long    0x00 "316-319,GPIO Pin Data In Register 316-319"
  bitfld.long  0x00 24.                  "PDI316 ,Pin 316 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI317 ,Pin 317 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI318 ,Pin 318 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI319 ,Pin 319 data in" "L,H"
group.long 0xC3F90940++0x03
  line.long    0x00 "320-323,GPIO Pin Data In Register 320-323"
  bitfld.long  0x00 24.                  "PDI320 ,Pin 320 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI321 ,Pin 321 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI322 ,Pin 322 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI323 ,Pin 323 data in" "L,H"
group.long 0xC3F90944++0x03
  line.long    0x00 "324-327,GPIO Pin Data In Register 324-327"
  bitfld.long  0x00 24.                  "PDI324 ,Pin 324 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI325 ,Pin 325 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI326 ,Pin 326 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI327 ,Pin 327 data in" "L,H"
group.long 0xC3F90948++0x03
  line.long    0x00 "328-331,GPIO Pin Data In Register 328-331"
  bitfld.long  0x00 24.                  "PDI328 ,Pin 328 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI329 ,Pin 329 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI330 ,Pin 330 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI331 ,Pin 331 data in" "L,H"
group.long 0xC3F9094C++0x03
  line.long    0x00 "332-335,GPIO Pin Data In Register 332-335"
  bitfld.long  0x00 24.                  "PDI332 ,Pin 332 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI333 ,Pin 333 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI334 ,Pin 334 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI335 ,Pin 335 data in" "L,H"
group.long 0xC3F90950++0x03
  line.long    0x00 "336-339,GPIO Pin Data In Register 336-339"
  bitfld.long  0x00 24.                  "PDI336 ,Pin 336 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI337 ,Pin 337 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI338 ,Pin 338 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI339 ,Pin 339 data in" "L,H"
group.long 0xC3F90954++0x03
  line.long    0x00 "340-343,GPIO Pin Data In Register 340-343"
  bitfld.long  0x00 24.                  "PDI340 ,Pin 340 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI341 ,Pin 341 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI342 ,Pin 342 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI343 ,Pin 343 data in" "L,H"
group.long 0xC3F90958++0x03
  line.long    0x00 "344-347,GPIO Pin Data In Register 344-347"
  bitfld.long  0x00 24.                  "PDI344 ,Pin 344 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI345 ,Pin 345 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI346 ,Pin 346 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI347 ,Pin 347 data in" "L,H"
group.long 0xC3F9095C++0x03
  line.long    0x00 "348-351,GPIO Pin Data In Register 348-351"
  bitfld.long  0x00 24.                  "PDI348 ,Pin 348 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI349 ,Pin 349 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI350 ,Pin 350 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI351 ,Pin 351 data in" "L,H"
group.long 0xC3F90960++0x03
  line.long    0x00 "352-355,GPIO Pin Data In Register 352-355"
  bitfld.long  0x00 24.                  "PDI352 ,Pin 352 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI353 ,Pin 353 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI354 ,Pin 354 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI355 ,Pin 355 data in" "L,H"
group.long 0xC3F90964++0x03
  line.long    0x00 "356-359,GPIO Pin Data In Register 356-359"
  bitfld.long  0x00 24.                  "PDI356 ,Pin 356 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI357 ,Pin 357 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI358 ,Pin 358 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI359 ,Pin 359 data in" "L,H"
group.long 0xC3F90968++0x03
  line.long    0x00 "360-363,GPIO Pin Data In Register 360-363"
  bitfld.long  0x00 24.                  "PDI360 ,Pin 360 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI361 ,Pin 361 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI362 ,Pin 362 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI363 ,Pin 363 data in" "L,H"
group.long 0xC3F9096C++0x03
  line.long    0x00 "364-367,GPIO Pin Data In Register 364-367"
  bitfld.long  0x00 24.                  "PDI364 ,Pin 364 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI365 ,Pin 365 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI366 ,Pin 366 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI367 ,Pin 367 data in" "L,H"
group.long 0xC3F90970++0x03
  line.long    0x00 "368-371,GPIO Pin Data In Register 368-371"
  bitfld.long  0x00 24.                  "PDI368 ,Pin 368 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI369 ,Pin 369 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI370 ,Pin 370 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI371 ,Pin 371 data in" "L,H"
group.long 0xC3F90974++0x03
  line.long    0x00 "372-375,GPIO Pin Data In Register 372-375"
  bitfld.long  0x00 24.                  "PDI372 ,Pin 372 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI373 ,Pin 373 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI374 ,Pin 374 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI375 ,Pin 375 data in" "L,H"
group.long 0xC3F90978++0x03
  line.long    0x00 "376-379,GPIO Pin Data In Register 376-379"
  bitfld.long  0x00 24.                  "PDI376 ,Pin 376 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI377 ,Pin 377 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI378 ,Pin 378 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI379 ,Pin 379 data in" "L,H"
group.long 0xC3F9097C++0x03
  line.long    0x00 "380-383,GPIO Pin Data In Register 380-383"
  bitfld.long  0x00 24.                  "PDI380 ,Pin 380 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI381 ,Pin 381 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI382 ,Pin 382 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI383 ,Pin 383 data in" "L,H"
group.long 0xC3F90980++0x03
  line.long    0x00 "384-387,GPIO Pin Data In Register 384-387"
  bitfld.long  0x00 24.                  "PDI384 ,Pin 384 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI385 ,Pin 385 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI386 ,Pin 386 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI387 ,Pin 387 data in" "L,H"
group.long 0xC3F90984++0x03
  line.long    0x00 "388-391,GPIO Pin Data In Register 388-391"
  bitfld.long  0x00 24.                  "PDI388 ,Pin 388 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI389 ,Pin 389 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI390 ,Pin 390 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI391 ,Pin 391 data in" "L,H"
group.long 0xC3F90988++0x03
  line.long    0x00 "392-395,GPIO Pin Data In Register 392-395"
  bitfld.long  0x00 24.                  "PDI392 ,Pin 392 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI393 ,Pin 393 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI394 ,Pin 394 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI395 ,Pin 395 data in" "L,H"
group.long 0xC3F9098C++0x03
  line.long    0x00 "396-399,GPIO Pin Data In Register 396-399"
  bitfld.long  0x00 24.                  "PDI396 ,Pin 396 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI397 ,Pin 397 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI398 ,Pin 398 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI399 ,Pin 399 data in" "L,H"
group.long 0xC3F90990++0x03
  line.long    0x00 "400-403,GPIO Pin Data In Register 400-403"
  bitfld.long  0x00 24.                  "PDI400 ,Pin 400 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI401 ,Pin 401 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI402 ,Pin 402 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI403 ,Pin 403 data in" "L,H"
group.long 0xC3F90994++0x03
  line.long    0x00 "404-407,GPIO Pin Data In Register 404-407"
  bitfld.long  0x00 24.                  "PDI404 ,Pin 404 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI405 ,Pin 405 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI406 ,Pin 406 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI407 ,Pin 407 data in" "L,H"
group.long 0xC3F90998++0x03
  line.long    0x00 "408-411,GPIO Pin Data In Register 408-411"
  bitfld.long  0x00 24.                  "PDI408 ,Pin 408 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI409 ,Pin 409 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI410 ,Pin 410 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI411 ,Pin 411 data in" "L,H"
group.long 0xC3F9099C++0x03
  line.long    0x00 "412-415,GPIO Pin Data In Register 412-415"
  bitfld.long  0x00 24.                  "PDI412 ,Pin 412 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI413 ,Pin 413 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI414 ,Pin 414 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI415 ,Pin 415 data in" "L,H"
group.long 0xC3F909A0++0x03
  line.long    0x00 "416-419,GPIO Pin Data In Register 416-419"
  bitfld.long  0x00 24.                  "PDI416 ,Pin 416 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI417 ,Pin 417 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI418 ,Pin 418 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI419 ,Pin 419 data in" "L,H"
group.long 0xC3F909A4++0x03
  line.long    0x00 "420-423,GPIO Pin Data In Register 420-423"
  bitfld.long  0x00 24.                  "PDI420 ,Pin 420 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI421 ,Pin 421 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI422 ,Pin 422 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI423 ,Pin 423 data in" "L,H"
group.long 0xC3F909A8++0x03
  line.long    0x00 "424-427,GPIO Pin Data In Register 424-427"
  bitfld.long  0x00 24.                  "PDI424 ,Pin 424 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI425 ,Pin 425 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI426 ,Pin 426 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI427 ,Pin 427 data in" "L,H"
group.long 0xC3F909AC++0x03
  line.long    0x00 "428-431,GPIO Pin Data In Register 428-431"
  bitfld.long  0x00 24.                  "PDI428 ,Pin 428 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI429 ,Pin 429 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI430 ,Pin 430 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI431 ,Pin 431 data in" "L,H"
group.long 0xC3F909B0++0x03
  line.long    0x00 "432-435,GPIO Pin Data In Register 432-435"
  bitfld.long  0x00 24.                  "PDI432 ,Pin 432 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI433 ,Pin 433 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI434 ,Pin 434 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI435 ,Pin 435 data in" "L,H"
group.long 0xC3F909B4++0x03
  line.long    0x00 "436-439,GPIO Pin Data In Register 436-439"
  bitfld.long  0x00 24.                  "PDI436 ,Pin 436 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI437 ,Pin 437 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI438 ,Pin 438 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI439 ,Pin 439 data in" "L,H"
group.long 0xC3F909B8++0x03
  line.long    0x00 "440-443,GPIO Pin Data In Register 440-443"
  bitfld.long  0x00 24.                  "PDI440 ,Pin 440 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI441 ,Pin 441 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI442 ,Pin 442 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI443 ,Pin 443 data in" "L,H"
group.long 0xC3F909BC++0x03
  line.long    0x00 "444-447,GPIO Pin Data In Register 444-447"
  bitfld.long  0x00 24.                  "PDI444 ,Pin 444 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI445 ,Pin 445 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI446 ,Pin 446 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI447 ,Pin 447 data in" "L,H"
group.long 0xC3F909C0++0x03
  line.long    0x00 "448-451,GPIO Pin Data In Register 448-451"
  bitfld.long  0x00 24.                  "PDI448 ,Pin 448 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI449 ,Pin 449 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI450 ,Pin 450 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI451 ,Pin 451 data in" "L,H"
group.long 0xC3F909C4++0x03
  line.long    0x00 "452-455,GPIO Pin Data In Register 452-455"
  bitfld.long  0x00 24.                  "PDI452 ,Pin 452 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI453 ,Pin 453 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI454 ,Pin 454 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI455 ,Pin 455 data in" "L,H"
group.long 0xC3F909C8++0x03
  line.long    0x00 "456-459,GPIO Pin Data In Register 456-459"
  bitfld.long  0x00 24.                  "PDI456 ,Pin 456 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI457 ,Pin 457 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI458 ,Pin 458 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI459 ,Pin 459 data in" "L,H"
group.long 0xC3F909CC++0x03
  line.long    0x00 "460-463,GPIO Pin Data In Register 460-463"
  bitfld.long  0x00 24.                  "PDI460 ,Pin 460 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI461 ,Pin 461 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI462 ,Pin 462 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI463 ,Pin 463 data in" "L,H"
group.long 0xC3F909D0++0x03
  line.long    0x00 "464-467,GPIO Pin Data In Register 464-467"
  bitfld.long  0x00 24.                  "PDI464 ,Pin 464 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI465 ,Pin 465 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI466 ,Pin 466 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI467 ,Pin 467 data in" "L,H"
group.long 0xC3F909D4++0x03
  line.long    0x00 "468-471,GPIO Pin Data In Register 468-471"
  bitfld.long  0x00 24.                  "PDI468 ,Pin 468 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI469 ,Pin 469 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI470 ,Pin 470 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI471 ,Pin 471 data in" "L,H"
group.long 0xC3F909D8++0x03
  line.long    0x00 "472-475,GPIO Pin Data In Register 472-475"
  bitfld.long  0x00 24.                  "PDI472 ,Pin 472 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI473 ,Pin 473 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI474 ,Pin 474 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI475 ,Pin 475 data in" "L,H"
group.long 0xC3F909DC++0x03
  line.long    0x00 "476-479,GPIO Pin Data In Register 476-479"
  bitfld.long  0x00 24.                  "PDI476 ,Pin 476 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI477 ,Pin 477 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI478 ,Pin 478 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI479 ,Pin 479 data in" "L,H"
group.long 0xC3F909E0++0x03
  line.long    0x00 "480-483,GPIO Pin Data In Register 480-483"
  bitfld.long  0x00 24.                  "PDI480 ,Pin 480 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI481 ,Pin 481 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI482 ,Pin 482 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI483 ,Pin 483 data in" "L,H"
group.long 0xC3F909E4++0x03
  line.long    0x00 "484-487,GPIO Pin Data In Register 484-487"
  bitfld.long  0x00 24.                  "PDI484 ,Pin 484 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI485 ,Pin 485 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI486 ,Pin 486 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI487 ,Pin 487 data in" "L,H"
group.long 0xC3F909E8++0x03
  line.long    0x00 "488-491,GPIO Pin Data In Register 488-491"
  bitfld.long  0x00 24.                  "PDI488 ,Pin 488 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI489 ,Pin 489 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI490 ,Pin 490 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI491 ,Pin 491 data in" "L,H"
group.long 0xC3F909EC++0x03
  line.long    0x00 "492-495,GPIO Pin Data In Register 492-495"
  bitfld.long  0x00 24.                  "PDI492 ,Pin 492 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI493 ,Pin 493 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI494 ,Pin 494 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI495 ,Pin 495 data in" "L,H"
group.long 0xC3F909F0++0x03
  line.long    0x00 "496-499,GPIO Pin Data In Register 496-499"
  bitfld.long  0x00 24.                  "PDI496 ,Pin 496 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI497 ,Pin 497 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI498 ,Pin 498 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI499 ,Pin 499 data in" "L,H"
group.long 0xC3F909F4++0x03
  line.long    0x00 "500-503,GPIO Pin Data In Register 500-503"
  bitfld.long  0x00 24.                  "PDI500 ,Pin 500 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI501 ,Pin 501 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI502 ,Pin 502 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI503 ,Pin 503 data in" "L,H"
group.long 0xC3F909F8++0x03
  line.long    0x00 "504-507,GPIO Pin Data In Register 504-507"
  bitfld.long  0x00 24.                  "PDI504 ,Pin 504 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI505 ,Pin 505 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI506 ,Pin 506 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI507 ,Pin 507 data in" "L,H"
group.long 0xC3F909FC++0x03
  line.long    0x00 "508-511,GPIO Pin Data In Register 508-511"
  bitfld.long  0x00 24.                  "PDI508 ,Pin 508 data in" "L,H"
  bitfld.long  0x00 16.                  "  PDI509 ,Pin 509 data in" "L,H"
  bitfld.long  0x00 08.                  "  PDI510 ,Pin 510 data in" "L,H"
  bitfld.long  0x00 00.                  "  PDI511 ,Pin 511 data in" "L,H"
tree.end

endif


tree "IMUX Select Registers"

sif ((cpu()=="MPC5632M")||(cpu()=="MPC5633M")||(cpu()=="MPC5634M")||(cpu()=="SPC563M54")||(cpu()=="SPC563M60")||(cpu()=="SPC563M64"))

group.long 0xC3F90900++0x03
  line.long    0x00 "ISEL0,ETISR - eQADC Trigger Input Select Register"
  bitfld.long  0x00 30.--31.             "TSEL5 ,eQADC trigger input select 5"   "eTSEL5,ETPUA26 channel,EMIOS12 channel,ETRIG1 pin"
  bitfld.long  0x00 28.--29.             "  TSEL4 ,eQADC trigger input select 4" "eTSEL4,ETPUA27 channel,EMIOS13 channel,ETRIG0 pin"
TEXTLINE "                   "
  bitfld.long  0x00 26.--27.             "  TSEL3 ,eQADC trigger input select 3" "eTSEL3,ETPUA28 channel,EMIOS14 channel,ETRIG1 pin"
  bitfld.long  0x00 24.--25.             "  TSEL2 ,eQADC trigger input select 2" "eTSEL2,ETPUA29 channel,EMIOS15 channel,ETRIG0 pin"
TEXTLINE "                   "
  bitfld.long  0x00 22.--23.             "  TSEL1 ,eQADC trigger input select 1" "eTSEL1,ETPUA31 channel,EMIOS11 channel,ETRIG1 pin"
  bitfld.long  0x00 20.--21.             "  TSEL0 ,eQADC trigger input select 0" "eTSEL0,ETPUA30 channel,EMIOS10 channel,ETRIG0 pin"
TEXTLINE ""

group.long 0xC3F90904++0x03
  line.long    0x00 "ISEL1,EIISR - External IRQ Input Select Register"
  bitfld.long  0x00 30.--31.             "ESEL15 ,External IRQ input select 15"   "IRQ15 pin,DSPI_B15,DSPI_C00,DSPI_D01"
  bitfld.long  0x00 28.--29.             "  ESEL14 ,External IRQ input select 14" "IRQ14 pin,DSPI_B14,DSPI_C15,DSPI_D00"
  bitfld.long  0x00 26.--27.             "  ESEL13 ,External IRQ input select 13" "IRQ13 pin,DSPI_B13,DSPI_C14,DSPI_D15"
  bitfld.long  0x00 24.--25.             "  ESEL12 ,External IRQ input select 12" "IRQ12 pin,DSPI_B12,DSPI_C13,DSPI_D14"
TEXTLINE "                   "
  bitfld.long  0x00 22.--23.             "  ESEL11 ,External IRQ input select 11" "IRQ11 pin,DSPI_B11,DSPI_C12,DSPI_D13"
  bitfld.long  0x00 20.--21.             "  ESEL10 ,External IRQ input select 10" "IRQ10 pin,DSPI_B10,DSPI_C11,DSPI_D12"
  bitfld.long  0x00 18.--19.             "  ESEL09 ,External IRQ input select 09" "IRQ09 pin,DSPI_B09,DSPI_C10,DSPI_D11"
  bitfld.long  0x00 16.--17.             "  ESEL08 ,External IRQ input select 08" "IRQ08 pin,DSPI_B08,DSPI_C09,DSPI_D10"
TEXTLINE "                   "
  bitfld.long  0x00 14.--15.             "  ESEL07 ,External IRQ input select 07" "IRQ07 pin,DSPI_B07,DSPI_C08,DSPI_D09"
  bitfld.long  0x00 12.--13.             "  ESEL06 ,External IRQ input select 06" "IRQ06 pin,DSPI_B06,DSPI_C07,DSPI_D08"
  bitfld.long  0x00 10.--11.             "  ESEL05 ,External IRQ input select 05" "IRQ05 pin,DSPI_B05,DSPI_C06,DSPI_D07"
  bitfld.long  0x00 08.--09.             "  ESEL04 ,External IRQ input select 04" "IRQ04 pin,DSPI_B04,DSPI_C05,DSPI_D06"
TEXTLINE "                   "
  bitfld.long  0x00 06.--07.             "  ESEL03 ,External IRQ input select 03" "IRQ03 pin,DSPI_B03,DSPI_C04,DSPI_D05"
  bitfld.long  0x00 04.--05.             "  ESEL02 ,External IRQ input select 02" "IRQ02 pin,DSPI_B02,DSPI_C03,DSPI_D04"
  bitfld.long  0x00 02.--03.             "  ESEL01 ,External IRQ input select 01" "IRQ01 pin,DSPI_B01,DSPI_C02,DSPI_D03"
  bitfld.long  0x00 00.--01.             "  ESEL00 ,External IRQ input select 00" "IRQ00 pin,DSPI_B00,DSPI_C01,DSPI_D02"
TEXTLINE ""

group.long 0xC3F90908++0x03
  line.long    0x00 "ISEL2,DISR - DSPI Input Select Register"
;  bitfld.long  0x00 30.--31.             "SINSELA ,DSPI_A data input select"           "SINA_GPIO94 pin       ,SOUTB,SOUTC,SOUTD"
;  bitfld.long  0x00 28.--29.             "  SSSELA ,DSPI_A slave select input select"  "PCSA0_GPIO96 pin       ,PCSB0,PCSC0,PCSD0"
;  bitfld.long  0x00 26.--27.             "  SCKSELA ,DSPI_A clock input select"        "SCKA_GPIO93 pin       ,SCKB,SCKC,SCKD"
;  bitfld.long  0x00 24.--25.             "  TRIGSELA ,DSPI_A trigger input select"     "res.,PCSB4,PCSC4,PCSD4"
;TEXTLINE "                   "
  bitfld.long  0x00 22.--23.               "SINSELB  ,DSPI_B data input select"         "DSPI_B_SIN_DSPI_C_PCS[2]_GPIO[103] pin   ,res.,DSPI_C_SOUT,res."
TEXTLINE "                   "
  bitfld.long  0x00 20.--21.             "  SSSELB   ,DSPI_B slave select input select" "DSPI_B_PCS[0]_DSPI_D_PCS[2]_GPIO[105] pin,res.,DSPI_C_CS[0],res."
TEXTLINE "                   "
  bitfld.long  0x00 18.--19.             "  SCKSELB  ,DSPI_B clock input select"        "DSPI_B_SCK_DSPI_C_PCS[1]_GPIO[102] pin   ,res.,DSPI_C_SCK,res."
TEXTLINE "                   "
  bitfld.long  0x00 16.--17.             "  TRIGSELB ,DSPI_B trigger input select"      "res.                                     ,res.,DSPI_C_CS,res."
TEXTLINE ""
TEXTLINE "                   "
  bitfld.long  0x00 14.--15.             "  SINSELC  ,DSPI_C data input select"         "DSPI_A_PCS[2]_DSPI_C_SIN_GPIO[108] pin   ,res.,DSPI_B_SOUT,res."
TEXTLINE "                   "
  bitfld.long  0x00 12.--13.             "  SSSELC   ,DSPI_C slave select input select" "DSPI_B_PCS[5]_DSPI_C_PCS[0]_GPIO[110] pin,res.,DSPI_B_CS[0],res."
TEXTLINE "                   "
  bitfld.long  0x00 10.--11.             "  SCKSELC  ,DSPI_C clock input select"        "DSPI_B_PCS[4]_DSPI_C_SCK_GPIO[109] pin   ,res.,DSPI_B_SCK,res."
TEXTLINE "                   "
  bitfld.long  0x00 08.--09.             "  TRIGSELC ,DSPI_C trigger input select"      "res.                                     ,res.,DSPI_B_CS[4],res."
;TEXTLINE "                   "
;  bitfld.long  0x00 06.--07.             "  SINSELD  ,DSPI_D data input select"  "PCSA3_SIND_GPIO99 pin ,SOUTA,SOUTB,SOUTC"
;  bitfld.long  0x00 04.--05.             "  SSSELD   ,DSPI_D slave select input select" "PCSB1_PCSD0_GPIO106 pin,PCSA0,PCSB0,PCSC0"
;  bitfld.long  0x00 02.--03.             "  SCKSELD  ,DSPI_D clock input select" "PCSA2_SCKD_GPIO98 pin ,SCKA,SCKB,SCKC"
;  bitfld.long  0x00 00.--01.             "  TRIGSELD ,DSPI_D trigger input select" "res.,PCSA4,PCSB4,PCSC4"
TEXTLINE ""

group.long 0xC3F9090C++0x03
  line.long    0x00 "ISEL3,MUX Select Register 3"
  bitfld.long  0x00 25.--29.             "eTSEL5 ,eQADC Enhanced Trigger Input"   "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
TEXTLINE "                   "
  bitfld.long  0x00 20.--24.             "  eTSEL4 ,eQADC Enhanced Trigger Input"   "GPIO206 (eTRIG0),RTI Trigger,PIT0 Trigger,PIT1 Trigger,PIT2 Trigger,PIT3 Trigger,Reserved(6),BOOTCFG[1] (eTRIG3),eTPU30 AND PIT0,eTPU30 AND PIT1,Reserved(10),Reserved(11),eTPUA28,eTPUA29,eTPUA30,eTPUA31,Reserved(16),Reserved(17),Reserved(18),Reserved(19),eMIOS10 AND PIT2,eMIOS10 AND PIT3,Reserved(22),Reserved(23),Reserved(24),Reserved(25),Reserved(26),Reserved(27),Reserved(28),Reserved(29),Reserved(30),eMIOS23"
TEXTLINE "                   "
  bitfld.long  0x00 15.--19.             "  eTSEL3 ,eQADC Enhanced Trigger Input"   "GPIO207 (eTRIG1),RTI Trigger,PIT0 Trigger,PIT1 Trigger,PIT2 Trigger,PIT3 Trigger,Reserved(6),PLLREF (eTRIG2),eTPU30 AND PIT0,eTPU30 AND PIT1,Reserved(10),Reserved(11),eTPUA28,eTPUA29,eTPUA30,eTPUA31,Reserved(16),Reserved(17),Reserved(18),Reserved(19),eMIOS10 AND PIT2,eMIOS10 AND PIT3,Reserved(22),Reserved(23),Reserved(24),Reserved(25),Reserved(26),Reserved(27),Reserved(28),Reserved(29),Reserved(30),eMIOS23"
TEXTLINE "                   "
  bitfld.long  0x00 10.--14.             "  eTSEL2 ,eQADC Enhanced Trigger Input"   "GPIO206 (eTRIG0),RTI Trigger,PIT0 Trigger,PIT1 Trigger,PIT2 Trigger,PIT3 Trigger,Reserved(6),BOOTCFG[1] (eTRIG3),eTPU30 AND PIT0,eTPU30 AND PIT1,Reserved(10),Reserved(11),eTPUA28,eTPUA29,eTPUA30,eTPUA31,Reserved(16),Reserved(17),Reserved(18),Reserved(19),eMIOS10 AND PIT2,eMIOS10 AND PIT3,Reserved(22),Reserved(23),Reserved(24),Reserved(25),Reserved(26),Reserved(27),Reserved(28),Reserved(29),Reserved(30),eMIOS23"
TEXTLINE "                   "
  bitfld.long  0x00 05.--09.             "  eTSEL1 ,eQADC Enhanced Trigger Input"   "GPIO207 (eTRIG1),RTI Trigger,PIT0 Trigger,PIT1 Trigger,PIT2 Trigger,PIT3 Trigger,Reserved(6),PLLREF (eTRIG2),eTPU31 AND PIT0,eTPU31 AND PIT1,Reserved(10),Reserved(11),eTPUA28,eTPUA29,eTPUA30,eTPUA31,Reserved(16),Reserved(17),Reserved(18),Reserved(19),eMIOS11 AND PIT2,eMIOS11 AND PIT3,Reserved(22),Reserved(23),Reserved(24),Reserved(25),Reserved(26),Reserved(27),Reserved(28),Reserved(29),Reserved(30),eMIOS23"
TEXTLINE "                   "
  bitfld.long  0x00 00.--04.             "  eTSEL0 ,eQADC Enhanced Trigger Input"   "GPIO206 (eTRIG0),RTI Trigger,PIT0 Trigger,PIT1 Trigger,PIT2 Trigger,PIT3 Trigger,Reserved,BOOTCFG[1] (eTRIG3),eTPU30 AND PIT0,eTPU30 AND PIT1,Reserved(10),Reserved(11),eTPUA28,eTPUA29,eTPUA30,eTPUA31,Reserved(16),Reserved(17),Reserved(18),Reserved(19),eMIOS10 AND PIT2,eMIOS10 AND PIT3,Reserved(22),Reserved(23),Reserved(24),Reserved(25),Reserved(26),Reserved(27),Reserved(28),Reserved(29),Reserved(30),eMIOS23"
TEXTLINE ""

group.long 0xC3F90920++0x03
  line.long    0x00 "ISEL8,MUX Select Register 8"
  bitfld.long  0x00 20.                  "eSEL5 ,eTPU input channels"   "DSPI_B Serialized input 8 ,eTPU channel 29"
TEXTLINE "                   "
  bitfld.long  0x00 16.                  "  eSEL4 ,eTPU input channels"   "DSPI_B Serialized input 9 ,eTPU channel 28"
TEXTLINE "                   "
  bitfld.long  0x00 12.                  "  eSEL3 ,eTPU input channels"   "DSPI_B Serialized input 10,eTPU channel 27"
TEXTLINE "                   "
  bitfld.long  0x00 08.                  "  eSEL2 ,eTPU input channels"   "DSPI_B Serialized input 11,eTPU channel 26"
TEXTLINE "                   "
  bitfld.long  0x00 04.                  "  eSEL1 ,eTPU input channels"   "DSPI_B Serialized input 12,eTPU channel 25"
TEXTLINE "                   "
  bitfld.long  0x00 00.                  "  eSEL0 ,eTPU input channels"   "DSPI_B Serialized input 13,eTPU channel 24"
TEXTLINE ""

group.long 0xC3F90924++0x03
  line.long    0x00 "ISEL9,MUX Select Register 9"
  bitfld.long  0x00 00.--04.             "eTSEL0A ,eQADC Trigger Input"   "GPIO206 (eTRIG0),RTI Trigger,PIT0 Trigger,PIT1 Trigger,PIT2 Trigger,PIT3 Trigger,Reserved(6),BOOTCFG[1] (eTRIG3),eTPU30 AND PIT0,eTPU30 AND PIT1,Reserved(10),Reserved(11),eTPUA28,eTPUA29,eTPUA30,eTPUA31,Reserved(16),Reserved(17),Reserved(18),Reserved(19),eMIOS10 AND PIT2,eMIOS10 AND PIT3,Reserved(22),Reserved(23),Reserved(24),Reserved(25),Reserved(26),Reserved(27),Reserved(28),Reserved(29),Reserved(30),eMIOS23"

endif


sif (CPUIS("MPC5674*"))

group.long 0xC3F90904++0x03
  line.long    0x00 "EIISR,External IRQ Input Select Register"
  bitfld.long  0x00 30.--31.             "ESEL15 ,External IRQ input select 15"   "IRQ15 pin,DSPI_B15,DSPI_C00,DSPI_D01"
  bitfld.long  0x00 28.--29.             "  ESEL14 ,External IRQ input select 14" "IRQ14 pin,DSPI_B14,DSPI_C15,DSPI_D00"
  bitfld.long  0x00 26.--27.             "  ESEL13 ,External IRQ input select 13" "IRQ13 pin,DSPI_B13,DSPI_C14,DSPI_D15"
  bitfld.long  0x00 24.--25.             "  ESEL12 ,External IRQ input select 12" "IRQ12 pin,DSPI_B12,DSPI_C13,DSPI_D14"
TEXTLINE "                   "
  bitfld.long  0x00 22.--23.             "  ESEL11 ,External IRQ input select 11" "IRQ11 pin,DSPI_B11,DSPI_C12,DSPI_D13"
  bitfld.long  0x00 20.--21.             "  ESEL10 ,External IRQ input select 10" "IRQ10 pin,DSPI_B10,DSPI_C11,DSPI_D12"
  bitfld.long  0x00 18.--19.             "  ESEL09 ,External IRQ input select 09" "IRQ09 pin,DSPI_B09,DSPI_C10,DSPI_D11"
  bitfld.long  0x00 16.--17.             "  ESEL08 ,External IRQ input select 08" "IRQ08 pin,DSPI_B08,DSPI_C09,DSPI_D10"
TEXTLINE "                   "
  bitfld.long  0x00 14.--15.             "  ESEL07 ,External IRQ input select 07" "IRQ07 pin,DSPI_B07,DSPI_C08,DSPI_D09"
  bitfld.long  0x00 12.--13.             "  ESEL06 ,External IRQ input select 06" "IRQ06 pin,DSPI_B06,DSPI_C07,DSPI_D08"
  bitfld.long  0x00 10.--11.             "  ESEL05 ,External IRQ input select 05" "IRQ05 pin,DSPI_B05,DSPI_C06,DSPI_D07"
  bitfld.long  0x00 08.--09.             "  ESEL04 ,External IRQ input select 04" "IRQ04 pin,DSPI_B04,DSPI_C05,DSPI_D06"
TEXTLINE "                   "
  bitfld.long  0x00 06.--07.             "  ESEL03 ,External IRQ input select 03" "IRQ03 pin,DSPI_B03,DSPI_C04,DSPI_D05"
  bitfld.long  0x00 04.--05.             "  ESEL02 ,External IRQ input select 02" "IRQ02 pin,DSPI_B02,DSPI_C03,DSPI_D04"
  bitfld.long  0x00 02.--03.             "  ESEL01 ,External IRQ input select 01" "IRQ01 pin,DSPI_B01,DSPI_C02,DSPI_D03"
  bitfld.long  0x00 00.--01.             "  ESEL00 ,External IRQ input select 00" "IRQ00 pin,DSPI_B00,DSPI_C01,DSPI_D02"
TEXTLINE ""

group.long 0xC3F90908++0x03
  line.long    0x00 "DISR,DSPI Input Select Register"
  bitfld.long  0x00 30.--31.         "SINSELA  ,DSPI_A data input select"        "SINA_PCSC[2]_GPIO[94]pin     ,SOUTB  ,SOUTC,SOUTD"
TEXTLINE "                   "
  bitfld.long  0x00 28.--29.       "  SSSELA   ,DSPI_A slave select input select" "PCSA[0]_PCSD[2]_GPIO[96] pin ,PCSB0  ,PCSC0,PCSD0"
TEXTLINE "                   "
  bitfld.long  0x00 26.--27.       "  SCKSELA  ,DSPI_A clock input select"       "SCKA_PCSC[1]_GPIO[93] pin    ,SCKB   ,SCKC,SCKD"
TEXTLINE "                   "
  bitfld.long  0x00 24.--25.       "  TRIGSELA ,DSPI_A trigger input select"    "no trigger                   ,PCSB4  ,PCSC4,PCSD4"
TEXTLINE ""
TEXTLINE "                   "
  bitfld.long  0x00 22.--23.       "  SINSELB  ,DSPI_B data input select"        "SINB_GPIO[103] pin           ,res.   ,DSPI_C_SOUT,res."
TEXTLINE "                   "
  bitfld.long  0x00 20.--21.       "  SSSELB   ,DSPI_B slave select input select" "PCSB[0]_PCSD[2]_GPIO[105] pin,res.   ,DSPI_C_CS[0],res."
TEXTLINE "                   "
  bitfld.long  0x00 18.--19.       "  SCKSELB  ,DSPI_B clock input select"       "SCKB_GPIO[102] pin           ,res.   ,DSPI_C_SCK,res."
TEXTLINE "                   "
  bitfld.long  0x00 16.--17.       "  TRIGSELB ,DSPI_B trigger input select"    "res.                         ,PCSA[4],PCSC[4],PCSD[4]"
TEXTLINE ""
TEXTLINE "                   "
  bitfld.long  0x00 14.--15.       "  SINSELC  ,DSPI_C data input select"        "PCSB[3]_SINC_GPIO[108] pin   ,SOUTA,SOUTB,SOUTD"
TEXTLINE "                   "
  bitfld.long  0x00 12.--13.       "  SSSELC   ,DSPI_C slave select input select" "PCSB[5]_PCSC[0]_GPIO[110] pin,PCSA[0],PCSB[0],PCSD[0]"
TEXTLINE "                   "
  bitfld.long  0x00 10.--11.       "  SCKSELC  ,DSPI_C clock input select"       "PCSB[4]_SCKC_GPIO[109] pin   ,SCKA,SCKB,SCKD"
TEXTLINE "                   "
  bitfld.long  0x00 08.--09.       "  TRIGSELC ,DSPI_C trigger input select"    "res.                         ,PCSA[4],PCSB[4],PCSD[4]"
TEXTLINE ""
TEXTLINE "                   "
  bitfld.long  0x00 06.--07.       "  SINSELD  ,DSPI_D data input select"        "PCSA[3]_GPIO[99] pin         ,SOUTA,SOUTB,SOUTC"
TEXTLINE "                   "
  bitfld.long  0x00 04.--05.       "  SSSELD   ,DSPI_D slave select input select" "PCSB[1]_PCSD[0]_GPIO[106] pin,PCSA0,PCSB0,PCSC0"
TEXTLINE "                   "
  bitfld.long  0x00 02.--03.       "  SCKSELD  ,DSPI_D clock input select"       "PPCSA[2]_SCKD_GPIO[98] pin   ,res.,SCKB,SCKC"
TEXTLINE "                   "
  bitfld.long  0x00 00.--01.       "  TRIGSELD ,DSPI_D trigger input select"    "res.                         ,PCSA4,PCSB4,PCSC4"
TEXTLINE ""

group.long 0xC3F90910++0x03
  line.long    0x00 "ISEL4,IMUX Select Registers"
  hexmask.long.byte 0 24.--30. 1.       "cTSEL5_0  ,"
  hexmask.long.byte 0 16.--22. 1.     "  cTSEL4_0  ,"
  hexmask.long.byte 0 08.--14. 1.     "  cTSEL3_0  ,"
  hexmask.long.byte 0 00.--06. 1.     "  cTSEL2_0  ,"
  
group.long 0xC3F90914++0x03
  line.long    0x00 "ISEL5,IMUX Select Registers"
  hexmask.long.byte 0 24.--30. 1.       "cTSEL1_0  ,"
  hexmask.long.byte 0 16.--22. 1.     "  cTSEL0_0  ,"
TEXTLINE ""

group.long 0xC3F90918++0x03
  line.long    0x00 "ISEL6,IMUX Select Registers"
  hexmask.long.byte 0 24.--30. 1.       "cTSEL5_1  ,"
  hexmask.long.byte 0 16.--22. 1.     "  cTSEL4_1  ,"
  hexmask.long.byte 0 08.--14. 1.     "  cTSEL3_1  ,"
  hexmask.long.byte 0 00.--06. 1.     "  cTSEL2_1  ,"
  
group.long 0xC3F9091C++0x03
  line.long    0x00 "ISEL7,IMUX Select Registers"
  hexmask.long.byte 0 24.--30. 1.       "cTSEL1_1  ,"
  hexmask.long.byte 0 16.--22. 1.     "  cTSEL0_1  ,"
TEXTLINE ""

endif

tree.end

sif (CPUIS("MPC5674*"))
tree "Parallel GPIO Pin Data Output Registers"
  group.long 0xC3F90C00++0x03
  line.long    0x00 "PGPDO0,Parallel GPIO Pin Data Output Register 0"
  group.long 0xC3F90C04++0x03
  line.long    0x00 "PGPDO1,Parallel GPIO Pin Data Output Register 1"
  group.long 0xC3F90C08++0x03
  line.long    0x00 "PGPDO2,Parallel GPIO Pin Data Output Register 2"
  group.long 0xC3F90C0C++0x03
  line.long    0x00 "PGPDO3,Parallel GPIO Pin Data Output Register 3"
  group.long 0xC3F90C10++0x03
  line.long    0x00 "PGPDO4,Parallel GPIO Pin Data Output Register 4"
  group.long 0xC3F90C14++0x03
  line.long    0x00 "PGPDO5,Parallel GPIO Pin Data Output Register 5"
  group.long 0xC3F90C18++0x03
  line.long    0x00 "PGPDO6,Parallel GPIO Pin Data Output Register 6"
  group.long 0xC3F90C1C++0x03
  line.long    0x00 "PGPDO7,Parallel GPIO Pin Data Output Register 7"
  group.long 0xC3F90C20++0x03
  line.long    0x00 "PGPDO8,Parallel GPIO Pin Data Output Register 8"
  group.long 0xC3F90C24++0x03
  line.long    0x00 "PGPDO9,Parallel GPIO Pin Data Output Register 9"
  group.long 0xC3F90C28++0x03
  line.long    0x00 "PGPDO10,Parallel GPIO Pin Data Output Register 10"
  group.long 0xC3F90C2C++0x03
  line.long    0x00 "PGPDO11,Parallel GPIO Pin Data Output Register 11"
  group.long 0xC3F90C30++0x03
  line.long    0x00 "PGPDO12,Parallel GPIO Pin Data Output Register 12"
  group.long 0xC3F90C34++0x03
  line.long    0x00 "PGPDO13,Parallel GPIO Pin Data Output Register 13"
  group.long 0xC3F90C38++0x03
  line.long    0x00 "PGPDO14,Parallel GPIO Pin Data Output Register 14"
  group.long 0xC3F90C3C++0x03
  line.long    0x00 "PGPDO15,Parallel GPIO Pin Data Output Register 15"
tree.end

tree "Parallel GPIO Pin Data Input Registers"
  group.long 0xC3F90C40++0x03
  line.long    0x00 "PGPDI0,Parallel GPIO Pin Data Input Register 0"
  group.long 0xC3F90C44++0x03
  line.long    0x00 "PGPDI1,Parallel GPIO Pin Data Input Register 1"
  group.long 0xC3F90C48++0x03
  line.long    0x00 "PGPDI2,Parallel GPIO Pin Data Input Register 2"
  group.long 0xC3F90C4C++0x03
  line.long    0x00 "PGPDI3,Parallel GPIO Pin Data Input Register 3"
  group.long 0xC3F90C50++0x03
  line.long    0x00 "PGPDI4,Parallel GPIO Pin Data Input Register 4"
  group.long 0xC3F90C54++0x03
  line.long    0x00 "PGPDI5,Parallel GPIO Pin Data Input Register 5"
  group.long 0xC3F90C58++0x03
  line.long    0x00 "PGPDI6,Parallel GPIO Pin Data Input Register 6"
  group.long 0xC3F90C5C++0x03
  line.long    0x00 "PGPDI7,Parallel GPIO Pin Data Input Register 7"
  group.long 0xC3F90C60++0x03
  line.long    0x00 "PGPDI8,Parallel GPIO Pin Data Input Register 8"
  group.long 0xC3F90C64++0x03
  line.long    0x00 "PGPDI9,Parallel GPIO Pin Data Input Register 9"
  group.long 0xC3F90C68++0x03
  line.long    0x00 "PGPDI10,Parallel GPIO Pin Data Input Register 10"
  group.long 0xC3F90C6C++0x03
  line.long    0x00 "PGPDI11,Parallel GPIO Pin Data Input Register 11"
  group.long 0xC3F90C70++0x03
  line.long    0x00 "PGPDI12,Parallel GPIO Pin Data Input Register 12"
  group.long 0xC3F90C74++0x03
  line.long    0x00 "PGPDI13,Parallel GPIO Pin Data Input Register 13"
  group.long 0xC3F90C78++0x03
  line.long    0x00 "PGPDI14,Parallel GPIO Pin Data Input Register 14"
  group.long 0xC3F90C7C++0x03
  line.long    0x00 "PGPDI15,Parallel GPIO Pin Data Input Register 15"
tree.end

tree "Masked Parallel GPIO Pin Data Output Registers"
  group.long 0xC3F90C80++0x03
  line.long    0x00 "MPGPDO0,Masked Parallel GPIO Pin Data Output Register 0"
  group.long 0xC3F90C84++0x03
  line.long    0x00 "MPGPDO1,Masked Parallel GPIO Pin Data Output Register 1"
  group.long 0xC3F90C88++0x03
  line.long    0x00 "MPGPDO2,Masked Parallel GPIO Pin Data Output Register 2"
  group.long 0xC3F90C8C++0x03
  line.long    0x00 "MPGPDO3,Masked Parallel GPIO Pin Data Output Register 3"
  group.long 0xC3F90C90++0x03
  line.long    0x00 "MPGPDO4,Masked Parallel GPIO Pin Data Output Register 4"
  group.long 0xC3F90C94++0x03
  line.long    0x00 "MPGPDO5,Masked Parallel GPIO Pin Data Output Register 5"
  group.long 0xC3F90C98++0x03
  line.long    0x00 "MPGPDO6,Masked Parallel GPIO Pin Data Output Register 6"
  group.long 0xC3F90C9C++0x03
  line.long    0x00 "MPGPDO7,Masked Parallel GPIO Pin Data Output Register 7"
  group.long 0xC3F90CA0++0x03
  line.long    0x00 "MPGPDO8,Masked Parallel GPIO Pin Data Output Register 8"
  group.long 0xC3F90CA4++0x03
  line.long    0x00 "MPGPDO9,Masked Parallel GPIO Pin Data Output Register 9"
  group.long 0xC3F90CA8++0x03
  line.long    0x00 "MPGPDO10,Masked Parallel GPIO Pin Data Output Register 10"
  group.long 0xC3F90CAC++0x03
  line.long    0x00 "MPGPDO11,Masked Parallel GPIO Pin Data Output Register 11"
  group.long 0xC3F90CB0++0x03
  line.long    0x00 "MPGPDO12,Masked Parallel GPIO Pin Data Output Register 12"
  group.long 0xC3F90CB4++0x03
  line.long    0x00 "MPGPDO13,Masked Parallel GPIO Pin Data Output Register 13"
  group.long 0xC3F90CB8++0x03
  line.long    0x00 "MPGPDO14,Masked Parallel GPIO Pin Data Output Register 14"
  group.long 0xC3F90CBC++0x03
  line.long    0x00 "MPGPDO15,Masked Parallel GPIO Pin Data Output Register 15"
tree.end


tree "Masked Serial GPO Registers for DSPI"

group.long 0xC3F90D00++0x03
  line.long    0x00 "SIU_DSPIAH,DSPIA GP Mask-Output High Register"
  hexmask.long.word 0 16.--31. 1.       "MASK ,control mask"
  hexmask.long.word 0 00.--15. 1.       "  DATA ,data value"

group.long 0xC3F90D04++0x03
  line.long    0x00 "SIU_DSPIAL,DSPIA GP Mask-Output Low Register"
  hexmask.long.word 0 16.--31. 1.       "MASK ,control mask"
  hexmask.long.word 0 00.--15. 1.       "  DATA ,data value"

group.long 0xC3F90D08++0x03
  line.long    0x00 "SIU_DSPIBH,DSPIB GP Mask-Output High Register"
  hexmask.long.word 0 16.--31. 1.       "MASK ,control mask"
  hexmask.long.word 0 00.--15. 1.       "  DATA ,data value"

group.long 0xC3F90D0C++0x03
  line.long    0x00 "SIU_DSPIBL,DSPIB GP Mask-Output Low Register"
  hexmask.long.word 0 16.--31. 1.       "MASK ,control mask"
  hexmask.long.word 0 00.--15. 1.       "  DATA ,data value"

group.long 0xC3F90D10++0x03
  line.long    0x00 "SIU_DSPICH,DSPIC GP Mask-Output High Register"
  hexmask.long.word 0 16.--31. 1.       "MASK ,control mask"
  hexmask.long.word 0 00.--15. 1.       "  DATA ,data value"

group.long 0xC3F90D14++0x03
  line.long    0x00 "SIU_DSPICL,DSPIC GP Mask-Output Low Register"
  hexmask.long.word 0 16.--31. 1.       "MASK ,control mask"
  hexmask.long.word 0 00.--15. 1.       "  DATA ,data value"

group.long 0xC3F90D18++0x03
  line.long    0x00 "SIU_DSPIDH,DSPID GP Mask-Output High Register"
  hexmask.long.word 0 16.--31. 1.       "MASK ,control mask"
  hexmask.long.word 0 00.--15. 1.       "  DATA ,data value"

group.long 0xC3F90D1C++0x03
  line.long    0x00 "SIU_DSPIDL,DSPID GP Mask-Output Low Register"
  hexmask.long.word 0 16.--31. 1.       "MASK ,control mask"
  hexmask.long.word 0 00.--15. 1.       "  DATA ,data value"
tree.end

tree "Serialized Output Signal Selection Registers"

group.long 0xC3F90D40++0x03
  line.long    0x00 "ETPUBA,eTPU_B Select Register for DSPI_A"

group.long 0xC3F90D44++0x03
  line.long    0x00 "EMIOSA,eMIOS Select Register for DSPI_A"

group.long 0xC3F90D48++0x03
  line.long    0x00 "DSPIAHLA,Select Register for DSPI_A"
  hexmask.long.word 0 16.--31. 1.       "H ,high"
  hexmask.long.word 0 00.--15. 1.       "  L ,low"
TEXTLINE ""

group.long 0xC3F90D50++0x03
  line.long    0x00 "ETPUAB,eTPU_A Select Register for DSPI_B"

group.long 0xC3F90D54++0x03
  line.long    0x00 "EMIOSB,eMIOS Select Register for DSPI_B"

group.long 0xC3F90D58++0x03
  line.long    0x00 "DSPIBHLB,Select Register for DSPI_B"
  hexmask.long.word 0 16.--31. 1.       "H ,high"
  hexmask.long.word 0 00.--15. 1.       "  L ,low"
TEXTLINE ""

group.long 0xC3F90D60++0x03
  line.long    0x00 "ETPUAC,eTPU_A Select Register for DSPI_C"

group.long 0xC3F90D64++0x03
  line.long    0x00 "EMIOSC,eMIOS Select Register for DSPI_C"

group.long 0xC3F90D68++0x03
  line.long    0x00 "DSPICHLC,Select Register for DSPI_C"
  hexmask.long.word 0 16.--31. 1.       "H ,high"
  hexmask.long.word 0 00.--15. 1.       "  L ,low"
TEXTLINE ""

group.long 0xC3F90D70++0x03
  line.long    0x00 "ETPUAD,eTPU_A Select Register for DSPI_D"

group.long 0xC3F90D74++0x03
  line.long    0x00 "EMIOSD,eMIOS Select Register for DSPI_D"

group.long 0xC3F90D78++0x03
  line.long    0x00 "DSPIDHLD,Select Register for DSPI_D"
  hexmask.long.word 0 16.--31. 1.       "H ,high"
  hexmask.long.word 0 00.--15. 1.       "  L ,low"
TEXTLINE ""


tree.end

endif

tree.end

width 9.
else
width 12.

tree "System Integration Unit (SIU)"

rgroup.long 0xC3F90004++0x03
  line.long    0x00 "MIDR,MCU ID Register"
  hexmask.word 0x00 00.--15.   1.        "PARTNUM ,MCU part number"
  hexmask.byte 0x03 04.--07.   1.        "  MASKNUM_MAJ ,MCU mask number"
  hexmask.byte 0x03 00.--03.   1.        "  MASKNUM_MIN ,MCU mask number"

group.long 0xC3F9000C++0x03
  line.long    0x00 "RSR,Reset Status Register"
  bitfld.long  0x00 31.                  "PORS ,Power-on reset status" "0,1"
  bitfld.long  0x00 30.                  "  ERS  ,External reset status" "0,1"
  bitfld.long  0x00 29.                  "  LLRS   ,Loss of lock reset status" "0,1"
  bitfld.long  0x00 28.                  "  LCRS    ,Loss of clock reset status" "0,1"
  bitfld.long  0x00 27.                  "   WDRS ,Watchdog timer/debug reset status" "0,1"
  bitfld.long  0x00 26.                  "     CRS  ,Checkstop reset status" "0,1"
TEXTLINE "                   "  
  bitfld.long  0x00 17.                  "  SSRS ,Software system reset status" "0,1"
  bitfld.long  0x00 16.                  "  SERF ,Software external reset flag" "0,1"
  bitfld.long  0x00 15.                  "  WKPCFG ,Weak pull up configuration pin status" "0,1"
  bitfld.long  0x00 01.--02.             "  BOOTCFG ,Reset configuration pin status" "Int Flash,CAN/SCI,ExMem(no arb),ExMem(ex arb)"
  bitfld.long  0x00 00.                  "  RGF  ,Reset glitch flag" "0,1"
  
  
group.long 0xC3F90010++0x03
  line.long    0x00 "SRCR,System Reset Control Register"
  bitfld.long  0x00 31.                  "SSR  ,Software system reset" "0,1"
  bitfld.long  0x00 30.                  "  SER  ,Software external reset" "0,1"
  bitfld.long  0x00 15.                  "  CRE    ,Checkstop reset enable" "0,1"

group.long 0xC3F90014++0x03
  line.long    0x00 "EISR,SIU External Interrupt Status Register"
  bitfld.long  0x00 15.                  "EIF15-12  ,External interrupt request flag 15" "0,1"
  bitfld.long  0x00 14.                  ",External interrupt request flag 14" "0,1"
  bitfld.long  0x00 13.                  ",External interrupt request flag 13" "0,1"
  bitfld.long  0x00 12.                  ",External interrupt request flag 12" "0,1"

  bitfld.long  0x00 11.                  "  EIF11-08  ,External interrupt request flag 11" "0,1"
  bitfld.long  0x00 10.                  ",External interrupt request flag 10" "0,1"
  bitfld.long  0x00 09.                  ",External interrupt request flag 9" "0,1"
  bitfld.long  0x00 08.                  ",External interrupt request flag 8" "0,1"

  bitfld.long  0x00 07.                  "  EIF07-04  ,External interrupt request flag 7" "0,1"
  bitfld.long  0x00 06.                  ",External interrupt request flag 6" "0,1"
  bitfld.long  0x00 05.                  ",External interrupt request flag 5" "0,1"
  bitfld.long  0x00 04.                  ",External interrupt request flag 4" "0,1"

  bitfld.long  0x00 03.                  "  EIF03-00  ,External interrupt request flag 3" "0,1"
  bitfld.long  0x00 02.                  ",External interrupt request flag 2" "0,1"
  bitfld.long  0x00 01.                  ",External interrupt request flag 1" "0,1"
  bitfld.long  0x00 00.                  ",External interrupt request flag 0" "0,1"

group.long 0xC3F90018++0x03
  line.long    0x00 "DIRER,DMA/Interrupt Request Enable Register"
  bitfld.long  0x00 15.                  "EIRE15-12 ,External interrupt request enable 15" "0,1"
  bitfld.long  0x00 14.                  ",External interrupt request enable 14" "0,1"
  bitfld.long  0x00 13.                  ",External interrupt request enable 13" "0,1"
  bitfld.long  0x00 12.                  ",External interrupt request enable 12" "0,1"

  bitfld.long  0x00 11.                  "  EIRE11-08 ,External interrupt request enable 11" "0,1"
  bitfld.long  0x00 10.                  ",External interrupt request enable 10" "0,1"
  bitfld.long  0x00 09.                  ",External interrupt request enable 9" "0,1"
  bitfld.long  0x00 08.                  ",External interrupt request enable 8" "0,1"

  bitfld.long  0x00 07.                  "  EIRE07-04 ,External interrupt request enable 7" "0,1"
  bitfld.long  0x00 06.                  ",External interrupt request enable 6" "0,1"
  bitfld.long  0x00 05.                  ",External interrupt request enable 5" "0,1"
  bitfld.long  0x00 04.                  ",External interrupt request enable 4" "0,1"

  bitfld.long  0x00 03.                  "  EIRE03-00 ,External interrupt request enable 3" "0,1"
  bitfld.long  0x00 02.                  ",External interrupt request enable 2" "0,1"
  bitfld.long  0x00 01.                  ",External interrupt request enable 1" "0,1"
  bitfld.long  0x00 00.                  ",External interrupt request enable 0" "0,1"

group.long 0xC3F9001C++0x03
  line.long    0x00 "DIRSR,DMA/Interrupt Request Select Register"
  bitfld.long  0x00 03.                  "DIRS03-00 ,DMA/Interrupt Request Select 3" "0,1"
  bitfld.long  0x00 02.                  ",DMA/Interrupt Request Select 2" "0,1"
  bitfld.long  0x00 01.                  ",DMA/Interrupt Request Select 1" "0,1"
  bitfld.long  0x00 00.                  ",DMA/Interrupt Request Select 0" "0,1"

group.long 0xC3F90020++0x03
  line.long    0x00 "OSR,Overrun Status Register"
  bitfld.long  0x00 15.                  "OVF15-12  ,Overrun flag 15" "0,1"
  bitfld.long  0x00 14.                  ",Overrun flag 14" "0,1"
  bitfld.long  0x00 13.                  ",Overrun flag 13" "0,1"
  bitfld.long  0x00 12.                  ",Overrun flag 12" "0,1"

  bitfld.long  0x00 11.                  "  OVF11-08  ,Overrun flag 11" "0,1"
  bitfld.long  0x00 10.                  ",Overrun flag 10" "0,1"
  bitfld.long  0x00 09.                  ",Overrun flag 9" "0,1"
  bitfld.long  0x00 08.                  ",Overrun flag 8" "0,1"

  bitfld.long  0x00 07.                  "  OVF07-04  ,Overrun flag 7" "0,1"
  bitfld.long  0x00 06.                  ",Overrun flag 6" "0,1"
  bitfld.long  0x00 05.                  ",Overrun flag 5" "0,1"
  bitfld.long  0x00 04.                  ",Overrun flag 4" "0,1"

  bitfld.long  0x00 03.                  "  OVF03-00  ,Overrun flag 3" "0,1"
  bitfld.long  0x00 02.                  ",Overrun flag 2" "0,1"
  bitfld.long  0x00 01.                  ",Overrun flag 1" "0,1"
  bitfld.long  0x00 00.                  ",Overrun flag 0" "0,1"

group.long 0xC3F90024++0x03
  line.long    0x00 "ORER,Overrun Request Enable Register"
  bitfld.long  0x00 15.                  "ORE15-12  ,Overrun request enable 15" "0,1"
  bitfld.long  0x00 14.                  ",Overrun request enable 14" "0,1"
  bitfld.long  0x00 13.                  ",Overrun request enable 13" "0,1"
  bitfld.long  0x00 12.                  ",Overrun request enable 12" "0,1"

  bitfld.long  0x00 11.                  "  ORE11-08  ,Overrun request enable 11" "0,1"
  bitfld.long  0x00 10.                  ",Overrun request enable 10" "0,1"
  bitfld.long  0x00 09.                  ",Overrun request enable 9" "0,1"
  bitfld.long  0x00 08.                  ",Overrun request enable 8" "0,1"

  bitfld.long  0x00 07.                  "  ORE07-04  ,Overrun request enable 7" "0,1"
  bitfld.long  0x00 06.                  ",Overrun request enable 6" "0,1"
  bitfld.long  0x00 05.                  ",Overrun request enable 5" "0,1"
  bitfld.long  0x00 04.                  ",Overrun request enable 4" "0,1"

  bitfld.long  0x00 03.                  "  ORE03-00  ,Overrun request enable 3" "0,1"
  bitfld.long  0x00 02.                  ",Overrun request enable 2" "0,1"
  bitfld.long  0x00 01.                  ",Overrun request enable 1" "0,1"
  bitfld.long  0x00 00.                  ",Overrun request enable 0" "0,1"

group.long 0xC3F90028++0x03
  line.long    0x00 "IREER,IRQ Rising-Edge Event Enable Register"
  bitfld.long  0x00 15.                  "IREE15-12 ,IRQ rising-edge event enable 15" "0,1"
  bitfld.long  0x00 14.                  ",IRQ rising-edge event enable 14" "0,1"
  bitfld.long  0x00 13.                  ",IRQ rising-edge event enable 13" "0,1"
  bitfld.long  0x00 12.                  ",IRQ rising-edge event enable 12" "0,1"

  bitfld.long  0x00 11.                  "  IREE11-08 ,IRQ rising-edge event enable 11" "0,1"
  bitfld.long  0x00 10.                  ",IRQ rising-edge event enable 10" "0,1"
  bitfld.long  0x00 09.                  ",IRQ rising-edge event enable 9" "0,1"
  bitfld.long  0x00 08.                  ",IRQ rising-edge event enable 8" "0,1"

  bitfld.long  0x00 07.                  "  IREE07-04 ,IRQ rising-edge event enable 7" "0,1"
  bitfld.long  0x00 06.                  ",IRQ rising-edge event enable 6" "0,1"
  bitfld.long  0x00 05.                  ",IRQ rising-edge event enable 5" "0,1"
  bitfld.long  0x00 04.                  ",IRQ rising-edge event enable 4" "0,1"

  bitfld.long  0x00 03.                  "  IREE03-00 ,IRQ rising-edge event enable 3" "0,1"
  bitfld.long  0x00 02.                  ",IRQ rising-edge event enable 2" "0,1"
  bitfld.long  0x00 01.                  ",IRQ rising-edge event enable 1" "0,1"
  bitfld.long  0x00 00.                  ",IRQ rising-edge event enable 0" "0,1"

group.long 0xC3F9002C++0x03
  line.long    0x00 "IFEER,IRQ Falling-Edge Event Enable Register"
  bitfld.long  0x00 15.                  "IFEE15-12 ,IRQ falling-edge event enable 15" "0,1"
  bitfld.long  0x00 14.                  ",IRQ falling-edge event enable 14" "0,1"
  bitfld.long  0x00 13.                  ",IRQ falling-edge event enable 13" "0,1"
  bitfld.long  0x00 12.                  ",IRQ falling-edge event enable 12" "0,1"

  bitfld.long  0x00 11.                  "  IFEE11-08 ,IRQ falling-edge event enable 11" "0,1"
  bitfld.long  0x00 10.                  ",IRQ falling-edge event enable 10" "0,1"
  bitfld.long  0x00 09.                  ",IRQ falling-edge event enable 9" "0,1"
  bitfld.long  0x00 08.                  ",IRQ falling-edge event enable 8" "0,1"

  bitfld.long  0x00 07.                  "  IFEE07-04 ,IRQ falling-edge event enable 7" "0,1"
  bitfld.long  0x00 06.                  ",IRQ falling-edge event enable 6" "0,1"
  bitfld.long  0x00 05.                  ",IRQ falling-edge event enable 5" "0,1"
  bitfld.long  0x00 04.                  ",IRQ falling-edge event enable 4" "0,1"

  bitfld.long  0x00 03.                  "  IFEE03-00 ,IRQ falling-edge event enable 3" "0,1"
  bitfld.long  0x00 02.                  ",IRQ falling-edge event enable 2" "0,1"
  bitfld.long  0x00 01.                  ",IRQ falling-edge event enable 1" "0,1"
  bitfld.long  0x00 00.                  ",IRQ falling-edge event enable 0" "0,1"

group.long 0xC3F90030++0x03
  line.long    0x00 "IDFR,IRQ Digital Filter Register"
  bitfld.long  0x00 00.--03.             "DFL ,Digital filter length" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"


TEXTLINE ""


group.long 0xC3F90980++0x03
  line.long    0x00 "CCR,Chip Configuration Register"
  bitfld.long  0x00 17.                  "MATCH ,Compare register match" "0,1"
  bitfld.long  0x00 16.                  "  DISNEX ,Disable Nexus" "0,1"
  bitfld.long  0x00 01.                  "  CSRE ,The CRSE bit enables the suppression of reflections from the EBIs calibration bus onto the non-calibration bus" "0,1"
  bitfld.long  0x00 00.                  "  TEST ,Test mode enable. The application should not change this bit from its negated state at reset" "0,1"
  
group.long 0xC3F90984++0x03
  line.long    0x00 "ECCR,External Clock Control Register"
  hexmask.long.byte 0x00 08.--15. 1.       "ENGDIV ,Engineering clock division factor"
sif (CPU()=="MPC5561")
  bitfld.long  0x00 07.                  "  ECSS ,Engineering clock (ENGCLK) source select." "system clock,external clock"
endif
  bitfld.long  0x00 03.                  "  EBTS ,External bus tap select" "0,1"
  bitfld.long  0x00 00.--01.             "  EBDF ,External bus division factor" "res.,1/2,res.,1/4"
  
  
group.long 0xC3F90988++0x03
  line.long    0x00 "CARH,Compare A High Register"

group.long 0xC3F9098C++0x03
  line.long    0x00 "CARL,Compare A Low Register"
  
group.long 0xC3F90990++0x03
  line.long    0x00 "CBRH,Compare B High Register"

group.long 0xC3F90994++0x03
  line.long    0x00 "CBRL,Compare B Low Register"




tree "Pad Configuration Registers"

sif (CPU()=="MPC5554")
group 0xC3F90040++0x07 "PCR000-PCR003: !CS[0:3] / ADDR[8:11]"
  line.word 0x00 "PCR000,Pad Configuration Register 000"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPI0,!CS0,ADDR08,!CS0,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR001,Pad Configuration Register 001"
  bitfld.word 0x02 10.--12.       "PA , Pin assignment" "GPI0,!CS1,ADDR09,!CS1,res.,res.,res.,res.      "
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x02 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x04 "PCR002,Pad Configuration Register 002"
  bitfld.word 0x04 10.--12.       "PA , Pin assignment" "GPI0,!CS2,ADDR10,!CS2,res.,res.,res.,res.      "
  bitfld.word 0x04 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x04 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x04 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x04 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x04 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x04 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x04 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x06 "PCR003,Pad Configuration Register 003"
  bitfld.word 0x06 10.--12.       "PA , Pin assignment" "GPI0,!CS3,ADDR11,!CS3,res.,res.,res.,res.      "
  bitfld.word 0x06 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x06 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x06 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x06 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x06 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x06 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x06 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90048++0x2f "PCR004-PCR011: ADDR[8:15]"
  line.word 0x00 "PCR004,Pad Configuration Register 004"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,ADDR08,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR005,Pad Configuration Register 005"
  bitfld.word 0x02 10.--12.       "PA , Pin assignment" "GPIO,ADDR09,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x02 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x04 "PCR006,Pad Configuration Register 006"
  bitfld.word 0x04 10.--12.       "PA , Pin assignment" "GPIO,ADDR10,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x04 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x04 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x04 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x04 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x04 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x04 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x04 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x06 "PCR007,Pad Configuration Register 007"
  bitfld.word 0x06 10.--12.       "PA , Pin assignment" "GPIO,ADDR11,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x06 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x06 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x06 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x06 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x06 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x06 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x06 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x08 "PCR008,Pad Configuration Register 008"
  bitfld.word 0x08 10.--12.       "PA , Pin assignment" "GPIO,ADDR12,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x08 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x08 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x08 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x08 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x08 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x08 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x08 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0a "PCR009,Pad Configuration Register 009"
  bitfld.word 0x0a 10.--12.       "PA , Pin assignment" "GPIO,ADDR13,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x0a 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0a 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0a 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x0a 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x0a 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0a 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0a 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0c "PCR010,Pad Configuration Register 010"
  bitfld.word 0x0c 10.--12.       "PA , Pin assignment" "GPIO,ADDR14,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x0c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0c 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x0c 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x0c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0c 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0e "PCR011,Pad Configuration Register 011"
  bitfld.word 0x0e 10.--12.       "PA , Pin assignment" "GPIO,ADDR15,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x0e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0e 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x0e 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x0e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0e 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0e 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90048++0x2f "PCR012-PCR027: ADDR[16:31]"
  line.word 0x10 "PCR012,Pad Configuration Register 012"
  bitfld.word 0x10 10.--12.       "PA , Pin assignment" "GPIO,ADDR16,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x10 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x10 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x10 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x10 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x10 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x10 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x10 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x12 "PCR013,Pad Configuration Register 013"
  bitfld.word 0x12 10.--12.       "PA , Pin assignment" "GPIO,ADDR17,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x12 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x12 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x12 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x12 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x12 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x12 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x12 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x14 "PCR014,Pad Configuration Register 014"
  bitfld.word 0x14 10.--12.       "PA , Pin assignment" "GPIO,ADDR18,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x14 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x14 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x14 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x14 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x14 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x14 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x14 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x16 "PCR015,Pad Configuration Register 015"
  bitfld.word 0x16 10.--12.       "PA , Pin assignment" "GPIO,ADDR19,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x16 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x16 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x16 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x16 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x16 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x16 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x16 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x18 "PCR016,Pad Configuration Register 016"
  bitfld.word 0x18 10.--12.       "PA , Pin assignment" "GPIO,ADDR20,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x18 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x18 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x18 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x18 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x18 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x18 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x18 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x1A "PCR017,Pad Configuration Register 017"
  bitfld.word 0x1A 10.--12.       "PA , Pin assignment" "GPIO,ADDR21,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x1A 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x1A 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x1A 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x1A 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x1A 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x1A 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x1A 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x1C "PCR018,Pad Configuration Register 018"
  bitfld.word 0x1C 10.--12.       "PA , Pin assignment" "GPIO,ADDR22,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x1C 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x1C 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x1C 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x1C 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x1C 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x1C 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x1C 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x1E "PCR019,Pad Configuration Register 019"
  bitfld.word 0x1E 10.--12.       "PA , Pin assignment" "GPIO,ADDR23,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x1E 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x1E 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x1E 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x1E 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x1E 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x1E 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x1E 00.            "  WPS , Weak pull up/down select" "0,1"

TEXTLINE ""
  line.word 0x20 "PCR020,Pad Configuration Register 020"
  bitfld.word 0x20 10.--12.       "PA , Pin assignment" "GPIO,ADDR24,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x20 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x20 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x20 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x20 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x20 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x20 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x20 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x22 "PCR021,Pad Configuration Register 021"
  bitfld.word 0x22 10.--12.       "PA , Pin assignment" "GPIO,ADDR25,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x22 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x22 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x22 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x22 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x22 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x22 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x22 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x24 "PCR022,Pad Configuration Register 022"
  bitfld.word 0x24 10.--12.       "PA , Pin assignment" "GPIO,ADDR26,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x24 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x24 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x24 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x24 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x24 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x24 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x24 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x26 "PCR023,Pad Configuration Register 023"
  bitfld.word 0x26 10.--12.       "PA , Pin assignment" "GPIO,ADDR27,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x26 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x26 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x26 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x26 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x26 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x26 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x26 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x28 "PCR024,Pad Configuration Register 024"
  bitfld.word 0x28 10.--12.       "PA , Pin assignment" "GPIO,ADDR28,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x28 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x28 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x28 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x28 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x28 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x28 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x28 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x2a "PCR025,Pad Configuration Register 025"
  bitfld.word 0x2a 10.--12.       "PA , Pin assignment" "GPIO,ADDR29,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x2a 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x2a 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x2a 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x2a 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x2a 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x2a 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x2a 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x2c "PCR026,Pad Configuration Register 026"
  bitfld.word 0x2c 10.--12.       "PA , Pin assignment" "GPIO,ADDR30,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x2c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x2c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x2c 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x2c 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x2c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x2c 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x2c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x2e "PCR027,Pad Configuration Register 027"
  bitfld.word 0x2e 10.--12.       "PA , Pin assignment" "GPIO,ADDR31,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x2e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x2e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x2e 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x2e 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x2e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x2e 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x2e 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90078++0x3f "PCR028-PCR043: DATA[0:15]"
  line.word 0x00 "PCR028,Pad Configuration Register 028"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,DATA00,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR029,Pad Configuration Register 029"
  bitfld.word 0x02 10.--12.       "PA , Pin assignment" "GPIO,DATA01,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x02 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x04 "PCR030,Pad Configuration Register 030"
  bitfld.word 0x04 10.--12.       "PA , Pin assignment" "GPIO,DATA02,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x04 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x04 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x04 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x04 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x04 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x04 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x04 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x06 "PCR031,Pad Configuration Register 031"
  bitfld.word 0x06 10.--12.       "PA , Pin assignment" "GPIO,DATA03,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x06 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x06 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x06 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x06 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x06 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x06 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x06 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x08 "PCR032,Pad Configuration Register 032"
  bitfld.word 0x08 10.--12.       "PA , Pin assignment" "GPIO,DATA04,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x08 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x08 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x08 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x08 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x08 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x08 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x08 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0a "PCR033,Pad Configuration Register 033"
  bitfld.word 0x0a 10.--12.       "PA , Pin assignment" "GPIO,DATA05,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x0a 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0a 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0a 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x0a 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x0a 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0a 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0a 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0c "PCR034,Pad Configuration Register 034"
  bitfld.word 0x0c 10.--12.       "PA , Pin assignment" "GPIO,DATA06,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x0c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0c 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x0c 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x0c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0c 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0e "PCR035,Pad Configuration Register 035"
  bitfld.word 0x0e 10.--12.       "PA , Pin assignment" "GPIO,DATA07,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x0e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0e 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x0e 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x0e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0e 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0e 00.            "  WPS , Weak pull up/down select" "0,1"

TEXTLINE ""
  line.word 0x10 "PCR036,Pad Configuration Register 036"
  bitfld.word 0x10 10.--12.       "PA , Pin assignment" "GPIO,DATA08,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x10 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x10 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x10 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x10 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x10 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x10 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x10 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x12 "PCR037,Pad Configuration Register 037"
  bitfld.word 0x12 10.--12.       "PA , Pin assignment" "GPIO,DATA09,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x12 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x12 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x12 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x12 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x12 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x12 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x12 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x14 "PCR038,Pad Configuration Register 038"
  bitfld.word 0x14 10.--12.       "PA , Pin assignment" "GPIO,DATA10,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x14 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x14 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x14 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x14 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x14 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x14 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x14 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x16 "PCR039,Pad Configuration Register 039"
  bitfld.word 0x16 10.--12.       "PA , Pin assignment" "GPIO,DATA11,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x16 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x16 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x16 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x16 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x16 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x16 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x16 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x18 "PCR040,Pad Configuration Register 040"
  bitfld.word 0x18 10.--12.       "PA , Pin assignment" "GPIO,DATA12,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x18 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x18 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x18 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x18 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x18 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x18 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x18 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x1A "PCR041,Pad Configuration Register 041"
  bitfld.word 0x1A 10.--12.       "PA , Pin assignment" "GPIO,DATA13,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x1A 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x1A 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x1A 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x1A 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x1A 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x1A 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x1A 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x1c "PCR042,Pad Configuration Register 042"
  bitfld.word 0x1c 10.--12.       "PA , Pin assignment" "GPIO,DATA14,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x1c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x1c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x1c 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x1c 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x1c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x1c 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x1c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x1e "PCR043,Pad Configuration Register 043"
  bitfld.word 0x1e 10.--12.       "PA , Pin assignment" "GPIO,DATA15,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x1e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x1e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x1e 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x1e 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x1e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x1e 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x1e 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90078++0x3f "PCR044-PCR059: DATA[16:31]"
  line.word 0x20 "PCR044,Pad Configuration Register 044"
  bitfld.word 0x20 10.--12.       "PA , Pin assignment" "GPIO,DATA16,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x20 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x20 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x20 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x20 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x20 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x20 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x20 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x22 "PCR045,Pad Configuration Register 045"
  bitfld.word 0x22 10.--12.       "PA , Pin assignment" "GPIO,DATA17,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x22 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x22 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x22 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x22 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x22 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x22 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x22 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x24 "PCR046,Pad Configuration Register 046"
  bitfld.word 0x24 10.--12.       "PA , Pin assignment" "GPIO,DATA18,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x24 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x24 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x24 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x24 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x24 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x24 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x24 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x26 "PCR047,Pad Configuration Register 047"
  bitfld.word 0x26 10.--12.       "PA , Pin assignment" "GPIO,DATA19,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x26 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x26 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x26 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x26 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x26 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x26 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x26 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x28 "PCR048,Pad Configuration Register 048"
  bitfld.word 0x28 10.--12.       "PA , Pin assignment" "GPIO,DATA20,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x28 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x28 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x28 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x28 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x28 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x28 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x28 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x2a "PCR049,Pad Configuration Register 049"
  bitfld.word 0x2a 10.--12.       "PA , Pin assignment" "GPIO,DATA21,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x2a 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x2a 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x2a 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x2a 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x2a 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x2a 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x2a 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x2c "PCR050,Pad Configuration Register 050"
  bitfld.word 0x2c 10.--12.       "PA , Pin assignment" "GPIO,DATA22,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x2c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x2c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x2c 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x2c 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x2c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x2c 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x2c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x2e "PCR051,Pad Configuration Register 051"
  bitfld.word 0x2e 10.--12.       "PA , Pin assignment" "GPIO,DATA23,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x2e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x2e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x2e 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x2e 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x2e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x2e 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x2e 00.            "  WPS , Weak pull up/down select" "0,1"

TEXTLINE ""
  line.word 0x30 "PCR052,Pad Configuration Register 052"
  bitfld.word 0x30 10.--12.       "PA , Pin assignment" "GPIO,DATA24,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x30 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x30 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x30 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x30 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x30 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x30 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x30 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x32 "PCR053,Pad Configuration Register 053"
  bitfld.word 0x32 10.--12.       "PA , Pin assignment" "GPIO,DATA25,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x32 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x32 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x32 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x32 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x32 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x32 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x32 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x34 "PCR054,Pad Configuration Register 054"
  bitfld.word 0x34 10.--12.       "PA , Pin assignment" "GPIO,DATA26,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x34 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x34 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x34 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x34 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x34 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x34 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x34 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x36 "PCR055,Pad Configuration Register 055"
  bitfld.word 0x36 10.--12.       "PA , Pin assignment" "GPIO,DATA27,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x36 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x36 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x36 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x36 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x36 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x36 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x36 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x38 "PCR056,Pad Configuration Register 056"
  bitfld.word 0x38 10.--12.       "PA , Pin assignment" "GPIO,DATA28,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x38 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x38 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x38 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x38 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x38 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x38 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x38 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x3a "PCR057,Pad Configuration Register 057"
  bitfld.word 0x3a 10.--12.       "PA , Pin assignment" "GPIO,DATA29,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x3a 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x3a 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x3a 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x3a 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x3a 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x3a 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x3a 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x3c "PCR058,Pad Configuration Register 058"
  bitfld.word 0x3c 10.--12.       "PA , Pin assignment" "GPIO,DATA30,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x3c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x3c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x3c 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x3c 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x3c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x3c 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x3c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x3e "PCR059,Pad Configuration Register 059"
  bitfld.word 0x3e 10.--12.       "PA , Pin assignment" "GPIO,DATA31,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x3e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x3e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x3e 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x3e 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x3e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x3e 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x3e 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900B8++0x03 "PCR060-PCR061: TSIZ[0:1]"
  line.word 0x00 "PCR060,Pad Configuration Register 060"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,TSIZ0,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR061,Pad Configuration Register 061"
  bitfld.word 0x02 10.--12.       "PA , Pin assignment" "GPIO,TSIZ1,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x02 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900BC++0x01 "PCR062: RD/!WR"
  line.word 0x00 "PCR062,Pad Configuration Register 062"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,RD/!WR,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900BE++0x01 "PCR063: !BDIP"
  line.word 0x00 "PCR063,Pad Configuration Register 063"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,!BDIP,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900C0++0x07 "PCR064-067: !WE_BE[0:3]"
  line.word 0x00 "PCR064,Pad Configuration Register 064"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,!WE0_BE0,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR065,Pad Configuration Register 065"
  bitfld.word 0x02 10.--12.       "PA , Pin assignment" "GPIO,!WE1_BE1,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x02 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x04 "PCR066,Pad Configuration Register 066"
  bitfld.word 0x04 10.--12.       "PA , Pin assignment" "GPIO,!WE2_BE2,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x04 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x04 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x04 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x04 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x04 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x04 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x04 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x06 "PCR067,Pad Configuration Register 067"
  bitfld.word 0x06 10.--12.       "PA , Pin assignment" "GPIO,!WE3_BE3,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x06 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x06 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x06 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x06 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x06 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x06 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x06 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900C8++0x01 "PCR068: !OE"
  line.word 0x00 "PCR068,Pad Configuration Register 068"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,!OE,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900CA++0x01 "PCR069: !TS"
  line.word 0x00 "PCR069,Pad Configuration Register 069"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,!TS,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900CC++0x01 "PCR070: !TA"
  line.word 0x00 "PCR070,Pad Configuration Register 070"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,!TA,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900CE++0x01 "PCR071: !TEA"
  line.word 0x00 "PCR071,Pad Configuration Register 071"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,!TEA,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900D0++0x01 "PCR072: !BR"
  line.word 0x00 "PCR072,Pad Configuration Register 072"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,!BR,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900D2++0x01 "PCR073: !BG"
  line.word 0x00 "PCR073,Pad Configuration Register 073"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,!BG,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900D4++0x01 "PCR074: !BB"
  line.word 0x00 "PCR074,Pad Configuration Register 074"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,!BB,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900D6++0x0f "PCR075-PCR082: MDO[4:11]"
  line.word 0x00 "PCR075,Pad Configuration Register 075"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO/MDO04,res.,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR076,Pad Configuration Register 076"
  bitfld.word 0x02 10.--12.       "PA , Pin assignment" "GPIO/MDO05,res.,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x02 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x04 "PCR077,Pad Configuration Register 077"
  bitfld.word 0x04 10.--12.       "PA , Pin assignment" "GPIO/MDO06,res.,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x04 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x04 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x04 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x04 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x04 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x04 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x04 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x06 "PCR078,Pad Configuration Register 078"
  bitfld.word 0x06 10.--12.       "PA , Pin assignment" "GPIO/MDO07,res.,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x06 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x06 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x06 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x06 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x06 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x06 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x06 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x08 "PCR079,Pad Configuration Register 079"
  bitfld.word 0x08 10.--12.       "PA , Pin assignment" "GPIO/MDO08,res.,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x08 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x08 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x08 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x08 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x08 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x08 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x08 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0a "PCR080,Pad Configuration Register 080"
  bitfld.word 0x0a 10.--12.       "PA , Pin assignment" "GPIO/MDO09,res.,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x0a 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0a 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0a 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x0a 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x0a 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0a 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0a 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0c "PCR081,Pad Configuration Register 081"
  bitfld.word 0x0c 10.--12.       "PA , Pin assignment" "GPIO/MDO10,res.,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x0c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0c 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x0c 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x0c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0c 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0e "PCR082,Pad Configuration Register 082"
  bitfld.word 0x0e 10.--12.       "PA , Pin assignment" "GPIO/MDO11,res.,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x0e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0e 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x0e 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x0e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0e 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0e 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900E6++0x01 "PCR083: CNTX_A"
  line.word 0x00 "PCR083,Pad Configuration Register 083"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,CNTX_A,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900E8++0x01 "PCR084: CNRX_A"
  line.word 0x00 "PCR084,Pad Configuration Register 084"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,CNRX_A,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900EA++0x01 "PCR085: CNTX_B / DSPI PCSC3"
  line.word 0x00 "PCR085,Pad Configuration Register 085"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,CNTX_B,PCSC3,CNTX_B,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900EC++0x01 "PCR086: CNRX_B / DSPI PCSC4"
  line.word 0x00 "PCR086,Pad Configuration Register 086"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,CNRX_B,PCSC4,CNRX_B,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900EE++0x01 "PCR087: CNTX_C / DSPI PCSD3"
  line.word 0x00 "PCR087,Pad Configuration Register 087"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,CNTX_C,PCSD3,CNTX_C,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900F0++0x01 "PCR088: CNRX_C / DSPI PCSD4"
  line.word 0x00 "PCR088,Pad Configuration Register 088"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,CNRX_C,PCSD4,CNRX_C,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900F2++0x01 "PCR089: TXD_A"
  line.word 0x00 "PCR089,Pad Configuration Register 089"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,TXD_A,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900F4++0x01 "PCR090: RXD_A"
  line.word 0x00 "PCR090,Pad Configuration Register 090"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,RXD_A,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900F6++0x01 "PCR091: TXD_B / DSPI PCSD1"
  line.word 0x00 "PCR091,Pad Configuration Register 091"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,TXD_B,PCSD1,TXD_B,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900F8++0x01 "PCR092: RXD_B / PCSD5"
  line.word 0x00 "PCR092,Pad Configuration Register 092"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,RXD_B,PCSD5,RXD_B,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900FA++0x01 "PCR093: DSPI SCK_A / DSPI PCSC1"
  line.word 0x00 "PCR093,Pad Configuration Register 093"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,SCK_A,PCSC1,SCK_A,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900FC++0x01 "PCR094: DSPI SIN_A / DSPI PCSC2"
  line.word 0x00 "PCR094,Pad Configuration Register 094"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,SIN_A,PCSC2,SIN_A,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900FE++0x01 "PCR095: DSPI SOUT_A / DSPI PCSC5"
  line.word 0x00 "PCR095,Pad Configuration Register 095"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,SOUT_A,PCSC5,SOUT_A,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90100++0x01 "PCR096: DSPI PCSA0 / DSPI PCSD2"
  line.word 0x00 "PCR096,Pad Configuration Register 096"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,PCSA0,PCSD2,PCSA0,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90102++0x01 "PCR097: DSPI PCSA1 / PCSB2"
  line.word 0x00 "PCR097,Pad Configuration Register 097"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,PCSA1,PCSB2,PCSA1,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90104++0x01 "PCR098: DSPI PCSA2 / DSPI SCKD"
  line.word 0x00 "PCR098,Pad Configuration Register 098"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,PCSA2,SCKD,PCSA2,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90106++0x01 "PCR099: DSPI PCSA3 / DSPI SIN_D"
  line.word 0x00 "PCR099,Pad Configuration Register 099"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,PCSA3,SIN_D,PCSA3,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90108++0x01 "PCR100: DSPI PCSA4 / DSPI SOUTD"
  line.word 0x00 "PCR100,Pad Configuration Register 100"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,PCSA4,SOUTD,PCSA4,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F9010a++0x01 "PCR101: DSPI PCSA5 / DSPI PCSB3"
  line.word 0x00 "PCR101,Pad Configuration Register 101"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,PCSA5,PCSB3,PCSA5,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F9010c++0x01 "PCR102: DSPI SCKB / DSPI PCSC1"
  line.word 0x00 "PCR102,Pad Configuration Register 102"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,SCKB,PCSC1,SCKB,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F9010e++0x01 "PCR103: DSPI SINB / DSPI PCSC2"
  line.word 0x00 "PCR103,Pad Configuration Register 103"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,SINB,PCSC2,SINB,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90110++0x01 "PCR104: DSPI SOUTB / DSPI PCSC5"
  line.word 0x00 "PCR104,Pad Configuration Register 104"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,SOUTB,PCSC5,SOUTB,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90112++0x01 "PCR105: DSPI PCSB0 / DSPI PCSD2"
  line.word 0x00 "PCR105,Pad Configuration Register 105"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,PCSB0,PCSD2,PCSB0,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90114++0x01 "PCR106: DSPI PCSB1 / DSPI PCSD0"
  line.word 0x00 "PCR106,Pad Configuration Register 106"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,PCSB1,PCSD0,PCSB1,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90116++0x01 "PCR107: DSPI PCSB2 / DSPI SOUTC"
  line.word 0x00 "PCR107,Pad Configuration Register 107"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,PCSB2,SOUTC,PCSB2,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90118++0x01 "PCR108: DSPI PCSB3 / DSPI SINC"
  line.word 0x00 "PCR108,Pad Configuration Register 108"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,PCSB3,SINC,PCSB3,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F9011A++0x01 "PCR109: DSPI PCSB4 / DSPI SCKC"
  line.word 0x00 "PCR109,Pad Configuration Register 109"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,PCSB4,SCKC,PCSB4,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F9011C++0x01 "PCR110: DSPI PCSB5 / DSPI PCSC0"
  line.word 0x00 "PCR110,Pad Configuration Register 110"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,PCSB5,PCSC0,PCSB5,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F9011E++0x03 "PCR111-112: ETRIG[0:1]"
  line.word 0x00 "PCR111,Pad Configuration Register 111"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,ETRIG0,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR112,Pad Configuration Register 112"
  bitfld.word 0x02 10.--12.       "PA , Pin assignment" "GPIO,ETRIG1,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x02 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90122++0x01 "PCR113: TCRCLKA / IRQ7"
  line.word 0x00 "PCR113,Pad Configuration Register 113"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,TCRCLKA,IRQ7,TCRCLKA.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90124++0x3F "PCR114-145: ETPUA[0:31] / ETPUA[12:23] / PCSB[1:4] / IRQ[8:15] / PCDC[1:4] / PCSD[1:4]"
  line.word 0x00 "PCR114,Pad Configuration Register 114"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,ETPUA00,ETPUA12,ETPUA00,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR115,Pad Configuration Register 115"
  bitfld.word 0x02 10.--12.       "PA , Pin assignment" "GPIO,ETPUA01,ETPUA13,ETPUA01,res.,res.,res.,res.      "
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x02 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x04 "PCR116,Pad Configuration Register 116"
  bitfld.word 0x04 10.--12.       "PA , Pin assignment" "GPIO,ETPUA02,ETPUA14,ETPUA02,res.,res.,res.,res.      "
  bitfld.word 0x04 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x04 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x04 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x04 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x04 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x04 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x04 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x06 "PCR117,Pad Configuration Register 117"
  bitfld.word 0x06 10.--12.       "PA , Pin assignment" "GPIO,ETPUA03,ETPUA15,ETPUA03,res.,res.,res.,res.      "
  bitfld.word 0x06 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x06 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x06 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x06 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x06 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x06 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x06 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x08 "PCR118,Pad Configuration Register 118"
  bitfld.word 0x08 10.--12.       "PA , Pin assignment" "GPIO,ETPUA04,ETPUA16,ETPUA04,res.,res.,res.,res.      "
  bitfld.word 0x08 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x08 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x08 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x08 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x08 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x08 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x08 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0a "PCR119,Pad Configuration Register 119"
  bitfld.word 0x0a 10.--12.       "PA , Pin assignment" "GPIO,ETPUA05,ETPUA17,ETPUA05,res.,res.,res.,res.      "
  bitfld.word 0x0a 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0a 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0a 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x0a 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0a 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x0a 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0a 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0c "PCR120,Pad Configuration Register 120"
  bitfld.word 0x0c 10.--12.       "PA , Pin assignment" "GPIO,ETPUA06,ETPUA18,ETPUA06,res.,res.,res.,res.      "
  bitfld.word 0x0c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0c 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x0c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0c 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x0c 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0e "PCR121,Pad Configuration Register 121"
  bitfld.word 0x0e 10.--12.       "PA , Pin assignment" "GPIO,ETPUA07,ETPUA19,ETPUA07,res.,res.,res.,res.      "
  bitfld.word 0x0e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0e 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x0e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0e 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x0e 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0e 00.            "  WPS , Weak pull up/down select" "0,1"

TEXTLINE "" 
  line.word 0x10 "PCR122,Pad Configuration Register 122"
  bitfld.word 0x10 10.--12.       "PA , Pin assignment" "GPIO,ETPUA08,ETPUA20,ETPUA08,res.,res.,res.,res.      "
  bitfld.word 0x10 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x10 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x10 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x10 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x10 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x10 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x10 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x12 "PCR123,Pad Configuration Register 123"
  bitfld.word 0x12 10.--12.       "PA , Pin assignment" "GPIO,ETPUA09,ETPUA21,ETPUA09,res.,res.,res.,res.      "
  bitfld.word 0x12 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x12 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x12 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x12 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x12 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x12 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x12 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x14 "PCR124,Pad Configuration Register 124"
  bitfld.word 0x14 10.--12.       "PA , Pin assignment" "GPIO,ETPUA10,ETPUA22,ETPUA10,res.,res.,res.,res.      "
  bitfld.word 0x14 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x14 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x14 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x14 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x14 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x14 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x14 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x16 "PCR125,Pad Configuration Register 125"
  bitfld.word 0x16 10.--12.       "PA , Pin assignment" "GPIO,ETPUA11,ETPUA23,ETPUA11,res.,res.,res.,res.      "
  bitfld.word 0x16 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x16 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x16 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x16 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x16 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x16 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x16 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x18 "PCR126,Pad Configuration Register 126"
  bitfld.word 0x18 10.--12.       "PA , Pin assignment" "GPIO,ETPUA12,PCSB1,ETPUA12,res.,res.,res.,res.      "
  bitfld.word 0x18 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x18 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x18 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x18 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x18 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x18 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x18 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x1A "PCR127,Pad Configuration Register 127"
  bitfld.word 0x1A 10.--12.       "PA , Pin assignment" "GPIO,ETPUA13,PCSB3,ETPUA13,res.,res.,res.,res.      "
  bitfld.word 0x1A 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x1A 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x1A 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x1A 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x1A 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x1A 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x1A 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x1c "PCR128,Pad Configuration Register 128"
  bitfld.word 0x1c 10.--12.       "PA , Pin assignment" "GPIO,ETPUA14,PCSB4,ETPUA14,res.,res.,res.,res.      "
  bitfld.word 0x1c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x1c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x1c 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x1c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x1c 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x1c 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x1c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x1e "PCR129,Pad Configuration Register 129"
  bitfld.word 0x1e 10.--12.       "PA , Pin assignment" "GPIO,ETPUA15,PCSB5,ETPUA15,res.,res.,res.,res.      "
  bitfld.word 0x1e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x1e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x1e 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x1e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x1e 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x1e 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x1e 00.            "  WPS , Weak pull up/down select" "0,1"

TEXTLINE ""
  line.word 0x20 "PCR130,Pad Configuration Register 130"
  bitfld.word 0x20 10.--12.       "PA , Pin assignment" "GPIO,ETPUA16,PCSD1,ETPUA16,res.,res.,res.,res.      "
  bitfld.word 0x20 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x20 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x20 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x20 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x20 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x20 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x20 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x22 "PCR131,Pad Configuration Register 131"
  bitfld.word 0x22 10.--12.       "PA , Pin assignment" "GPIO,ETPUA17,PCSD2,ETPUA17,res.,res.,res.,res.      "
  bitfld.word 0x22 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x22 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x22 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x22 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x22 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x22 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x22 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x24 "PCR132,Pad Configuration Register 132"
  bitfld.word 0x24 10.--12.       "PA , Pin assignment" "GPIO,ETPUA18,PCSD3,ETPUA18,res.,res.,res.,res.      "
  bitfld.word 0x24 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x24 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x24 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x24 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x24 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x24 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x24 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x26 "PCR133,Pad Configuration Register 133"
  bitfld.word 0x26 10.--12.       "PA , Pin assignment" "GPIO,ETPUA19,PCSD4,ETPUA19,res.,res.,res.,res.      "
  bitfld.word 0x26 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x26 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x26 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x26 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x26 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x26 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x26 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x28 "PCR134,Pad Configuration Register 134"
  bitfld.word 0x28 10.--12.       "PA , Pin assignment" "GPIO,ETPUA20,IRQ08,ETPUA20,res.,res.,res.,res.      "
  bitfld.word 0x28 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x28 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x28 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x28 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x28 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x28 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x28 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x2a "PCR135,Pad Configuration Register 135"
  bitfld.word 0x2a 10.--12.       "PA , Pin assignment" "GPIO,ETPUA21,IRQ09,ETPUA21,res.,res.,res.,res.      "
  bitfld.word 0x2a 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x2a 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x2a 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x2a 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x2a 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x2a 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x2a 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x2c "PCR136,Pad Configuration Register 136"
  bitfld.word 0x2c 10.--12.       "PA , Pin assignment" "GPIO,ETPUA22,IRQ10,ETPUA22,res.,res.,res.,res.      "
  bitfld.word 0x2c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x2c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x2c 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x2c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x2c 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x2c 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x2c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x2e "PCR137,Pad Configuration Register 137"
  bitfld.word 0x2e 10.--12.       "PA , Pin assignment" "GPIO,ETPUA23,IRQ11,ETPUA23,res.,res.,res.,res.      "
  bitfld.word 0x2e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x2e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x2e 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x2e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x2e 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x2e 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x2e 00.            "  WPS , Weak pull up/down select" "0,1"

TEXTLINE ""
  line.word 0x30 "PCR138,Pad Configuration Register 138"
  bitfld.word 0x30 10.--12.       "PA , Pin assignment" "GPIO,ETPUA24,IRQ12,ETPUA24,res.,res.,res.,res.      "
  bitfld.word 0x30 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x30 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x30 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x30 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x30 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x30 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x30 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x32 "PCR139,Pad Configuration Register 139"
  bitfld.word 0x32 10.--12.       "PA , Pin assignment" "GPIO,ETPUA25,IRQ13,ETPUA25,res.,res.,res.,res.      "
  bitfld.word 0x32 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x32 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x32 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x32 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x32 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x32 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x32 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x34 "PCR140,Pad Configuration Register 140"
  bitfld.word 0x34 10.--12.       "PA , Pin assignment" "GPIO,ETPUA26,IRQ14,ETPUA26,res.,res.,res.,res.      "
  bitfld.word 0x34 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x34 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x34 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x34 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x34 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x34 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x34 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x36 "PCR141,Pad Configuration Register 141"
  bitfld.word 0x36 10.--12.       "PA , Pin assignment" "GPIO,ETPUA27,IRQ15,ETPUA27,res.,res.,res.,res.      "
  bitfld.word 0x36 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x36 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x36 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x36 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x36 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x36 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x36 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x38 "PCR142,Pad Configuration Register 142"
  bitfld.word 0x38 10.--12.       "PA , Pin assignment" "GPIO,ETPUA28,PCSC1,ETPUA28,res.,res.,res.,res.      "
  bitfld.word 0x38 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x38 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x38 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x38 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x38 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x38 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x38 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x3a "PCR143,Pad Configuration Register 143"
  bitfld.word 0x3a 10.--12.       "PA , Pin assignment" "GPIO,ETPUA29,PCSC2,ETPUA29,res.,res.,res.,res.      "
  bitfld.word 0x3a 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x3a 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x3a 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x3a 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x3a 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x3a 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x3a 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x3c "PCR144,Pad Configuration Register 144"
  bitfld.word 0x3c 10.--12.       "PA , Pin assignment" "GPIO,ETPUA30,PCSC3,ETPUA30,res.,res.,res.,res.      "
  bitfld.word 0x3c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x3c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x3c 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x3c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x3c 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x3c 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x3c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x3e "PCR145,Pad Configuration Register 145"
  bitfld.word 0x3e 10.--12.       "PA , Pin assignment" "GPIO,ETPUA31,PCSC4,ETPUA31,res.,res.,res.,res.      "
  bitfld.word 0x3e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x3e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x3e 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x3e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x3e 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x3e 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x3e 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90164++0x01 "PCR146: TCRCLKB / IRQ6"
  line.word 0x00 "PCR146,Pad Configuration Register 146"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,TCRCLKB,IRQ06,TCRCLKB,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90166++0x3F "PCR147-178: ETPUB[0:31] / ETPUB[16:31] / PCSA[1:4]"
  line.word 0x00 "PCR147,Pad Configuration Register 147"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,ETPUB00,ETPUB16,ETPUB00,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR148,Pad Configuration Register 148"
  bitfld.word 0x02 10.--12.       "PA , Pin assignment" "GPIO,ETPUB01,ETPUB17,ETPUB01,res.,res.,res.,res.      "
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x02 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x04 "PCR149,Pad Configuration Register 149"
  bitfld.word 0x04 10.--12.       "PA , Pin assignment" "GPIO,ETPUB02,ETPUB18,ETPUB02,res.,res.,res.,res.      "
  bitfld.word 0x04 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x04 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x04 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x04 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x04 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x04 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x04 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x06 "PCR150,Pad Configuration Register 150"
  bitfld.word 0x06 10.--12.       "PA , Pin assignment" "GPIO,ETPUB03,ETPUB19,ETPUB03,res.,res.,res.,res.      "
  bitfld.word 0x06 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x06 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x06 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x06 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x06 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x06 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x06 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x08 "PCR151,Pad Configuration Register 151"
  bitfld.word 0x08 10.--12.       "PA , Pin assignment" "GPIO,ETPUB04,ETPUB20,ETPUB04,res.,res.,res.,res.      "
  bitfld.word 0x08 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x08 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x08 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x08 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x08 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x08 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x08 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0a "PCR152,Pad Configuration Register 152"
  bitfld.word 0x0a 10.--12.       "PA , Pin assignment" "GPIO,ETPUB05,ETPUB21,ETPUB05,res.,res.,res.,res.      "
  bitfld.word 0x0a 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0a 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0a 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x0a 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0a 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x0a 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0a 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0c "PCR153,Pad Configuration Register 153"
  bitfld.word 0x0c 10.--12.       "PA , Pin assignment" "GPIO,ETPUB06,ETPUB22,ETPUB06,res.,res.,res.,res.      "
  bitfld.word 0x0c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0c 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x0c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0c 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x0c 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0e "PCR154,Pad Configuration Register 154"
  bitfld.word 0x0e 10.--12.       "PA , Pin assignment" "GPIO,ETPUB07,ETPUB23,ETPUB07,res.,res.,res.,res.      "
  bitfld.word 0x0e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0e 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x0e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0e 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x0e 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0e 00.            "  WPS , Weak pull up/down select" "0,1"

TEXTLINE "" 
  line.word 0x10 "PCR155,Pad Configuration Register 155"
  bitfld.word 0x10 10.--12.       "PA , Pin assignment" "GPIO,ETPUB08,ETPUB24,ETPUB08,res.,res.,res.,res.      "
  bitfld.word 0x10 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x10 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x10 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x10 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x10 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x10 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x10 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x12 "PCR156,Pad Configuration Register 156"
  bitfld.word 0x12 10.--12.       "PA , Pin assignment" "GPIO,ETPUB09,ETPUB25,ETPUB09,res.,res.,res.,res.      "
  bitfld.word 0x12 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x12 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x12 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x12 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x12 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x12 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x12 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x14 "PCR157,Pad Configuration Register 157"
  bitfld.word 0x14 10.--12.       "PA , Pin assignment" "GPIO,ETPUB10,ETPUB26,ETPUB10,res.,res.,res.,res.      "
  bitfld.word 0x14 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x14 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x14 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x14 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x14 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x14 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x14 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x16 "PCR158,Pad Configuration Register 158"
  bitfld.word 0x16 10.--12.       "PA , Pin assignment" "GPIO,ETPUB11,ETPUB27,ETPUB11,res.,res.,res.,res.      "
  bitfld.word 0x16 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x16 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x16 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x16 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x16 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x16 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x16 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x18 "PCR159,Pad Configuration Register 159"
  bitfld.word 0x18 10.--12.       "PA , Pin assignment" "GPIO,ETPUB12,ETPUB28,ETPUB12,res.,res.,res.,res.      "
  bitfld.word 0x18 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x18 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x18 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x18 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x18 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x18 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x18 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x1A "PCR160,Pad Configuration Register 160"
  bitfld.word 0x1A 10.--12.       "PA , Pin assignment" "GPIO,ETPUB13,ETPUB29,ETPUB13,res.,res.,res.,res.      "
  bitfld.word 0x1A 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x1A 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x1A 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x1A 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x1A 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x1A 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x1A 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x1c "PCR161,Pad Configuration Register 161"
  bitfld.word 0x1c 10.--12.       "PA , Pin assignment" "GPIO,ETPUB14,ETPUB30,ETPUB14,res.,res.,res.,res.      "
  bitfld.word 0x1c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x1c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x1c 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x1c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x1c 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x1c 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x1c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x1e "PCR162,Pad Configuration Register 162"
  bitfld.word 0x1e 10.--12.       "PA , Pin assignment" "GPIO,ETPUB15,ETPUB31,ETPUB15,res.,res.,res.,res.      "
  bitfld.word 0x1e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x1e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x1e 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x1e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x1e 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x1e 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x1e 00.            "  WPS , Weak pull up/down select" "0,1"

TEXTLINE ""
  line.word 0x20 "PCR163,Pad Configuration Register 163"
  bitfld.word 0x20 10.--12.       "PA , Pin assignment" "GPIO,ETPUB16,PCSA1,ETPUB16,res.,res.,res.,res.      "
  bitfld.word 0x20 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x20 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x20 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x20 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x20 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x20 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x20 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x22 "PCR164,Pad Configuration Register 164"
  bitfld.word 0x22 10.--12.       "PA , Pin assignment" "GPIO,ETPUB17,PCSA2,ETPUB17,res.,res.,res.,res.      "
  bitfld.word 0x22 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x22 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x22 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x22 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x22 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x22 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x22 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x24 "PCR165,Pad Configuration Register 165"
  bitfld.word 0x24 10.--12.       "PA , Pin assignment" "GPIO,ETPUB18,PCSA3,ETPUB18,res.,res.,res.,res.      "
  bitfld.word 0x24 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x24 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x24 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x24 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x24 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x24 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x24 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x26 "PCR166,Pad Configuration Register 166"
  bitfld.word 0x26 10.--12.       "PA , Pin assignment" "GPIO,ETPUB19,PCSA4,ETPUB19,res.,res.,res.,res.      "
  bitfld.word 0x26 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x26 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x26 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x26 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x26 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x26 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x26 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x28 "PCR167,Pad Configuration Register 167"
  bitfld.word 0x28 10.--12.       "PA , Pin assignment" "GPIO,ETPUB20,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x28 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x28 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x28 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x28 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x28 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x28 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x28 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x2a "PCR168,Pad Configuration Register 168"
  bitfld.word 0x2a 10.--12.       "PA , Pin assignment" "GPIO,ETPUB21,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x2a 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x2a 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x2a 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x2a 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x2a 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x2a 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x2a 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x2c "PCR169,Pad Configuration Register 169"
  bitfld.word 0x2c 10.--12.       "PA , Pin assignment" "GPIO,ETPUB22,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x2c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x2c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x2c 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x2c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x2c 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x2c 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x2c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x2e "PCR170,Pad Configuration Register 170"
  bitfld.word 0x2e 10.--12.       "PA , Pin assignment" "GPIO,ETPUB23,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x2e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x2e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x2e 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x2e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x2e 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x2e 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x2e 00.            "  WPS , Weak pull up/down select" "0,1"

TEXTLINE "" 
  line.word 0x30 "PCR171,Pad Configuration Register 171"
  bitfld.word 0x30 10.--12.       "PA , Pin assignment" "GPIO,ETPUB24,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x30 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x30 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x30 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x30 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x30 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x30 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x30 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x32 "PCR172,Pad Configuration Register 172"
  bitfld.word 0x32 10.--12.       "PA , Pin assignment" "GPIO,ETPUB25,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x32 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x32 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x32 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x32 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x32 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x32 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x32 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x34 "PCR173,Pad Configuration Register 173"
  bitfld.word 0x34 10.--12.       "PA , Pin assignment" "GPIO,ETPUB26,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x34 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x34 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x34 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x34 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x34 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x34 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x34 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x36 "PCR174,Pad Configuration Register 174"
  bitfld.word 0x36 10.--12.       "PA , Pin assignment" "GPIO,ETPUB27,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x36 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x36 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x36 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x36 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x36 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x36 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x36 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x38 "PCR175,Pad Configuration Register 175"
  bitfld.word 0x38 10.--12.       "PA , Pin assignment" "GPIO,ETPUB28,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x38 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x38 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x38 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x38 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x38 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x38 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x38 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x3a "PCR176,Pad Configuration Register 176"
  bitfld.word 0x3a 10.--12.       "PA , Pin assignment" "GPIO,ETPUB29,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x3a 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x3a 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x3a 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x3a 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x3a 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x3a 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x3a 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x3c "PCR177,Pad Configuration Register 177"
  bitfld.word 0x3c 10.--12.       "PA , Pin assignment" "GPIO,ETPUB30,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x3c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x3c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x3c 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x3c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x3c 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x3c 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x3c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x3e "PCR178,Pad Configuration Register 178"
  bitfld.word 0x3e 10.--12.       "PA , Pin assignment" "GPIO,ETPUB31,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x3e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x3e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x3e 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x3e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x3e 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x3e 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x3e 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F901A6++0x31 "PCR179-202: EMIOS[0:23] / ETPUA[0:9] / SOUTC / SOUTD / IRQ[0:1] / ETPUB[0:7]"
  line.word 0x00 "PCR179,Pad Configuration Register 179"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,EMIOS00,ETPUA00,EMIOS00,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR180,Pad Configuration Register 180"
  bitfld.word 0x02 10.--12.       "PA , Pin assignment" "GPIO,EMIOS01,ETPUA01,EMIOS01,res.,res.,res.,res.      "
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x02 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x04 "PCR181,Pad Configuration Register 181"
  bitfld.word 0x04 10.--12.       "PA , Pin assignment" "GPIO,EMIOS02,ETPUA02,EMIOS02,res.,res.,res.,res.      "
  bitfld.word 0x04 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x04 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x04 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x04 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x04 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x04 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x04 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x06 "PCR182,Pad Configuration Register 182"
  bitfld.word 0x06 10.--12.       "PA , Pin assignment" "GPIO,EMIOS03,ETPUA03,EMIOS03,res.,res.,res.,res.      "
  bitfld.word 0x06 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x06 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x06 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x06 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x06 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x06 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x06 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x08 "PCR183,Pad Configuration Register 183"
  bitfld.word 0x08 10.--12.       "PA , Pin assignment" "GPIO,EMIOS04,ETPUA04,EMIOS04,res.,res.,res.,res.      "
  bitfld.word 0x08 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x08 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x08 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x08 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x08 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x08 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x08 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0a "PCR184,Pad Configuration Register 184"
  bitfld.word 0x0a 10.--12.       "PA , Pin assignment" "GPIO,EMIOS05,ETPUA05,EMIOS05,res.,res.,res.,res.      "
  bitfld.word 0x0a 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0a 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0a 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x0a 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0a 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x0a 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0a 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0c "PCR185,Pad Configuration Register 185"
  bitfld.word 0x0c 10.--12.       "PA , Pin assignment" "GPIO,EMIOS06,ETPUA06,EMIOS06,res.,res.,res.,res.      "
  bitfld.word 0x0c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0c 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x0c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0c 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x0c 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0e "PCR186,Pad Configuration Register 186"
  bitfld.word 0x0e 10.--12.       "PA , Pin assignment" "GPIO,EMIOS07,ETPUA07,EMIOS07,res.,res.,res.,res.      "
  bitfld.word 0x0e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0e 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x0e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0e 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x0e 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0e 00.            "  WPS , Weak pull up/down select" "0,1"

TEXTLINE "" 
  line.word 0x10 "PCR187,Pad Configuration Register 187"
  bitfld.word 0x10 10.--12.       "PA , Pin assignment" "GPIO,EMIOS08,ETPUA08,EMIOS08,res.,res.,res.,res.      "
  bitfld.word 0x10 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x10 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x10 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x10 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x10 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x10 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x10 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x12 "PCR188,Pad Configuration Register 188"
  bitfld.word 0x12 10.--12.       "PA , Pin assignment" "GPIO,EMIOS09,ETPUA09,EMIOS09,res.,res.,res.,res.      "
  bitfld.word 0x12 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x12 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x12 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x12 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x12 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x12 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x12 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x14 "PCR189,Pad Configuration Register 189"
  bitfld.word 0x14 10.--12.       "PA , Pin assignment" "GPIO,EMIOS10,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x14 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x14 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x14 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x14 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x14 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x14 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x14 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x16 "PCR190,Pad Configuration Register 190"
  bitfld.word 0x16 10.--12.       "PA , Pin assignment" "GPIO,EMIOS11,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x16 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x16 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x16 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x16 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x16 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x16 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x16 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x18 "PCR191,Pad Configuration Register 191"
  bitfld.word 0x18 10.--12.       "PA , Pin assignment" "GPIO,EMIOS12,SOUTC,EMIOS12,res.,res.,res.,res.      "
  bitfld.word 0x18 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x18 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x18 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x18 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x18 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x18 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x18 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x1A "PCR192,Pad Configuration Register 192"
  bitfld.word 0x1A 10.--12.       "PA , Pin assignment" "GPIO,EMIOS13,SOUTD,EMIOS13,res.,res.,res.,res.      "
  bitfld.word 0x1A 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x1A 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x1A 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x1A 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x1A 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x1A 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x1A 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x1c "PCR193,Pad Configuration Register 193"
  bitfld.word 0x1c 10.--12.       "PA , Pin assignment" "GPIO,EMIOS14,IRQ00,EMIOS14,res.,res.,res.,res.      "
  bitfld.word 0x1c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x1c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x1c 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x1c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x1c 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x1c 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x1c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x1e "PCR194,Pad Configuration Register 194"
  bitfld.word 0x1e 10.--12.       "PA , Pin assignment" "GPIO,EMIOS15,IRQ01,EMIOS15,res.,res.,res.,res.      "
  bitfld.word 0x1e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x1e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x1e 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x1e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x1e 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x1e 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x1e 00.            "  WPS , Weak pull up/down select" "0,1"

TEXTLINE ""
  line.word 0x20 "PCR195,Pad Configuration Register 195"
  bitfld.word 0x20 10.--12.       "PA , Pin assignment" "GPIO,EMIOS16,ETPUB00,EMIOS16,res.,res.,res.,res.      "
  bitfld.word 0x20 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x20 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x20 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x20 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x20 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x20 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x20 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x22 "PCR196,Pad Configuration Register 196"
  bitfld.word 0x22 10.--12.       "PA , Pin assignment" "GPIO,EMIOS17,ETPUB01,EMIOS17,res.,res.,res.,res.      "
  bitfld.word 0x22 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x22 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x22 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x22 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x22 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x22 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x22 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x24 "PCR197,Pad Configuration Register 197"
  bitfld.word 0x24 10.--12.       "PA , Pin assignment" "GPIO,EMIOS18,ETPUB02,EMIOS18,res.,res.,res.,res.      "
  bitfld.word 0x24 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x24 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x24 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x24 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x24 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x24 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x24 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x26 "PCR198,Pad Configuration Register 198"
  bitfld.word 0x26 10.--12.       "PA , Pin assignment" "GPIO,EMIOS19,ETPUB03,EMIOS19,res.,res.,res.,res.      "
  bitfld.word 0x26 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x26 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x26 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x26 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x26 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x26 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x26 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x28 "PCR199,Pad Configuration Register 199"
  bitfld.word 0x28 10.--12.       "PA , Pin assignment" "GPIO,EMIOS20,ETPUB04,EMIOS20,res.,res.,res.,res.      "
  bitfld.word 0x28 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x28 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x28 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x28 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x28 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x28 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x28 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x2a "PCR200,Pad Configuration Register 200"
  bitfld.word 0x2a 10.--12.       "PA , Pin assignment" "GPIO,EMIOS21,ETPUB05,EMIOS21,res.,res.,res.,res.      "
  bitfld.word 0x2a 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x2a 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x2a 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x2a 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x2a 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x2a 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x2a 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x2c "PCR201,Pad Configuration Register 201"
  bitfld.word 0x2c 10.--12.       "PA , Pin assignment" "GPIO,EMIOS22,ETPUB06,EMIOS22,res.,res.,res.,res.      "
  bitfld.word 0x2c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x2c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x2c 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x2c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x2c 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x2c 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x2c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x2e "PCR202,Pad Configuration Register 202"
  bitfld.word 0x2e 10.--12.       "PA , Pin assignment" "GPIO,EMIOS23,ETPUB07,EMIOS23,res.,res.,res.,res.      "
  bitfld.word 0x2e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x2e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x2e 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x2e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x2e 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x2e 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x2e 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F901D6++0x09 "PCR203-207: GPIO / EMIOS[14:15]"
  line.word 0x00 "PCR203,Pad Configuration Register 203"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,EMIOS14,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR204,Pad Configuration Register 204"
  bitfld.word 0x02 10.--12.       "PA , Pin assignment" "GPIO,EMIOS15,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x02 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x04 "PCR205,Pad Configuration Register 205"
  bitfld.word 0x04 10.--12.       "PA , Pin assignment" "GPIO,res.,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x04 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x04 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x04 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x04 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x04 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x04 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x04 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x06 "PCR206,Pad Configuration Register 206"
  bitfld.word 0x06 10.--12.       "PA , Pin assignment" "GPIO,res.,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x06 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x06 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x06 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x06 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x06 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x06 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x06 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x08 "PCR207,Pad Configuration Register 207"
  bitfld.word 0x08 10.--12.       "PA , Pin assignment" "GPIO,res.,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x08 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x08 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x08 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x08 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x08 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x08 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x08 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F901E0++0x03 "PCR208-209: PLLCFG[0:1] / IRQ[4:5] / SOUTD"
  line.word 0x00 "PCR208,Pad Configuration Register 208"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,PLLCFG0,IRQ04,PLLCFG0,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR209,Pad Configuration Register 209"
  bitfld.word 0x02 10.--12.       "PA , Pin assignment" "GPIO,PLLCFG1,IRQ05,PLLCFG1,SOUTD,res.,res.,res.      "
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x02 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F901E4++0x01 "PCR210: !RSCFG"
  line.word 0x00 "PCR210,Pad Configuration Register 210"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,!RSCFG,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F901E6++0x03 "PCR211-212: BOOTCFG[0:1] / IRQ[2:3]"
  line.word 0x00 "PCR211,Pad Configuration Register 211"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,BOOTCFG0,IRQ02,BOOTCFG0,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR212,Pad Configuration Register 212"
  bitfld.word 0x02 10.--12.       "PA , Pin assignment" "GPIO,BOOTCFG1,IRQ03,BOOTCFG0,res.,res.,res.,res.      "
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x02 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F901EA++0x01 "PCR213: WKPCFG"
  line.word 0x00 "PCR213,Pad Configuration Register 213"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,WKPCFG,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F901EC++0x01 "PCR214: ENGCLK"
  line.word 0x00 "PCR214,Pad Configuration Register 214"

; bitfld.word 0x00 10.--13.       "PA , Pin assignment" "   0,   1,   2,   3,   4,   5,   6,   7,   8,   9,   A,   B,   C,   D,   E,   F"
  bitfld.word 0x00 09.            "         OBE , Output buffer enable" "0,1"
; bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "         DSC , Drive strength control" "10pF,20pF,30pF,50pF"
; bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
; bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
; bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
; bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
; bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

group 0xC3F901EE++0x01 "PCR215: AN12 / MA0 / !SDS"
  line.word 0x00 "PCR215,Pad Configuration Register 215"

  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "!SDS,res.,MA0,AN12,res.,res.,res.,res.      "
;  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
;  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
; bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
;  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
;  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
;  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F901F0++0x01 "PCR216: AN13 / MA1 / SDO"
  line.word 0x00 "PCR216,Pad Configuration Register 216"

  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "SDO,res.,MA1,AN13,res.,res.,res.,res.      "
;  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
;  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
; bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
;  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
;  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
;  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F901F2++0x01 "PCR217: AN14 / MA2 / SDI"
  line.word 0x00 "PCR217,Pad Configuration Register 217"

  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "SDI,res.,MA2,AN14,res.,res.,res.,res.      "
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F901F4++0x01 "PCR218: AN15 / FCK"
  line.word 0x00 "PCR218,Pad Configuration Register 218"

  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "FCK,AN15,res.,res.,res.,res.,res.,res.      "
;  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
;  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
; bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
;  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
;  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
;  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F901F6++0x01 "PCR219: MCKO"
  line.word 0x00 "PCR219,Pad Configuration Register 219"

;  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "   0,   1,   2,   3,   4,   5,   6,   7,   8,   9,   A,   B,   C,   D,   E,   F"
;  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
;  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "                       DSC , Drive strength control" "10pF,20pF,30pF,50pF"
;  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
;  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
;  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
;  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
;  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

group 0xC3F901F8++0x09 "PCR220-223: MDO[0:3]"
  line.word 0x00 "PCR220,Pad Configuration Register 220"

;  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "   0,   1,   2,   3,   4,   5,   6,   7,   8,   9,   A,   B,   C,   D,   E,   F"
;  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
;  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "                       DSC , Drive strength control" "10pF,20pF,30pF,50pF"
;  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
;  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
;  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
;  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
;  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"
  line.word 0x02 "PCR221,Pad Configuration Register 221"

;  bitfld.word 0x02 10.--13.       "PA , Pin assignment" "   0,   1,   2,   3,   4,   5,   6,   7,   8,   9,   A,   B,   C,   D,   E,   F"
;  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
;  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 06.--07.       "                       DSC , Drive strength control" "10pF,20pF,30pF,50pF"
;  bitfld.word 0x02 05.            "  ODE , Open drain output enable" "0,1"
;  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
;  bitfld.word 0x02 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
;  bitfld.word 0x02 01.            "  WPE , Weak pull up/down enable" "0,1"
;  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"
  line.word 0x04 "PCR222,Pad Configuration Register 222"

;  bitfld.word 0x04 10.--13.       "PA , Pin assignment" "   0,   1,   2,   3,   4,   5,   6,   7,   8,   9,   A,   B,   C,   D,   E,   F"
;  bitfld.word 0x04 09.            "  OBE , Output buffer enable" "0,1"
;  bitfld.word 0x04 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x04 06.--07.       "                       DSC , Drive strength control" "10pF,20pF,30pF,50pF"
;  bitfld.word 0x04 05.            "  ODE , Open drain output enable" "0,1"
;  bitfld.word 0x04 04.            "  HYS , Input hysteresis" "0,1"
;  bitfld.word 0x04 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
;  bitfld.word 0x04 01.            "  WPE , Weak pull up/down enable" "0,1"
;  bitfld.word 0x04 00.            "  WPS , Weak pull up/down select" "0,1"
  line.word 0x06 "PCR223,Pad Configuration Register 223"

;  bitfld.word 0x06 10.--13.       "PA , Pin assignment" "   0,   1,   2,   3,   4,   5,   6,   7,   8,   9,   A,   B,   C,   D,   E,   F"
;  bitfld.word 0x06 09.            "  OBE , Output buffer enable" "0,1"
;  bitfld.word 0x06 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x06 06.--07.       "                       DSC , Drive strength control" "10pF,20pF,30pF,50pF"
;  bitfld.word 0x06 05.            "  ODE , Open drain output enable" "0,1"
;  bitfld.word 0x06 04.            "  HYS , Input hysteresis" "0,1"
;  bitfld.word 0x06 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
;  bitfld.word 0x06 01.            "  WPE , Weak pull up/down enable" "0,1"
;  bitfld.word 0x06 00.            "  WPS , Weak pull up/down select" "0,1"

group 0xC3F90200++0x03 "PCR224-225: !MSEO[0:1]"
  line.word 0x00 "PCR224,Pad Configuration Register 224"

;  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "   0,   1,   2,   3,   4,   5,   6,   7,   8,   9,   A,   B,   C,   D,   E,   F"
;  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
;  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "                       DSC , Drive strength control" "10pF,20pF,30pF,50pF"
;  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
;  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
;  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
;  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
;  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"
  line.word 0x02 "PCR225,Pad Configuration Register 225"

;  bitfld.word 0x02 10.--13.       "PA , Pin assignment" "   0,   1,   2,   3,   4,   5,   6,   7,   8,   9,   A,   B,   C,   D,   E,   F"
;  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
;  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 06.--07.       "                       DSC , Drive strength control" "10pF,20pF,30pF,50pF"
;  bitfld.word 0x02 05.            "  ODE , Open drain output enable" "0,1"
;  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
;  bitfld.word 0x02 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
;  bitfld.word 0x02 01.            "  WPE , Weak pull up/down enable" "0,1"
;  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"

group 0xC3F90204++0x01 "PCR226: !RDY"
  line.word 0x00 "PCR226,Pad Configuration Register 226"

;  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "   0,   1,   2,   3,   4,   5,   6,   7,   8,   9,   A,   B,   C,   D,   E,   F"
;  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
;  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "                       DSC , Drive strength control" "10pF,20pF,30pF,50pF"
;  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
;  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
;  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
;  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
;  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

group 0xC3F90206++0x01 "PCR227: !EVTO"
  line.word 0x00 "PCR227,Pad Configuration Register 227"

;  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "   0,   1,   2,   3,   4,   5,   6,   7,   8,   9,   A,   B,   C,   D,   E,   F"
;  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
;  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "                       DSC , Drive strength control" "10pF,20pF,30pF,50pF"
;  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
;  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
;  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
;  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
;  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

group 0xC3F90208++0x01 "PCR228: TDO"
  line.word 0x00 "PCR228,Pad Configuration Register 228"

;  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "   0,   1,   2,   3,   4,   5,   6,   7,   8,   9,   A,   B,   C,   D,   E,   F"
;  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
;  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "                       DSC , Drive strength control" "10pF,20pF,30pF,50pF"
;  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
;  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
;  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
;  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
;  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

group 0xC3F9020A++0x01 "PCR229: !CLKOUT"
  line.word 0x00 "PCR229,Pad Configuration Register 229"

; bitfld.word 0x00 10.--13.       "PA , Pin assignment" "   0,   1,   2,   3,   4,   5,   6,   7,   8,   9,   A,   B,   C,   D,   E,   F"
  bitfld.word 0x00 09.            "         OBE , Output buffer enable" "0,1"
; bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "         DSC , Drive strength control" "10pF,20pF,30pF,50pF"
; bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
; bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
; bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
; bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
; bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

group 0xC3F9020C++0x01 "PCR230: !RSTOUT"
  line.word 0x00 "PCR230,Pad Configuration Register 230"

;  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "   0,   1,   2,   3,   4,   5,   6,   7,   8,   9,   A,   B,   C,   D,   E,   F"
;  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
;  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
;  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
;  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
;  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "                                               SRC , Slew rate control" "Min,Med,res,Max"
;  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
;  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"
endif

sif (CPU()=="MPC5553")
group 0xC3F90040++0x07 "PCR000-PCR003: !CS[0:3] / ADDR[8:11]"
  line.word 0x00 "PCR000,Pad Configuration Register 000"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPI0,!CS0,ADDR08,!CS0,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR001,Pad Configuration Register 001"
  bitfld.word 0x02 10.--12.       "PA , Pin assignment" "GPI0,!CS1,ADDR09,!CS1,res.,res.,res.,res.      "
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x02 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x04 "PCR002,Pad Configuration Register 002"
  bitfld.word 0x04 10.--12.       "PA , Pin assignment" "GPI0,!CS2,ADDR10,!CS2,res.,res.,res.,res.      "
  bitfld.word 0x04 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x04 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x04 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x04 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x04 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x04 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x04 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x06 "PCR003,Pad Configuration Register 003"
  bitfld.word 0x06 10.--12.       "PA , Pin assignment" "GPI0,!CS3,ADDR11,!CS3,res.,res.,res.,res.      "
  bitfld.word 0x06 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x06 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x06 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x06 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x06 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x06 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x06 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90048++0x2f "PCR004-PCR007: ADDR[8:11] / CAL_ADDR[27:30]"
  line.word 0x00 "PCR004,Pad Configuration Register 004"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,ADDR08,res.,ADDR08,CAL_ADDR27,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR005,Pad Configuration Register 005"
  bitfld.word 0x02 10.--12.       "PA , Pin assignment" "GPIO,ADDR09,res.,ADDR09,CAL_ADDR28,res.,res.,res.      "
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x02 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x04 "PCR006,Pad Configuration Register 006"
  bitfld.word 0x04 10.--12.       "PA , Pin assignment" "GPIO,ADDR10,res.,ADDR10,CAL_ADDR29,res.,res.,res.      "
  bitfld.word 0x04 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x04 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x04 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x04 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x04 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x04 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x04 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x06 "PCR007,Pad Configuration Register 007"
  bitfld.word 0x06 10.--12.       "PA , Pin assignment" "GPIO,ADDR11,res.,ADDR11,CAL_ADDR30,res.,res.,res.      "
  bitfld.word 0x06 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x06 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x06 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x06 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x06 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x06 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x06 00.            "  WPS , Weak pull up/down select" "0,1"

group 0xC3F90048++0x2f "PCR008-PCR011: ADDR[12:15]"
  line.word 0x08 "PCR008,Pad Configuration Register 008"
  bitfld.word 0x08 10.--12.       "PA , Pin assignment" "GPIO,ADDR12,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x08 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x08 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x08 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x08 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x08 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x08 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x08 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0a "PCR009,Pad Configuration Register 009"
  bitfld.word 0x0a 10.--12.       "PA , Pin assignment" "GPIO,ADDR13,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x0a 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0a 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0a 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x0a 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x0a 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0a 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0a 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0c "PCR010,Pad Configuration Register 010"
  bitfld.word 0x0c 10.--12.       "PA , Pin assignment" "GPIO,ADDR14,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x0c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0c 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x0c 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x0c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0c 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0e "PCR011,Pad Configuration Register 011"
  bitfld.word 0x0e 10.--12.       "PA , Pin assignment" "GPIO,ADDR15,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x0e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0e 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x0e 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x0e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0e 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0e 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90048++0x2f "PCR011-PCR027: ADDR[16:31]"
  line.word 0x10 "PCR012,Pad Configuration Register 012"
  bitfld.word 0x10 10.--12.       "PA , Pin assignment" "GPIO,ADDR16,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x10 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x10 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x10 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x10 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x10 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x10 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x10 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x12 "PCR013,Pad Configuration Register 013"
  bitfld.word 0x12 10.--12.       "PA , Pin assignment" "GPIO,ADDR17,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x12 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x12 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x12 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x12 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x12 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x12 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x12 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x14 "PCR014,Pad Configuration Register 014"
  bitfld.word 0x14 10.--12.       "PA , Pin assignment" "GPIO,ADDR18,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x14 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x14 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x14 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x14 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x14 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x14 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x14 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x16 "PCR015,Pad Configuration Register 015"
  bitfld.word 0x16 10.--12.       "PA , Pin assignment" "GPIO,ADDR19,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x16 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x16 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x16 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x16 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x16 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x16 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x16 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x18 "PCR016,Pad Configuration Register 016"
  bitfld.word 0x18 10.--12.       "PA , Pin assignment" "GPIO,ADDR20,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x18 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x18 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x18 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x18 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x18 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x18 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x18 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x1A "PCR017,Pad Configuration Register 017"
  bitfld.word 0x1A 10.--12.       "PA , Pin assignment" "GPIO,ADDR21,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x1A 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x1A 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x1A 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x1A 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x1A 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x1A 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x1A 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x1C "PCR018,Pad Configuration Register 018"
  bitfld.word 0x1C 10.--12.       "PA , Pin assignment" "GPIO,ADDR22,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x1C 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x1C 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x1C 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x1C 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x1C 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x1C 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x1C 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x1E "PCR019,Pad Configuration Register 019"
  bitfld.word 0x1E 10.--12.       "PA , Pin assignment" "GPIO,ADDR23,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x1E 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x1E 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x1E 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x1E 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x1E 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x1E 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x1E 00.            "  WPS , Weak pull up/down select" "0,1"

TEXTLINE ""
  line.word 0x20 "PCR020,Pad Configuration Register 020"
  bitfld.word 0x20 10.--12.       "PA , Pin assignment" "GPIO,ADDR24,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x20 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x20 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x20 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x20 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x20 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x20 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x20 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x22 "PCR021,Pad Configuration Register 021"
  bitfld.word 0x22 10.--12.       "PA , Pin assignment" "GPIO,ADDR25,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x22 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x22 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x22 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x22 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x22 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x22 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x22 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x24 "PCR022,Pad Configuration Register 022"
  bitfld.word 0x24 10.--12.       "PA , Pin assignment" "GPIO,ADDR26,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x24 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x24 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x24 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x24 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x24 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x24 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x24 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x26 "PCR023,Pad Configuration Register 023"
  bitfld.word 0x26 10.--12.       "PA , Pin assignment" "GPIO,ADDR27,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x26 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x26 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x26 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x26 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x26 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x26 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x26 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x28 "PCR024,Pad Configuration Register 024"
  bitfld.word 0x28 10.--12.       "PA , Pin assignment" "GPIO,ADDR28,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x28 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x28 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x28 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x28 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x28 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x28 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x28 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x2a "PCR025,Pad Configuration Register 025"
  bitfld.word 0x2a 10.--12.       "PA , Pin assignment" "GPIO,ADDR29,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x2a 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x2a 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x2a 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x2a 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x2a 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x2a 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x2a 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x2c "PCR026,Pad Configuration Register 026"
  bitfld.word 0x2c 10.--12.       "PA , Pin assignment" "GPIO,ADDR30,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x2c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x2c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x2c 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x2c 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x2c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x2c 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x2c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x2e "PCR027,Pad Configuration Register 027"
  bitfld.word 0x2e 10.--12.       "PA , Pin assignment" "GPIO,ADDR31,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x2e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x2e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x2e 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x2e 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x2e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x2e 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x2e 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90078++0x3f "PCR028-PCR043: DATA[0:15]"
  line.word 0x00 "PCR028,Pad Configuration Register 028"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,DATA00,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR029,Pad Configuration Register 029"
  bitfld.word 0x02 10.--12.       "PA , Pin assignment" "GPIO,DATA01,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x02 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x04 "PCR030,Pad Configuration Register 030"
  bitfld.word 0x04 10.--12.       "PA , Pin assignment" "GPIO,DATA02,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x04 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x04 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x04 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x04 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x04 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x04 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x04 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x06 "PCR031,Pad Configuration Register 031"
  bitfld.word 0x06 10.--12.       "PA , Pin assignment" "GPIO,DATA03,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x06 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x06 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x06 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x06 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x06 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x06 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x06 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x08 "PCR032,Pad Configuration Register 032"
  bitfld.word 0x08 10.--12.       "PA , Pin assignment" "GPIO,DATA04,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x08 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x08 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x08 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x08 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x08 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x08 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x08 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0a "PCR033,Pad Configuration Register 033"
  bitfld.word 0x0a 10.--12.       "PA , Pin assignment" "GPIO,DATA05,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x0a 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0a 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0a 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x0a 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x0a 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0a 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0a 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0c "PCR034,Pad Configuration Register 034"
  bitfld.word 0x0c 10.--12.       "PA , Pin assignment" "GPIO,DATA06,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x0c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0c 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x0c 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x0c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0c 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0e "PCR035,Pad Configuration Register 035"
  bitfld.word 0x0e 10.--12.       "PA , Pin assignment" "GPIO,DATA07,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x0e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0e 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x0e 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x0e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0e 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0e 00.            "  WPS , Weak pull up/down select" "0,1"

TEXTLINE ""
  line.word 0x10 "PCR036,Pad Configuration Register 036"
  bitfld.word 0x10 10.--12.       "PA , Pin assignment" "GPIO,DATA08,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x10 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x10 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x10 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x10 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x10 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x10 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x10 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x12 "PCR037,Pad Configuration Register 037"
  bitfld.word 0x12 10.--12.       "PA , Pin assignment" "GPIO,DATA09,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x12 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x12 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x12 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x12 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x12 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x12 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x12 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x14 "PCR038,Pad Configuration Register 038"
  bitfld.word 0x14 10.--12.       "PA , Pin assignment" "GPIO,DATA10,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x14 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x14 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x14 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x14 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x14 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x14 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x14 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x16 "PCR039,Pad Configuration Register 039"
  bitfld.word 0x16 10.--12.       "PA , Pin assignment" "GPIO,DATA11,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x16 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x16 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x16 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x16 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x16 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x16 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x16 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x18 "PCR040,Pad Configuration Register 040"
  bitfld.word 0x18 10.--12.       "PA , Pin assignment" "GPIO,DATA12,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x18 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x18 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x18 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x18 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x18 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x18 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x18 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x1A "PCR041,Pad Configuration Register 041"
  bitfld.word 0x1A 10.--12.       "PA , Pin assignment" "GPIO,DATA13,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x1A 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x1A 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x1A 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x1A 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x1A 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x1A 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x1A 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x1c "PCR042,Pad Configuration Register 042"
  bitfld.word 0x1c 10.--12.       "PA , Pin assignment" "GPIO,DATA14,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x1c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x1c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x1c 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x1c 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x1c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x1c 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x1c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x1e "PCR043,Pad Configuration Register 043"
  bitfld.word 0x1e 10.--12.       "PA , Pin assignment" "GPIO,DATA15,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x1e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x1e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x1e 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x1e 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x1e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x1e 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x1e 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90078++0x3f "PCR044-PCR059: DATA[16:31] / [FEC] / CAL_DATA[0:15]"
  line.word 0x20 "PCR044,Pad Configuration Register 044"
  bitfld.word 0x20 10.--12.       "PA , Pin assignment" "GPIO,DATA16,TX_CLK,DATA16,CAL_DATA0,res.,res.,res.      "
  bitfld.word 0x20 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x20 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x20 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x20 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x20 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x20 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x20 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x22 "PCR045,Pad Configuration Register 045"
  bitfld.word 0x22 10.--12.       "PA , Pin assignment" "GPIO,DATA17,CRS,DATA17,CAL_DATA1,res.,res.,res.      "
  bitfld.word 0x22 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x22 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x22 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x22 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x22 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x22 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x22 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x24 "PCR046,Pad Configuration Register 046"
  bitfld.word 0x24 10.--12.       "PA , Pin assignment" "GPIO,DATA18,TX_ERR,DATA18,CAL_DATA2,res.,res.,res.      "
  bitfld.word 0x24 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x24 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x24 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x24 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x24 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x24 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x24 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x26 "PCR047,Pad Configuration Register 047"
  bitfld.word 0x26 10.--12.       "PA , Pin assignment" "GPIO,DATA19,RX_CLK,DATA19,CAL_DATA3,res.,res.,res.      "
  bitfld.word 0x26 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x26 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x26 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x26 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x26 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x26 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x26 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x28 "PCR048,Pad Configuration Register 048"
  bitfld.word 0x28 10.--12.       "PA , Pin assignment" "GPIO,DATA20,TXD0,DATA20,CAL_DATA4,res.,res.,res.      "
  bitfld.word 0x28 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x28 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x28 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x28 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x28 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x28 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x28 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x2a "PCR049,Pad Configuration Register 049"
  bitfld.word 0x2a 10.--12.       "PA , Pin assignment" "GPIO,DATA21,RX_ERR,DATA21,CAL_DATA5,res.,res.,res.      "
  bitfld.word 0x2a 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x2a 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x2a 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x2a 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x2a 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x2a 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x2a 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x2c "PCR050,Pad Configuration Register 050"
  bitfld.word 0x2c 10.--12.       "PA , Pin assignment" "GPIO,DATA22,RXD0,DATA22,CAL_DATA6,res.,res.,res.      "
  bitfld.word 0x2c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x2c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x2c 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x2c 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x2c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x2c 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x2c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x2e "PCR051,Pad Configuration Register 051"
  bitfld.word 0x2e 10.--12.       "PA , Pin assignment" "GPIO,DATA23,TXD3,DATA23,CAL_DATA7,res.,res.,res.      "
  bitfld.word 0x2e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x2e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x2e 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x2e 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x2e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x2e 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x2e 00.            "  WPS , Weak pull up/down select" "0,1"

TEXTLINE ""
  line.word 0x30 "PCR052,Pad Configuration Register 052"
  bitfld.word 0x30 10.--12.       "PA , Pin assignment" "GPIO,DATA24,COL,DATA24,CAL_DATA8,res.,res.,res.      "
  bitfld.word 0x30 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x30 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x30 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x30 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x30 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x30 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x30 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x32 "PCR053,Pad Configuration Register 053"
  bitfld.word 0x32 10.--12.       "PA , Pin assignment" "GPIO,DATA25,RX_DV,DATA25,CAL_DATA9,res.,res.,res.      "
  bitfld.word 0x32 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x32 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x32 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x32 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x32 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x32 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x32 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x34 "PCR054,Pad Configuration Register 054"
  bitfld.word 0x34 10.--12.       "PA , Pin assignment" "GPIO,DATA26,TX_EN,DATA26,CAL_DATA10,res.,res.,res.      "
  bitfld.word 0x34 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x34 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x34 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x34 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x34 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x34 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x34 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x36 "PCR055,Pad Configuration Register 055"
  bitfld.word 0x36 10.--12.       "PA , Pin assignment" "GPIO,DATA27,TXD2,DATA27,CAL_DATA11,res.,res.,res.      "
  bitfld.word 0x36 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x36 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x36 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x36 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x36 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x36 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x36 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x38 "PCR056,Pad Configuration Register 056"
  bitfld.word 0x38 10.--12.       "PA , Pin assignment" "GPIO,DATA28,TXD1,DATA28,CAL_DATA12,res.,res.,res.      "
  bitfld.word 0x38 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x38 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x38 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x38 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x38 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x38 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x38 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x3a "PCR057,Pad Configuration Register 057"
  bitfld.word 0x3a 10.--12.       "PA , Pin assignment" "GPIO,DATA29,RXD1,DATA29,CAL_DATA13,res.,res.,res.      "
  bitfld.word 0x3a 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x3a 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x3a 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x3a 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x3a 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x3a 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x3a 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x3c "PCR058,Pad Configuration Register 058"
  bitfld.word 0x3c 10.--12.       "PA , Pin assignment" "GPIO,DATA30,RXD2,DATA30,CAL_DATA14,res.,res.,res.      "
  bitfld.word 0x3c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x3c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x3c 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x3c 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x3c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x3c 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x3c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x3e "PCR059,Pad Configuration Register 059"
  bitfld.word 0x3e 10.--12.       "PA , Pin assignment" "GPIO,DATA31,RXD3,DATA31,CAL_DATA15,res.,res.,res.      "
  bitfld.word 0x3e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x3e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x3e 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x3e 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x3e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x3e 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x3e 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900BC++0x01 "PCR062: RD/!WR"
  line.word 0x00 "PCR062,Pad Configuration Register 062"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,RD/!WR,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900BE++0x01 "PCR063: !BDIP"
  line.word 0x00 "PCR063,Pad Configuration Register 063"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,!BDIP,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900C0++0x03 "PCR064-065: !WE_BE[0:3]"
  line.word 0x00 "PCR064,Pad Configuration Register 064"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,!WE0_BE0,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR065,Pad Configuration Register 065"
  bitfld.word 0x02 10.--12.       "PA , Pin assignment" "GPIO,!WE1_BE1,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x02 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"

group 0xC3F900C4++0x03 "PCR066-067: WE_BE[2:3] / CAL_WE_BE[0:1]"
  line.word 0x00 "PCR066,Pad Configuration Register 066"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,!WE2_BE2,res.,!WE2_BE2,!CAL_WE0,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR067,Pad Configuration Register 067"
  bitfld.word 0x02 10.--12.       "PA , Pin assignment" "GPIO,!WE3_BE3,res.,!WE3_BE3,!CAL_WE1,res.,res.,res.      "
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x02 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900C8++0x01 "PCR068: !OE"
  line.word 0x00 "PCR068,Pad Configuration Register 068"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,!OE,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900CA++0x01 "PCR069: !TS"
  line.word 0x00 "PCR069,Pad Configuration Register 069"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,!TS,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900CC++0x01 "PCR070: !TA"
  line.word 0x00 "PCR070,Pad Configuration Register 070"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,!TA,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900CE++0x01 "PCR071: !TEA !CAL_CS0"
  line.word 0x00 "PCR071,Pad Configuration Register 071"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,!TEA,!CAL_CS0,!TEA,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900D0++0x01 "PCR072: CAL_ADDR[10] MDC CAL_CS[2]"
  line.word 0x00 "PCR072,Pad Configuration Register 072"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,CAL_ADDR10,MDC,CAL_ADDR10,!CAL_CS2,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900D2++0x01 "PCR073: CAL_ADDR[11] MDIO CAL_CS[3]"
  line.word 0x00 "PCR073,Pad Configuration Register 073"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,CAL_ADDR11,MDIO,CAL_ADDR11,!CAL_CS3,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900D6++0x0f "PCR075-PCR082: MDO[4:11]"
  line.word 0x00 "PCR075,Pad Configuration Register 075"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO/MDO04,res.,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR076,Pad Configuration Register 076"
  bitfld.word 0x02 10.--12.       "PA , Pin assignment" "GPIO/MDO05,res.,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x02 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x04 "PCR077,Pad Configuration Register 077"
  bitfld.word 0x04 10.--12.       "PA , Pin assignment" "GPIO/MDO06,res.,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x04 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x04 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x04 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x04 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x04 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x04 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x04 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x06 "PCR078,Pad Configuration Register 078"
  bitfld.word 0x06 10.--12.       "PA , Pin assignment" "GPIO/MDO07,res.,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x06 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x06 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x06 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x06 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x06 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x06 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x06 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x08 "PCR079,Pad Configuration Register 079"
  bitfld.word 0x08 10.--12.       "PA , Pin assignment" "GPIO/MDO08,res.,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x08 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x08 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x08 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x08 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x08 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x08 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x08 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0a "PCR080,Pad Configuration Register 080"
  bitfld.word 0x0a 10.--12.       "PA , Pin assignment" "GPIO/MDO09,res.,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x0a 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0a 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0a 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x0a 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x0a 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0a 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0a 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0c "PCR081,Pad Configuration Register 081"
  bitfld.word 0x0c 10.--12.       "PA , Pin assignment" "GPIO/MDO10,res.,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x0c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0c 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x0c 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x0c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0c 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0e "PCR082,Pad Configuration Register 082"
  bitfld.word 0x0e 10.--12.       "PA , Pin assignment" "GPIO/MDO11,res.,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x0e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0e 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x0e 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x0e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0e 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0e 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900E6++0x01 "PCR083: CNTX_A"
  line.word 0x00 "PCR083,Pad Configuration Register 083"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,CNTX_A,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900E8++0x01 "PCR084: CNRX_A"
  line.word 0x00 "PCR084,Pad Configuration Register 084"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,CNRX_A,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900EA++0x01 "PCR085: CNTX_B / DSPI PCSC3"
  line.word 0x00 "PCR085,Pad Configuration Register 085"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,CNTX_B,PCSC3,CNTX_B,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900EC++0x01 "PCR086: CNRX_B / DSPI PCSC4"
  line.word 0x00 "PCR086,Pad Configuration Register 086"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,CNRX_B,PCSC4,CNRX_B,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900EE++0x01 "PCR087: CNTX_C / DSPI PCSD3"
  line.word 0x00 "PCR087,Pad Configuration Register 087"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,CNTX_C,PCSD3,CNTX_C,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900F0++0x01 "PCR088: CNRX_C / DSPI PCSD4"
  line.word 0x00 "PCR088,Pad Configuration Register 088"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,CNRX_C,PCSD4,CNRX_C,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900F2++0x01 "PCR089: TXD_A"
  line.word 0x00 "PCR089,Pad Configuration Register 089"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,TXD_A,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900F4++0x01 "PCR090: RXD_A"
  line.word 0x00 "PCR090,Pad Configuration Register 090"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,RXD_A,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900F6++0x01 "PCR091: TXD_B / DSPI PCSD1"
  line.word 0x00 "PCR091,Pad Configuration Register 091"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,TXD_B,PCSD1,TXD_B,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900F8++0x01 "PCR092: RXD_B / PCSD5"
  line.word 0x00 "PCR092,Pad Configuration Register 092"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,RXD_B,PCSD5,RXD_B,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900FA++0x01 "PCR093: DSPI SCK_A / DSPI PCSC1"
  line.word 0x00 "PCR093,Pad Configuration Register 093"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,SCK_A,PCSC1,SCK_A,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900FC++0x01 "PCR094: DSPI SIN_A / DSPI PCSC2"
  line.word 0x00 "PCR094,Pad Configuration Register 094"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,SIN_A,PCSC2,SIN_A,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F900FE++0x01 "PCR095: DSPI SOUT_A / DSPI PCSC5"
  line.word 0x00 "PCR095,Pad Configuration Register 095"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,SOUT_A,PCSC5,SOUT_A,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90100++0x01 "PCR096: DSPI PCSA0 / DSPI PCSD2"
  line.word 0x00 "PCR096,Pad Configuration Register 096"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,PCSA0,PCSD2,PCSA0,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90102++0x01 "PCR097: DSPI PCSA1 / PCSB2"
  line.word 0x00 "PCR097,Pad Configuration Register 097"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,PCSA1,PCSB2,PCSA1,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90104++0x01 "PCR098: DSPI PCSA2 / DSPI SCKD"
  line.word 0x00 "PCR098,Pad Configuration Register 098"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,PCSA2,SCKD,PCSA2,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90106++0x01 "PCR099: DSPI PCSA3 / DSPI SIN_D"
  line.word 0x00 "PCR099,Pad Configuration Register 099"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,PCSA3,SIN_D,PCSA3,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90108++0x01 "PCR100: DSPI PCSA4 / DSPI SOUTD"
  line.word 0x00 "PCR100,Pad Configuration Register 100"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,PCSA4,SOUTD,PCSA4,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F9010a++0x01 "PCR101: DSPI PCSA5 / DSPI PCSB3"
  line.word 0x00 "PCR101,Pad Configuration Register 101"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,PCSA5,PCSB3,PCSA5,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F9010c++0x01 "PCR102: DSPI SCKB / DSPI PCSC1"
  line.word 0x00 "PCR102,Pad Configuration Register 102"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,SCKB,PCSC1,SCKB,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F9010e++0x01 "PCR103: DSPI SINB / DSPI PCSC2"
  line.word 0x00 "PCR103,Pad Configuration Register 103"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,SINB,PCSC2,SINB,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90110++0x01 "PCR104: DSPI SOUTB / DSPI PCSC5"
  line.word 0x00 "PCR104,Pad Configuration Register 104"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,SOUTB,PCSC5,SOUTB,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90112++0x01 "PCR105: DSPI PCSB0 / DSPI PCSD2"
  line.word 0x00 "PCR105,Pad Configuration Register 105"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,PCSB0,PCSD2,PCSB0,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90114++0x01 "PCR106: DSPI PCSB1 / DSPI PCSD0"
  line.word 0x00 "PCR106,Pad Configuration Register 106"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,PCSB1,PCSD0,PCSB1,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90116++0x01 "PCR107: DSPI PCSB2 / DSPI SOUTC"
  line.word 0x00 "PCR107,Pad Configuration Register 107"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,PCSB2,SOUTC,PCSB2,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90118++0x01 "PCR108: DSPI PCSB3 / DSPI SINC"
  line.word 0x00 "PCR108,Pad Configuration Register 108"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,PCSB3,SINC,PCSB3,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F9011A++0x01 "PCR109: DSPI PCSB4 / DSPI SCKC"
  line.word 0x00 "PCR109,Pad Configuration Register 109"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,PCSB4,SCKC,PCSB4,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F9011C++0x01 "PCR110: DSPI PCSB5 / DSPI PCSC0"
  line.word 0x00 "PCR110,Pad Configuration Register 110"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,PCSB5,PCSC0,PCSB5,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F9011E++0x03 "PCR111-112: ETRIG[0:1]"
  line.word 0x00 "PCR111,Pad Configuration Register 111"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,ETRIG0,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR112,Pad Configuration Register 112"
  bitfld.word 0x02 10.--12.       "PA , Pin assignment" "GPIO,ETRIG1,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x02 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90122++0x01 "PCR113: TCRCLKA / IRQ7"
  line.word 0x00 "PCR113,Pad Configuration Register 113"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,TCRCLKA,IRQ7,TCRCLKA.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90124++0x3F "PCR114-145: ETPUA[0:31] / ETPUA[12:23] / PCSB[1:4] / IRQ[8:15] / PCDC[1:4] / PCSD[1:4]"
  line.word 0x00 "PCR114,Pad Configuration Register 114"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,ETPUA00,ETPUA12,ETPUA00,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR115,Pad Configuration Register 115"
  bitfld.word 0x02 10.--12.       "PA , Pin assignment" "GPIO,ETPUA01,ETPUA13,ETPUA01,res.,res.,res.,res.      "
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x02 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x04 "PCR116,Pad Configuration Register 116"
  bitfld.word 0x04 10.--12.       "PA , Pin assignment" "GPIO,ETPUA02,ETPUA14,ETPUA02,res.,res.,res.,res.      "
  bitfld.word 0x04 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x04 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x04 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x04 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x04 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x04 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x04 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x06 "PCR117,Pad Configuration Register 117"
  bitfld.word 0x06 10.--12.       "PA , Pin assignment" "GPIO,ETPUA03,ETPUA15,ETPUA03,res.,res.,res.,res.      "
  bitfld.word 0x06 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x06 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x06 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x06 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x06 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x06 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x06 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x08 "PCR118,Pad Configuration Register 118"
  bitfld.word 0x08 10.--12.       "PA , Pin assignment" "GPIO,ETPUA04,ETPUA16,ETPUA04,res.,res.,res.,res.      "
  bitfld.word 0x08 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x08 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x08 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x08 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x08 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x08 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x08 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0a "PCR119,Pad Configuration Register 119"
  bitfld.word 0x0a 10.--12.       "PA , Pin assignment" "GPIO,ETPUA05,ETPUA17,ETPUA05,res.,res.,res.,res.      "
  bitfld.word 0x0a 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0a 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0a 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x0a 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0a 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x0a 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0a 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0c "PCR120,Pad Configuration Register 120"
  bitfld.word 0x0c 10.--12.       "PA , Pin assignment" "GPIO,ETPUA06,ETPUA18,ETPUA06,res.,res.,res.,res.      "
  bitfld.word 0x0c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0c 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x0c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0c 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x0c 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0e "PCR121,Pad Configuration Register 121"
  bitfld.word 0x0e 10.--12.       "PA , Pin assignment" "GPIO,ETPUA07,ETPUA19,ETPUA07,res.,res.,res.,res.      "
  bitfld.word 0x0e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0e 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x0e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0e 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x0e 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0e 00.            "  WPS , Weak pull up/down select" "0,1"

TEXTLINE "" 
  line.word 0x10 "PCR122,Pad Configuration Register 122"
  bitfld.word 0x10 10.--12.       "PA , Pin assignment" "GPIO,ETPUA08,ETPUA20,ETPUA08,res.,res.,res.,res.      "
  bitfld.word 0x10 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x10 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x10 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x10 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x10 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x10 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x10 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x12 "PCR123,Pad Configuration Register 123"
  bitfld.word 0x12 10.--12.       "PA , Pin assignment" "GPIO,ETPUA09,ETPUA21,ETPUA09,res.,res.,res.,res.      "
  bitfld.word 0x12 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x12 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x12 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x12 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x12 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x12 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x12 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x14 "PCR124,Pad Configuration Register 124"
  bitfld.word 0x14 10.--12.       "PA , Pin assignment" "GPIO,ETPUA10,ETPUA22,ETPUA10,res.,res.,res.,res.      "
  bitfld.word 0x14 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x14 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x14 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x14 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x14 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x14 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x14 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x16 "PCR125,Pad Configuration Register 125"
  bitfld.word 0x16 10.--12.       "PA , Pin assignment" "GPIO,ETPUA11,ETPUA23,ETPUA11,res.,res.,res.,res.      "
  bitfld.word 0x16 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x16 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x16 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x16 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x16 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x16 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x16 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x18 "PCR126,Pad Configuration Register 126"
  bitfld.word 0x18 10.--12.       "PA , Pin assignment" "GPIO,ETPUA12,PCSB1,ETPUA12,res.,res.,res.,res.      "
  bitfld.word 0x18 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x18 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x18 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x18 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x18 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x18 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x18 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x1A "PCR127,Pad Configuration Register 127"
  bitfld.word 0x1A 10.--12.       "PA , Pin assignment" "GPIO,ETPUA13,PCSB3,ETPUA13,res.,res.,res.,res.      "
  bitfld.word 0x1A 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x1A 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x1A 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x1A 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x1A 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x1A 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x1A 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x1c "PCR128,Pad Configuration Register 128"
  bitfld.word 0x1c 10.--12.       "PA , Pin assignment" "GPIO,ETPUA14,PCSB4,ETPUA14,res.,res.,res.,res.      "
  bitfld.word 0x1c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x1c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x1c 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x1c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x1c 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x1c 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x1c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x1e "PCR129,Pad Configuration Register 129"
  bitfld.word 0x1e 10.--12.       "PA , Pin assignment" "GPIO,ETPUA15,PCSB5,ETPUA15,res.,res.,res.,res.      "
  bitfld.word 0x1e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x1e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x1e 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x1e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x1e 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x1e 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x1e 00.            "  WPS , Weak pull up/down select" "0,1"

TEXTLINE ""
  line.word 0x20 "PCR130,Pad Configuration Register 130"
  bitfld.word 0x20 10.--12.       "PA , Pin assignment" "GPIO,ETPUA16,PCSD1,ETPUA16,res.,res.,res.,res.      "
  bitfld.word 0x20 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x20 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x20 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x20 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x20 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x20 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x20 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x22 "PCR131,Pad Configuration Register 131"
  bitfld.word 0x22 10.--12.       "PA , Pin assignment" "GPIO,ETPUA17,PCSD2,ETPUA17,res.,res.,res.,res.      "
  bitfld.word 0x22 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x22 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x22 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x22 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x22 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x22 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x22 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x24 "PCR132,Pad Configuration Register 132"
  bitfld.word 0x24 10.--12.       "PA , Pin assignment" "GPIO,ETPUA18,PCSD3,ETPUA18,res.,res.,res.,res.      "
  bitfld.word 0x24 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x24 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x24 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x24 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x24 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x24 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x24 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x26 "PCR133,Pad Configuration Register 133"
  bitfld.word 0x26 10.--12.       "PA , Pin assignment" "GPIO,ETPUA19,PCSD4,ETPUA19,res.,res.,res.,res.      "
  bitfld.word 0x26 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x26 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x26 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x26 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x26 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x26 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x26 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x28 "PCR134,Pad Configuration Register 134"
  bitfld.word 0x28 10.--12.       "PA , Pin assignment" "GPIO,ETPUA20,IRQ08,ETPUA20,res.,res.,res.,res.      "
  bitfld.word 0x28 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x28 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x28 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x28 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x28 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x28 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x28 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x2a "PCR135,Pad Configuration Register 135"
  bitfld.word 0x2a 10.--12.       "PA , Pin assignment" "GPIO,ETPUA21,IRQ09,ETPUA21,res.,res.,res.,res.      "
  bitfld.word 0x2a 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x2a 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x2a 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x2a 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x2a 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x2a 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x2a 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x2c "PCR136,Pad Configuration Register 136"
  bitfld.word 0x2c 10.--12.       "PA , Pin assignment" "GPIO,ETPUA22,IRQ10,ETPUA22,res.,res.,res.,res.      "
  bitfld.word 0x2c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x2c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x2c 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x2c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x2c 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x2c 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x2c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x2e "PCR137,Pad Configuration Register 137"
  bitfld.word 0x2e 10.--12.       "PA , Pin assignment" "GPIO,ETPUA23,IRQ11,ETPUA23,res.,res.,res.,res.      "
  bitfld.word 0x2e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x2e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x2e 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x2e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x2e 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x2e 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x2e 00.            "  WPS , Weak pull up/down select" "0,1"

TEXTLINE ""
  line.word 0x30 "PCR138,Pad Configuration Register 138"
  bitfld.word 0x30 10.--12.       "PA , Pin assignment" "GPIO,ETPUA24,IRQ12,ETPUA24,res.,res.,res.,res.      "
  bitfld.word 0x30 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x30 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x30 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x30 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x30 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x30 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x30 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x32 "PCR139,Pad Configuration Register 139"
  bitfld.word 0x32 10.--12.       "PA , Pin assignment" "GPIO,ETPUA25,IRQ13,ETPUA25,res.,res.,res.,res.      "
  bitfld.word 0x32 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x32 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x32 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x32 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x32 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x32 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x32 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x34 "PCR140,Pad Configuration Register 140"
  bitfld.word 0x34 10.--12.       "PA , Pin assignment" "GPIO,ETPUA26,IRQ14,ETPUA26,res.,res.,res.,res.      "
  bitfld.word 0x34 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x34 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x34 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x34 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x34 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x34 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x34 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x36 "PCR141,Pad Configuration Register 141"
  bitfld.word 0x36 10.--12.       "PA , Pin assignment" "GPIO,ETPUA27,IRQ15,ETPUA27,res.,res.,res.,res.      "
  bitfld.word 0x36 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x36 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x36 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x36 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x36 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x36 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x36 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x38 "PCR142,Pad Configuration Register 142"
  bitfld.word 0x38 10.--12.       "PA , Pin assignment" "GPIO,ETPUA28,PCSC1,ETPUA28,res.,res.,res.,res.      "
  bitfld.word 0x38 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x38 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x38 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x38 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x38 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x38 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x38 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x3a "PCR143,Pad Configuration Register 143"
  bitfld.word 0x3a 10.--12.       "PA , Pin assignment" "GPIO,ETPUA29,PCSC2,ETPUA29,res.,res.,res.,res.      "
  bitfld.word 0x3a 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x3a 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x3a 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x3a 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x3a 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x3a 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x3a 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x3c "PCR144,Pad Configuration Register 144"
  bitfld.word 0x3c 10.--12.       "PA , Pin assignment" "GPIO,ETPUA30,PCSC3,ETPUA30,res.,res.,res.,res.      "
  bitfld.word 0x3c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x3c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x3c 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x3c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x3c 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x3c 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x3c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x3e "PCR145,Pad Configuration Register 145"
  bitfld.word 0x3e 10.--12.       "PA , Pin assignment" "GPIO,ETPUA31,PCSC4,ETPUA31,res.,res.,res.,res.      "
  bitfld.word 0x3e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x3e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x3e 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x3e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x3e 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x3e 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x3e 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F901A6++0x31 "PCR179-202: EMIOS[0:23] / ETPUA[0:9] / SOUTC / SOUTD / IRQ[0:1] / ETPUB[0:7]"
  line.word 0x00 "PCR179,Pad Configuration Register 179"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,EMIOS00,ETPUA00,EMIOS00,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR180,Pad Configuration Register 180"
  bitfld.word 0x02 10.--12.       "PA , Pin assignment" "GPIO,EMIOS01,ETPUA01,EMIOS01,res.,res.,res.,res.      "
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x02 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x04 "PCR181,Pad Configuration Register 181"
  bitfld.word 0x04 10.--12.       "PA , Pin assignment" "GPIO,EMIOS02,ETPUA02,EMIOS02,res.,res.,res.,res.      "
  bitfld.word 0x04 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x04 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x04 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x04 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x04 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x04 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x04 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x06 "PCR182,Pad Configuration Register 182"
  bitfld.word 0x06 10.--12.       "PA , Pin assignment" "GPIO,EMIOS03,ETPUA03,EMIOS03,res.,res.,res.,res.      "
  bitfld.word 0x06 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x06 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x06 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x06 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x06 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x06 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x06 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x08 "PCR183,Pad Configuration Register 183"
  bitfld.word 0x08 10.--12.       "PA , Pin assignment" "GPIO,EMIOS04,ETPUA04,EMIOS04,res.,res.,res.,res.      "
  bitfld.word 0x08 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x08 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x08 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x08 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x08 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x08 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x08 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0a "PCR184,Pad Configuration Register 184"
  bitfld.word 0x0a 10.--12.       "PA , Pin assignment" "GPIO,EMIOS05,ETPUA05,EMIOS05,res.,res.,res.,res.      "
  bitfld.word 0x0a 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0a 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0a 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x0a 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0a 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x0a 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0a 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0c "PCR185,Pad Configuration Register 185"
  bitfld.word 0x0c 10.--12.       "PA , Pin assignment" "GPIO,EMIOS06,ETPUA06,EMIOS06,res.,res.,res.,res.      "
  bitfld.word 0x0c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0c 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x0c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0c 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x0c 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0e "PCR186,Pad Configuration Register 186"
  bitfld.word 0x0e 10.--12.       "PA , Pin assignment" "GPIO,EMIOS07,ETPUA07,EMIOS07,res.,res.,res.,res.      "
  bitfld.word 0x0e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0e 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x0e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0e 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x0e 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0e 00.            "  WPS , Weak pull up/down select" "0,1"

TEXTLINE "" 
  line.word 0x10 "PCR187,Pad Configuration Register 187"
  bitfld.word 0x10 10.--12.       "PA , Pin assignment" "GPIO,EMIOS08,ETPUA08,EMIOS08,res.,res.,res.,res.      "
  bitfld.word 0x10 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x10 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x10 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x10 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x10 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x10 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x10 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x12 "PCR188,Pad Configuration Register 188"
  bitfld.word 0x12 10.--12.       "PA , Pin assignment" "GPIO,EMIOS09,ETPUA09,EMIOS09,res.,res.,res.,res.      "
  bitfld.word 0x12 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x12 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x12 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x12 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x12 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x12 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x12 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x14 "PCR189,Pad Configuration Register 189"
  bitfld.word 0x14 10.--12.       "PA , Pin assignment" "GPIO,EMIOS10,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x14 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x14 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x14 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x14 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x14 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x14 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x14 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x16 "PCR190,Pad Configuration Register 190"
  bitfld.word 0x16 10.--12.       "PA , Pin assignment" "GPIO,EMIOS11,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x16 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x16 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x16 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x16 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x16 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x16 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x16 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x18 "PCR191,Pad Configuration Register 191"
  bitfld.word 0x18 10.--12.       "PA , Pin assignment" "GPIO,EMIOS12,SOUTC,EMIOS12,res.,res.,res.,res.      "
  bitfld.word 0x18 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x18 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x18 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x18 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x18 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x18 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x18 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x1A "PCR192,Pad Configuration Register 192"
  bitfld.word 0x1A 10.--12.       "PA , Pin assignment" "GPIO,EMIOS13,SOUTD,EMIOS13,res.,res.,res.,res.      "
  bitfld.word 0x1A 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x1A 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x1A 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x1A 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x1A 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x1A 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x1A 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x1c "PCR193,Pad Configuration Register 193"
  bitfld.word 0x1c 10.--12.       "PA , Pin assignment" "GPIO,EMIOS14,IRQ00,EMIOS14,res.,res.,res.,res.      "
  bitfld.word 0x1c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x1c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x1c 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x1c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x1c 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x1c 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x1c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x1e "PCR194,Pad Configuration Register 194"
  bitfld.word 0x1e 10.--12.       "PA , Pin assignment" "GPIO,EMIOS15,IRQ01,EMIOS15,res.,res.,res.,res.      "
  bitfld.word 0x1e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x1e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x1e 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x1e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x1e 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x1e 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x1e 00.            "  WPS , Weak pull up/down select" "0,1"

TEXTLINE ""
  line.word 0x20 "PCR195,Pad Configuration Register 195"
  bitfld.word 0x20 10.--12.       "PA , Pin assignment" "GPIO,EMIOS16,ETPUB00,EMIOS16,res.,res.,res.,res.      "
  bitfld.word 0x20 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x20 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x20 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x20 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x20 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x20 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x20 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x22 "PCR196,Pad Configuration Register 196"
  bitfld.word 0x22 10.--12.       "PA , Pin assignment" "GPIO,EMIOS17,ETPUB01,EMIOS17,res.,res.,res.,res.      "
  bitfld.word 0x22 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x22 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x22 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x22 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x22 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x22 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x22 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x24 "PCR197,Pad Configuration Register 197"
  bitfld.word 0x24 10.--12.       "PA , Pin assignment" "GPIO,EMIOS18,ETPUB02,EMIOS18,res.,res.,res.,res.      "
  bitfld.word 0x24 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x24 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x24 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x24 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x24 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x24 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x24 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x26 "PCR198,Pad Configuration Register 198"
  bitfld.word 0x26 10.--12.       "PA , Pin assignment" "GPIO,EMIOS19,ETPUB03,EMIOS19,res.,res.,res.,res.      "
  bitfld.word 0x26 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x26 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x26 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x26 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x26 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x26 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x26 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x28 "PCR199,Pad Configuration Register 199"
  bitfld.word 0x28 10.--12.       "PA , Pin assignment" "GPIO,EMIOS20,ETPUB04,EMIOS20,res.,res.,res.,res.      "
  bitfld.word 0x28 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x28 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x28 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x28 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x28 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x28 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x28 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x2a "PCR200,Pad Configuration Register 200"
  bitfld.word 0x2a 10.--12.       "PA , Pin assignment" "GPIO,EMIOS21,ETPUB05,EMIOS21,res.,res.,res.,res.      "
  bitfld.word 0x2a 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x2a 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x2a 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x2a 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x2a 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x2a 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x2a 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x2c "PCR201,Pad Configuration Register 201"
  bitfld.word 0x2c 10.--12.       "PA , Pin assignment" "GPIO,EMIOS22,ETPUB06,EMIOS22,res.,res.,res.,res.      "
  bitfld.word 0x2c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x2c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x2c 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x2c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x2c 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x2c 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x2c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x2e "PCR202,Pad Configuration Register 202"
  bitfld.word 0x2e 10.--12.       "PA , Pin assignment" "GPIO,EMIOS23,ETPUB07,EMIOS23,res.,res.,res.,res.      "
  bitfld.word 0x2e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x2e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x2e 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x2e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x2e 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x2e 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x2e 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F901D6++0x09 "PCR203-207: GPIO / EMIOS[14:15]"
  line.word 0x00 "PCR203,Pad Configuration Register 203"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "EMIOS14,GPIO,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR204,Pad Configuration Register 204"
  bitfld.word 0x02 10.--12.       "PA , Pin assignment" "EMIOS15,GPIO,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x02 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x04 "PCR205,Pad Configuration Register 205"
  bitfld.word 0x04 10.--12.       "PA , Pin assignment" "GPIO,res.,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x04 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x04 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x04 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x04 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x04 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x04 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x04 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x06 "PCR206,Pad Configuration Register 206"
  bitfld.word 0x06 10.--12.       "PA , Pin assignment" "GPIO,res.,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x06 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x06 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x06 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x06 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x06 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x06 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x06 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x08 "PCR207,Pad Configuration Register 207"
  bitfld.word 0x08 10.--12.       "PA , Pin assignment" "GPIO,res.,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x08 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x08 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x08 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x08 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x08 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x08 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x08 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F901E0++0x03 "PCR208-209: PLLCFG[0:1] / IRQ[4:5] / SOUTD"
  line.word 0x00 "PCR208,Pad Configuration Register 208"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,PLLCFG0,IRQ04,PLLCFG0,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR209,Pad Configuration Register 209"
  bitfld.word 0x02 10.--12.       "PA , Pin assignment" "GPIO,PLLCFG1,IRQ05,PLLCFG1,SOUTD,res.,res.,res.      "
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x02 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F901E4++0x01 "PCR210: !RSCFG"
  line.word 0x00 "PCR210,Pad Configuration Register 210"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,!RSCFG,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F901E6++0x03 "PCR211-212: BOOTCFG[0:1] / IRQ[2:3]"
  line.word 0x00 "PCR211,Pad Configuration Register 211"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,BOOTCFG0,IRQ02,BOOTCFG0,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR212,Pad Configuration Register 212"
  bitfld.word 0x02 10.--12.       "PA , Pin assignment" "GPIO,BOOTCFG1,IRQ03,BOOTCFG0,res.,res.,res.,res.      "
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x02 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F901EA++0x01 "PCR213: WKPCFG"
  line.word 0x00 "PCR213,Pad Configuration Register 213"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,WKPCFG,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 05.            "            ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "min,med,res,max"
  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F901EC++0x01 "PCR214: ENGCLK"
  line.word 0x00 "PCR214,Pad Configuration Register 214"

; bitfld.word 0x00 10.--13.       "PA , Pin assignment" "   0,   1,   2,   3,   4,   5,   6,   7,   8,   9,   A,   B,   C,   D,   E,   F"
  bitfld.word 0x00 09.            "         OBE , Output buffer enable" "0,1"
; bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "         DSC , Drive strength control" "10pF,20pF,30pF,50pF"
; bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
; bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
; bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
; bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
; bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

group 0xC3F901EE++0x01 "PCR215: AN12 / MA0 / !SDS"
  line.word 0x00 "PCR215,Pad Configuration Register 215"

  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "!SDS,res.,MA0,AN12,res.,res.,res.,res.      "
;  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
;  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
; bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
;  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
;  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
;  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F901F0++0x01 "PCR216: AN13 / MA1 / SDO"
  line.word 0x00 "PCR216,Pad Configuration Register 216"

  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "SDO,res.,MA1,AN13,res.,res.,res.,res.      "
;  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
;  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
; bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
;  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
;  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
;  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F901F2++0x01 "PCR217: AN14 / MA2 / SDI"
  line.word 0x00 "PCR217,Pad Configuration Register 217"

  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "SDI,res.,MA2,AN14,res.,res.,res.,res.      "
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F901F4++0x01 "PCR218: AN15 / FCK"
  line.word 0x00 "PCR218,Pad Configuration Register 218"

  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "FCK,AN15,res.,res.,res.,res.,res.,res.      "
;  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
;  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
; bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
;  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
;  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
;  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F901F6++0x01 "PCR219: MCKO"
  line.word 0x00 "PCR219,Pad Configuration Register 219"

;  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "   0,   1,   2,   3,   4,   5,   6,   7,   8,   9,   A,   B,   C,   D,   E,   F"
;  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
;  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "                       DSC , Drive strength control" "10pF,20pF,30pF,50pF"
;  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
;  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
;  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
;  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
;  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

group 0xC3F901F8++0x09 "PCR220-223: MDO[0:3]"
  line.word 0x00 "PCR220,Pad Configuration Register 220"

;  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "   0,   1,   2,   3,   4,   5,   6,   7,   8,   9,   A,   B,   C,   D,   E,   F"
;  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
;  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "                       DSC , Drive strength control" "10pF,20pF,30pF,50pF"
;  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
;  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
;  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
;  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
;  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"
  line.word 0x02 "PCR221,Pad Configuration Register 221"

;  bitfld.word 0x02 10.--13.       "PA , Pin assignment" "   0,   1,   2,   3,   4,   5,   6,   7,   8,   9,   A,   B,   C,   D,   E,   F"
;  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
;  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 06.--07.       "                       DSC , Drive strength control" "10pF,20pF,30pF,50pF"
;  bitfld.word 0x02 05.            "  ODE , Open drain output enable" "0,1"
;  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
;  bitfld.word 0x02 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
;  bitfld.word 0x02 01.            "  WPE , Weak pull up/down enable" "0,1"
;  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"
  line.word 0x04 "PCR222,Pad Configuration Register 222"

;  bitfld.word 0x04 10.--13.       "PA , Pin assignment" "   0,   1,   2,   3,   4,   5,   6,   7,   8,   9,   A,   B,   C,   D,   E,   F"
;  bitfld.word 0x04 09.            "  OBE , Output buffer enable" "0,1"
;  bitfld.word 0x04 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x04 06.--07.       "                       DSC , Drive strength control" "10pF,20pF,30pF,50pF"
;  bitfld.word 0x04 05.            "  ODE , Open drain output enable" "0,1"
;  bitfld.word 0x04 04.            "  HYS , Input hysteresis" "0,1"
;  bitfld.word 0x04 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
;  bitfld.word 0x04 01.            "  WPE , Weak pull up/down enable" "0,1"
;  bitfld.word 0x04 00.            "  WPS , Weak pull up/down select" "0,1"
  line.word 0x06 "PCR223,Pad Configuration Register 223"

;  bitfld.word 0x06 10.--13.       "PA , Pin assignment" "   0,   1,   2,   3,   4,   5,   6,   7,   8,   9,   A,   B,   C,   D,   E,   F"
;  bitfld.word 0x06 09.            "  OBE , Output buffer enable" "0,1"
;  bitfld.word 0x06 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x06 06.--07.       "                       DSC , Drive strength control" "10pF,20pF,30pF,50pF"
;  bitfld.word 0x06 05.            "  ODE , Open drain output enable" "0,1"
;  bitfld.word 0x06 04.            "  HYS , Input hysteresis" "0,1"
;  bitfld.word 0x06 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
;  bitfld.word 0x06 01.            "  WPE , Weak pull up/down enable" "0,1"
;  bitfld.word 0x06 00.            "  WPS , Weak pull up/down select" "0,1"

group 0xC3F90200++0x03 "PCR224-225: !MSEO[0:1]"
  line.word 0x00 "PCR224,Pad Configuration Register 224"

;  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "   0,   1,   2,   3,   4,   5,   6,   7,   8,   9,   A,   B,   C,   D,   E,   F"
;  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
;  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "                       DSC , Drive strength control" "10pF,20pF,30pF,50pF"
;  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
;  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
;  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
;  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
;  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"
  line.word 0x02 "PCR225,Pad Configuration Register 225"

;  bitfld.word 0x02 10.--13.       "PA , Pin assignment" "   0,   1,   2,   3,   4,   5,   6,   7,   8,   9,   A,   B,   C,   D,   E,   F"
;  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
;  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 06.--07.       "                       DSC , Drive strength control" "10pF,20pF,30pF,50pF"
;  bitfld.word 0x02 05.            "  ODE , Open drain output enable" "0,1"
;  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
;  bitfld.word 0x02 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
;  bitfld.word 0x02 01.            "  WPE , Weak pull up/down enable" "0,1"
;  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"

group 0xC3F90204++0x01 "PCR226: !RDY"
  line.word 0x00 "PCR226,Pad Configuration Register 226"

;  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "   0,   1,   2,   3,   4,   5,   6,   7,   8,   9,   A,   B,   C,   D,   E,   F"
;  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
;  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "                       DSC , Drive strength control" "10pF,20pF,30pF,50pF"
;  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
;  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
;  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
;  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
;  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

group 0xC3F90206++0x01 "PCR227: !EVTO"
  line.word 0x00 "PCR227,Pad Configuration Register 227"

;  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "   0,   1,   2,   3,   4,   5,   6,   7,   8,   9,   A,   B,   C,   D,   E,   F"
;  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
;  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "                       DSC , Drive strength control" "10pF,20pF,30pF,50pF"
;  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
;  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
;  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
;  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
;  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

group 0xC3F90208++0x01 "PCR228: TDO"
  line.word 0x00 "PCR228,Pad Configuration Register 228"

;  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "   0,   1,   2,   3,   4,   5,   6,   7,   8,   9,   A,   B,   C,   D,   E,   F"
;  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
;  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "                       DSC , Drive strength control" "10pF,20pF,30pF,50pF"
;  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
;  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
;  bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
;  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
;  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

group 0xC3F9020A++0x01 "PCR229: !CLKOUT"
  line.word 0x00 "PCR229,Pad Configuration Register 229"

; bitfld.word 0x00 10.--13.       "PA , Pin assignment" "   0,   1,   2,   3,   4,   5,   6,   7,   8,   9,   A,   B,   C,   D,   E,   F"
  bitfld.word 0x00 09.            "         OBE , Output buffer enable" "0,1"
; bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "         DSC , Drive strength control" "10pF,20pF,30pF,50pF"
; bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
; bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
; bitfld.word 0x00 02.--03.       "  SRC , Slew rate control" "Min,Med,res,Max"
; bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
; bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

group 0xC3F9020C++0x01 "PCR230: !RSTOUT"
  line.word 0x00 "PCR230,Pad Configuration Register 230"

;  bitfld.word 0x00 10.--13.       "PA , Pin assignment" "   0,   1,   2,   3,   4,   5,   6,   7,   8,   9,   A,   B,   C,   D,   E,   F"
;  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
;  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
;  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
;  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
;  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 02.--03.       "                                               SRC , Slew rate control" "Min,Med,res,Max"
;  bitfld.word 0x00 01.            "  WPE , Weak pull up/down enable" "0,1"
;  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"
endif

sif (CPU()=="MPC5533")||(CPU()=="MPC5534")
group 0xC3F90040++0x07 "PCR000-PCR003: !CS[0:3] / ADDR[8:11]"
  line.word 0x00 "PCR000,Pad Configuration Register 000"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPI0,!CS0,ADDR08,!CS0,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR001,Pad Configuration Register 001"
  bitfld.word 0x02 10.--12.       "PA , Pin assignment" "GPI0,!CS1,ADDR09,!CS1,res.,res.,res.,res.      "
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x02 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x04 "PCR002,Pad Configuration Register 002"
  bitfld.word 0x04 10.--12.       "PA , Pin assignment" "GPI0,!CS2,ADDR10,!CS2,res.,res.,res.,res.      "
  bitfld.word 0x04 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x04 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x04 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x04 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x04 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x04 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x04 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x06 "PCR003,Pad Configuration Register 003"
  bitfld.word 0x06 10.--12.       "PA , Pin assignment" "GPI0,!CS3,ADDR11,!CS3,res.,res.,res.,res.      "
  bitfld.word 0x06 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x06 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x06 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x06 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x06 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x06 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x06 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90048++0x2f "PCR008-PCR011: ADDR[12:15]"
  line.word 0x08 "PCR008,Pad Configuration Register 008"
  bitfld.word 0x08 10.--12.       "PA , Pin assignment" "GPIO,ADDR12,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x08 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x08 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x08 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x08 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x08 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x08 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x08 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0a "PCR009,Pad Configuration Register 009"
  bitfld.word 0x0a 10.--12.       "PA , Pin assignment" "GPIO,ADDR13,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x0a 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0a 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0a 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x0a 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x0a 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0a 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0a 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0c "PCR010,Pad Configuration Register 010"
  bitfld.word 0x0c 10.--12.       "PA , Pin assignment" "GPIO,ADDR14,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x0c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0c 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x0c 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x0c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0c 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x0e "PCR011,Pad Configuration Register 011"
  bitfld.word 0x0e 10.--12.       "PA , Pin assignment" "GPIO,ADDR15,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x0e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x0e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x0e 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x0e 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x0e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x0e 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x0e 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90048++0x2f "PCR011-PCR027: ADDR[16:31]"
  line.word 0x10 "PCR012,Pad Configuration Register 012"
  bitfld.word 0x10 10.--12.       "PA , Pin assignment" "GPIO,ADDR16,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x10 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x10 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x10 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x10 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x10 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x10 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x10 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x12 "PCR013,Pad Configuration Register 013"
  bitfld.word 0x12 10.--12.       "PA , Pin assignment" "GPIO,ADDR17,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x12 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x12 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x12 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x12 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x12 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x12 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x12 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x14 "PCR014,Pad Configuration Register 014"
  bitfld.word 0x14 10.--12.       "PA , Pin assignment" "GPIO,ADDR18,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x14 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x14 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x14 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x14 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x14 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x14 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x14 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x16 "PCR015,Pad Configuration Register 015"
  bitfld.word 0x16 10.--12.       "PA , Pin assignment" "GPIO,ADDR19,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x16 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x16 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x16 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x16 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x16 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x16 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x16 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x18 "PCR016,Pad Configuration Register 016"
  bitfld.word 0x18 10.--12.       "PA , Pin assignment" "GPIO,ADDR20,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x18 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x18 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x18 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x18 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x18 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x18 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x18 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x1A "PCR017,Pad Configuration Register 017"
  bitfld.word 0x1A 10.--12.       "PA , Pin assignment" "GPIO,ADDR21,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x1A 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x1A 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x1A 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x1A 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x1A 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x1A 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x1A 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x1C "PCR018,Pad Configuration Register 018"
  bitfld.word 0x1C 10.--12.       "PA , Pin assignment" "GPIO,ADDR22,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x1C 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x1C 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x1C 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x1C 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x1C 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x1C 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x1C 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x1E "PCR019,Pad Configuration Register 019"
  bitfld.word 0x1E 10.--12.       "PA , Pin assignment" "GPIO,ADDR23,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x1E 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x1E 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x1E 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x1E 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x1E 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x1E 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x1E 00.            "  WPS , Weak pull up/down select" "0,1"

TEXTLINE ""
  line.word 0x20 "PCR020,Pad Configuration Register 020"
  bitfld.word 0x20 10.--12.       "PA , Pin assignment" "GPIO,ADDR24,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x20 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x20 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x20 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x20 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x20 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x20 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x20 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x22 "PCR021,Pad Configuration Register 021"
  bitfld.word 0x22 10.--12.       "PA , Pin assignment" "GPIO,ADDR25,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x22 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x22 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x22 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x22 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x22 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x22 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x22 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x24 "PCR022,Pad Configuration Register 022"
  bitfld.word 0x24 10.--12.       "PA , Pin assignment" "GPIO,ADDR26,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x24 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x24 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x24 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x24 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x24 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x24 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x24 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x26 "PCR023,Pad Configuration Register 023"
  bitfld.word 0x26 10.--12.       "PA , Pin assignment" "GPIO,ADDR27,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x26 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x26 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x26 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x26 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x26 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x26 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x26 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x28 "PCR024,Pad Configuration Register 024"
  bitfld.word 0x28 10.--12.       "PA , Pin assignment" "GPIO,ADDR28,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x28 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x28 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x28 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x28 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x28 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x28 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x28 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x2a "PCR025,Pad Configuration Register 025"
  bitfld.word 0x2a 10.--12.       "PA , Pin assignment" "GPIO,ADDR29,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x2a 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x2a 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x2a 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x2a 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x2a 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x2a 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x2a 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x2c "PCR026,Pad Configuration Register 026"
  bitfld.word 0x2c 10.--12.       "PA , Pin assignment" "GPIO,ADDR30,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x2c 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x2c 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x2c 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x2c 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x2c 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x2c 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x2c 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x2e "PCR027,Pad Configuration Register 027"
  bitfld.word 0x2e 10.--12.       "PA , Pin assignment" "GPIO,ADDR31,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x2e 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x2e 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x2e 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x2e 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x2e 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x2e 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x2e 00.            "  WPS , Weak pull up/down select" "0,1"


group 0xC3F90078++0x3f "PCR028-PCR043: DATA[0:15]"
  line.word 0x00 "PCR028,Pad Configuration Register 028"
  bitfld.word 0x00 10.--12.       "PA , Pin assignment" "GPIO,DATA00,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x00 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x00 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x00 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x00 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x00 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x00 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x00 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x02 "PCR029,Pad Configuration Register 029"
  bitfld.word 0x02 10.--12.       "PA , Pin assignment" "GPIO,DATA01,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x02 09.            "  OBE , Output buffer enable" "0,1"
  bitfld.word 0x02 08.            "  IBE , Input buffer enable" "0,1"
  bitfld.word 0x02 06.--07.       "  DSC , Drive strength control" "10pF,20pF,30pF,50pF"
  bitfld.word 0x02 05.            "  ODE , Open drain output enable" "0,1"
  bitfld.word 0x02 04.            "  HYS , Input hysteresis" "0,1"
  bitfld.word 0x02 01.            "           WPE , Weak pull up/down enable" "0,1"
  bitfld.word 0x02 00.            "  WPS , Weak pull up/down select" "0,1"

  line.word 0x04 "PCR030,Pad Configuration Register 030"
  bitfld.word 0x04 10.--12.       "PA , Pin assignment" "GPIO,DATA02,res.,res.,res.,res.,res.,res.      "
  bitfld.word 0x04 09.            "  OBE , Output buffer enable" "0,1"
