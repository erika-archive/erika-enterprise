  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(09.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(09.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(09.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(09.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(09.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(09.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(09.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(10.)*0x20)++0x1F
  TEXTLINE "Channel 10 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(10.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(10.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(10.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(10.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(10.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(10.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(10.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(10.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(10.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(10.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(10.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(10.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(10.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(11.)*0x20)++0x1F
  TEXTLINE "Channel 11 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(11.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(11.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(11.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(11.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(11.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(11.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(11.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(11.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(11.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(11.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(11.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(11.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(11.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(12.)*0x20)++0x1F
  TEXTLINE "Channel 12 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(12.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(12.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(12.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(12.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(12.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(12.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(12.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(12.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(12.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(12.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(12.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(12.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(12.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(13.)*0x20)++0x1F
  TEXTLINE "Channel 13 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(13.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(13.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(13.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(13.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(13.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(13.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(13.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(13.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(13.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(13.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(13.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(13.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(13.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(14.)*0x20)++0x1F
  TEXTLINE "Channel 14 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(14.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(14.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(14.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(14.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(14.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(14.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(14.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(14.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(14.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(14.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(14.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(14.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(14.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(15.)*0x20)++0x1F
  TEXTLINE "Channel 15 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(15.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(15.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(15.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(15.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(15.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(15.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(15.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(15.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(15.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(15.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(15.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(15.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(15.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(16.)*0x20)++0x1F
  TEXTLINE "Channel 16 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(16.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(16.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(16.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(16.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(16.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(16.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(16.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(16.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(16.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(16.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(16.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(16.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(16.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(17.)*0x20)++0x1F
  TEXTLINE "Channel 17 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(17.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(17.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(17.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(17.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(17.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(17.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(17.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(17.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(17.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(17.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(17.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(17.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(17.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(18.)*0x20)++0x1F
  TEXTLINE "Channel 18 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(18.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(18.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(18.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(18.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(18.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(18.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(18.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(18.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(18.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(18.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(18.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(18.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(18.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(19.)*0x20)++0x1F
  TEXTLINE "Channel 19 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(19.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(19.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(19.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(19.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(19.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(19.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(19.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(19.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(19.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(19.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(19.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(19.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(19.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(20.)*0x20)++0x1F
  TEXTLINE "Channel 20 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(20.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(20.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(20.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(20.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(20.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(20.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(20.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(20.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(20.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(20.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(20.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(20.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(20.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(21.)*0x20)++0x1F
  TEXTLINE "Channel 21 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(21.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(21.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(21.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(21.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(21.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(21.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(21.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(21.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(21.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(21.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(21.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(21.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(21.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(22.)*0x20)++0x1F
  TEXTLINE "Channel 22 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(22.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(22.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(22.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(22.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(22.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(22.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(22.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(22.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(22.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(22.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(22.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(22.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(22.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(23.)*0x20)++0x1F
  TEXTLINE "Channel 23 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(23.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(23.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(23.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(23.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(23.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(23.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(23.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(23.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(23.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(23.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(23.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(23.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(23.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(24.)*0x20)++0x1F
  TEXTLINE "Channel 24 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(24.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(24.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(24.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(24.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(24.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(24.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(24.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(24.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(24.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(24.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(24.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(24.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(24.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(25.)*0x20)++0x1F
  TEXTLINE "Channel 25 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(25.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(25.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(25.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(25.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(25.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(25.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(25.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(25.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(25.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(25.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(25.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(25.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(25.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(26.)*0x20)++0x1F
  TEXTLINE "Channel 26 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(26.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(26.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(26.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(26.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(26.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(26.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(26.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(26.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(26.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(26.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(26.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(26.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(26.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(27.)*0x20)++0x1F
  TEXTLINE "Channel 27 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(27.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(27.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(27.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(27.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(27.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(27.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(27.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(27.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(27.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(27.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(27.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(27.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(27.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(28.)*0x20)++0x1F
  TEXTLINE "Channel 28 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(28.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(28.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(28.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(28.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(28.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(28.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(28.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(28.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(28.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(28.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(28.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(28.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(28.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(29.)*0x20)++0x1F
  TEXTLINE "Channel 29 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(29.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(29.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(29.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(29.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(29.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(29.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(29.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(29.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(29.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(29.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(29.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(29.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(29.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(30.)*0x20)++0x1F
  TEXTLINE "Channel 30 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(30.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(30.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(30.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(30.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(30.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(30.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(30.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(30.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(30.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(30.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(30.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(30.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(30.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(31.)*0x20)++0x1F
  TEXTLINE "Channel 31 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(31.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(31.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(31.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(31.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(31.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(31.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(31.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(31.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(31.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(31.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(31.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(31.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(31.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(32.)*0x20)++0x1F
  TEXTLINE "Channel 32 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(32.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(32.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(32.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(32.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(32.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(32.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(32.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(32.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(32.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(32.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(32.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(32.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(32.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(33.)*0x20)++0x1F
  TEXTLINE "Channel 33 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(33.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(33.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(33.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(33.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(33.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(33.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(33.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(33.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(33.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(33.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(33.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(33.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(33.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(34.)*0x20)++0x1F
  TEXTLINE "Channel 34 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(34.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(34.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(34.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(34.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(34.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(34.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(34.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(34.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(34.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(34.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(34.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(34.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(34.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(35.)*0x20)++0x1F
  TEXTLINE "Channel 35 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(35.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(35.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(35.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(35.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(35.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(35.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(35.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(35.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(35.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(35.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(35.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(35.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(35.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(36.)*0x20)++0x1F
  TEXTLINE "Channel 36 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(36.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(36.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(36.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(36.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(36.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(36.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(36.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(36.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(36.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(36.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(36.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(36.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(36.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(37.)*0x20)++0x1F
  TEXTLINE "Channel 37 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(37.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(37.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(37.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(37.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(37.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(37.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(37.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(37.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(37.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(37.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(37.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(37.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(37.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(38.)*0x20)++0x1F
  TEXTLINE "Channel 38 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(38.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(38.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(38.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(38.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(38.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(38.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(38.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(38.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(38.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(38.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(38.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(38.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(38.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(39.)*0x20)++0x1F
  TEXTLINE "Channel 39 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(39.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(39.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(39.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(39.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(39.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(39.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(39.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(39.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(39.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(39.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(39.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(39.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(39.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(40.)*0x20)++0x1F
  TEXTLINE "Channel 40 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(40.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(40.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(40.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(40.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(40.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(40.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(40.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(40.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(40.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(40.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(40.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(40.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(40.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(41.)*0x20)++0x1F
  TEXTLINE "Channel 41 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(41.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(41.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(41.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(41.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(41.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(41.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(41.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(41.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(41.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(41.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(41.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(41.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(41.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(42.)*0x20)++0x1F
  TEXTLINE "Channel 42 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(42.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(42.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(42.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(42.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(42.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(42.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(42.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(42.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(42.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(42.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(42.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(42.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(42.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(43.)*0x20)++0x1F
  TEXTLINE "Channel 43 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(43.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(43.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(43.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(43.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(43.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(43.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(43.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(43.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(43.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(43.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(43.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(43.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(43.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(44.)*0x20)++0x1F
  TEXTLINE "Channel 44 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(44.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(44.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(44.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(44.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(44.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(44.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(44.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(44.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(44.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(44.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(44.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(44.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(44.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(45.)*0x20)++0x1F
  TEXTLINE "Channel 45 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(45.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(45.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(45.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(45.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(45.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(45.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(45.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(45.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(45.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(45.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(45.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(45.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(45.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(46.)*0x20)++0x1F
  TEXTLINE "Channel 46 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(46.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(46.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(46.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(46.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(46.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(46.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(46.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(46.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(46.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(46.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(46.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(46.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(46.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(47.)*0x20)++0x1F
  TEXTLINE "Channel 47 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(47.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(47.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(47.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(47.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(47.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(47.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(47.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(47.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(47.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(47.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(47.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(47.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(47.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(48.)*0x20)++0x1F
  TEXTLINE "Channel 48 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(48.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(48.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(48.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(48.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(48.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(48.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(48.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(48.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(48.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(48.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(48.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(48.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(48.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(49.)*0x20)++0x1F
  TEXTLINE "Channel 49 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(49.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(49.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(49.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(49.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(49.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(49.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(49.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(49.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(49.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(49.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(49.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(49.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(49.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(50.)*0x20)++0x1F
  TEXTLINE "Channel 50 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(50.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(50.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(50.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(50.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(50.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(50.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(50.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(50.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(50.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(50.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(50.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(50.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(50.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(51.)*0x20)++0x1F
  TEXTLINE "Channel 51 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(51.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(51.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(51.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(51.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(51.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(51.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(51.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(51.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(51.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(51.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(51.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(51.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(51.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(52.)*0x20)++0x1F
  TEXTLINE "Channel 52 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(52.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(52.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(52.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(52.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(52.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(52.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(52.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(52.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(52.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(52.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(52.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(52.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(52.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(53.)*0x20)++0x1F
  TEXTLINE "Channel 53 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(53.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(53.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(53.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(53.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(53.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(53.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(53.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(53.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(53.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(53.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(53.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(53.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(53.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(54.)*0x20)++0x1F
  TEXTLINE "Channel 54 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(54.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(54.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(54.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(54.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(54.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(54.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(54.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(54.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(54.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(54.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(54.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(54.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(54.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(55.)*0x20)++0x1F
  TEXTLINE "Channel 55 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(55.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(55.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(55.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(55.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(55.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(55.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(55.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(55.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(55.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(55.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(55.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(55.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(55.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(56.)*0x20)++0x1F
  TEXTLINE "Channel 56 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(56.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(56.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(56.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(56.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(56.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(56.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(56.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(56.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(56.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(56.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(56.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(56.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(56.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(57.)*0x20)++0x1F
  TEXTLINE "Channel 57 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(57.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(57.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(57.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(57.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(57.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(57.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(57.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(57.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(57.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(57.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(57.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(57.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(57.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(58.)*0x20)++0x1F
  TEXTLINE "Channel 58 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(58.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(58.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(58.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(58.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(58.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(58.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(58.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(58.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(58.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(58.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(58.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(58.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(58.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(59.)*0x20)++0x1F
  TEXTLINE "Channel 59 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(59.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(59.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(59.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(59.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(59.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(59.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(59.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(59.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(59.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(59.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(59.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(59.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(59.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(60.)*0x20)++0x1F
  TEXTLINE "Channel 60 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(60.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(60.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(60.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(60.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(60.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(60.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(60.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(60.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(60.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(60.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(60.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(60.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(60.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(61.)*0x20)++0x1F
  TEXTLINE "Channel 61 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(61.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(61.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(61.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(61.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(61.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(61.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(61.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(61.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(61.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(61.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(61.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(61.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(61.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(62.)*0x20)++0x1F
  TEXTLINE "Channel 62 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(62.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(62.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(62.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(62.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(62.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(62.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(62.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(62.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(62.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(62.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(62.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(62.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(62.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(63.)*0x20)++0x1F
  TEXTLINE "Channel 63 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(63.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(63.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(63.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(63.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(63.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(63.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(63.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(63.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(63.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(63.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(63.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(63.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(63.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif




tree.end
  
tree.end
endif

sif ((cpu()=="MPC5533")||(cpu()=="MPC5534")||(cpu()=="MPC5553")||(cpu()=="MPC5561")||(cpu()=="MPC5565")||(cpu()=="MPC5567")||(cpu()=="MPC5633M")||(cpu()=="MPC5634M")||(cpu()=="SPC563M60")||(cpu()=="SPC563M64"))
tree "Enhanced Direct Memory Access (eDMA)  "

if data.word(anc:0xc3f90004)==0x5561

 group.long (0xfff44000+0x0000)++0x03
   line.long 0x00 "CR,eDMA Control Register"
   bitfld.long  0x00 17.                     "CX      ,Cancel the remaining data transfer" "0,1"
   bitfld.long  0x00 16.                   "  EX      ,Error cancel transfer" "0,1"
   bitfld.long  0x00 10.                   "  GRP1PRI ,Channel group 1 priority" "0,1"
   bitfld.long  0x00 08.                   "  GRP0PRI ,Channel group 0 priority" "0,1"
   TEXTLINE "                "
   bitfld.long  0x00 07.                   "  EMLM    ,Enable minor loop mapping" "0,1"
   bitfld.long  0x00 06.                   "  CLM     ,Continuous link mode" "0,1"
   bitfld.long  0x00 05.                   "  HALT    ,Halt DMA operations" "0,1"
   bitfld.long  0x00 04.                   "  HOE     ,Halt on error" "0,1"
   TEXTLINE "                "
   bitfld.long  0x00 03.                   "  ERGA    ,Enable round robin group arbitration" "0,1"
   bitfld.long  0x00 02.                   "  ERCA    ,Enable round robin channel arbitration" "0,1"
   bitfld.long  0x00 01.                   "  EDBG    ,Enable debug" "0,1"

 TEXTLINE ""

 group.long (0xfff44000+0x0004)++0x03
   line.long 0x00 "ESR,eDMA Error Status Register"
   bitfld.long  0x00 31.                "VLD ,Logical OR of all EDMA_ERRH and EDMA_ERRL status bits" "0,1"
   bitfld.long  0x00 16.              "  ECX ,Transfer canceled" "0,1"
   bitfld.long  0x00 15.              "  GPE ,Group priority error" "0,1"
   bitfld.long  0x00 14.              "  CPE ,Channel priority error" "0,1"
   hexmask.long.byte 0x00 08.--13.  1. "  ERRCHN ,Error channel number"
   TEXTLINE "                "
   bitfld.long  0x00 07.              "  SAE ,Source address error" "0,1"
   bitfld.long  0x00 06.              "  SOE ,Source offset error" "0,1"
   bitfld.long  0x00 05.              "  DAE ,Destination address error" "0,1"
   bitfld.long  0x00 04.              "  DOE ,Destination offset error" "0,1"
   bitfld.long  0x00 03.              "  NCE ,Nbytes/CITER configuration error" "0,1"
   bitfld.long  0x00 02.              "  SGE ,Scatter/gather configuration error" "0,1"
   bitfld.long  0x00 01.              "  SBE ,Source bus error" "0,1"
   bitfld.long  0x00 00.              "  DBE ,Destination bus error" "0,1"

else

 group.long (0xfff44000+0x0000)++0x03
   line.long 0x00 "CR,eDMA Control Register"
   bitfld.long  0x00 10.--11.                "GRP1PRI ,Channel group 1 priority." "0,1,2,3"
   bitfld.long  0x00 08.--09.              "  GRP0PRI ,Channel group 0 priority." "0,1,2,3"
   bitfld.long  0x00 03.                   "  ERGA    ,Enable round robin group arbitration" "0,1"
   bitfld.long  0x00 02.                   "  ERCA    ,Enable round robin channel arbitration" "0,1"
   bitfld.long  0x00 01.                   "  EDBG    ,Enable debug" "0,1"

 TEXTLINE ""

 group.long (0xfff44000+0x0004)++0x03
   line.long 0x00 "ESR,eDMA Error Status Register"
   bitfld.long  0x00 31.                "VLD ,Logical OR of all EDMA_ERRH and EDMA_ERRL status bits" "0,1"
   bitfld.long  0x00 15.              "  GPE ,Group priority error" "0,1"
   bitfld.long  0x00 14.              "  CPE ,Channel priority error" "0,1"
   hexmask.long.byte 0x00 08.--13.  1.     "  ERRCHN ,Error channel number"
   TEXTLINE "                "
   bitfld.long  0x00 07.              "  SAE ,Source address error" "0,1"
   bitfld.long  0x00 06.              "  SOE ,Source offset error" "0,1"
   bitfld.long  0x00 05.              "  DAE ,Destination address error" "0,1"
   bitfld.long  0x00 04.              "  DOE ,Destination offset error" "0,1"
   bitfld.long  0x00 03.              "  NCE ,Nbytes/CITER configuration error" "0,1"
   bitfld.long  0x00 02.              "  SGE ,Scatter/gather configuration error" "0,1"
   bitfld.long  0x00 01.              "  SBE ,Source bus error" "0,1"
   bitfld.long  0x00 00.              "  DBE ,Destination bus error" "0,1"

endif
  
TEXTLINE ""
    
group.long (0xfff44000+0x000C)++0x03
  line.long 0x00 "ERQRL,eDMA Enable Request Register L"
  bitfld.long  0x00 31.              "ERQ31-28 ,Enable DMA Request 31" "0,1"
  bitfld.long  0x00 30.              ",Enable DMA Request 30" "0,1"
  bitfld.long  0x00 29.              ",Enable DMA Request 29" "0,1"
  bitfld.long  0x00 28.              ",Enable DMA Request 28" "0,1"
  
  bitfld.long  0x00 27.              "  ERQ27-24 ,Enable DMA Request 27" "0,1"
  bitfld.long  0x00 26.              ",Enable DMA Request 26" "0,1"
  bitfld.long  0x00 25.              ",Enable DMA Request 25" "0,1"
  bitfld.long  0x00 24.              ",Enable DMA Request 24" "0,1"
  
  bitfld.long  0x00 23.              "  ERQ23-20 ,Enable DMA Request 23" "0,1"
  bitfld.long  0x00 22.              ",Enable DMA Request 22" "0,1"
  bitfld.long  0x00 21.              ",Enable DMA Request 21" "0,1"
  bitfld.long  0x00 20.              ",Enable DMA Request 20" "0,1"
  
  bitfld.long  0x00 19.              "  ERQ19-16 ,Enable DMA Request 19" "0,1"
  bitfld.long  0x00 18.              ",Enable DMA Request 18" "0,1"
  bitfld.long  0x00 17.              ",Enable DMA Request 17" "0,1"
  bitfld.long  0x00 16.              ",Enable DMA Request 16" "0,1"
  TEXTLINE "                  "
  bitfld.long  0x00 15.              "ERQ15-12 ,Enable DMA Request 15" "0,1"
  bitfld.long  0x00 14.              ",Enable DMA Request 14" "0,1"
  bitfld.long  0x00 13.              ",Enable DMA Request 13" "0,1"
  bitfld.long  0x00 12.              ",Enable DMA Request 12" "0,1"
  
  bitfld.long  0x00 11.              "  ERQ11-08 ,Enable DMA Request 11" "0,1"
  bitfld.long  0x00 10.              ",Enable DMA Request 10" "0,1"
  bitfld.long  0x00 09.              ",Enable DMA Request 09" "0,1"
  bitfld.long  0x00 08.              ",Enable DMA Request 08" "0,1"
  
  bitfld.long  0x00 07.              "  ERQ07-04 ,Enable DMA Request 07" "0,1"
  bitfld.long  0x00 06.              ",Enable DMA Request 06" "0,1"
  bitfld.long  0x00 05.              ",Enable DMA Request 05" "0,1"
  bitfld.long  0x00 04.              ",Enable DMA Request 04" "0,1"
  
  bitfld.long  0x00 03.              "  ERQ03-00 ,Enable DMA Request 03" "0,1"
  bitfld.long  0x00 02.              ",Enable DMA Request 02" "0,1"
  bitfld.long  0x00 01.              ",Enable DMA Request 01" "0,1"
  bitfld.long  0x00 00.              ",Enable DMA Request 00" "0,1"

  
TEXTLINE ""
  
group.long (0xfff44000+0x0014)++0x03
  line.long 0x00 "EEIRL,eDMA Enable Error Interrupt Register L"
  bitfld.long  0x00 31.              "EEI31-28 ,Enable error interrupt 31" "0,1"
  bitfld.long  0x00 30.              ",Enable error interrupt 30" "0,1"
  bitfld.long  0x00 29.              ",Enable error interrupt 29" "0,1"
  bitfld.long  0x00 28.              ",Enable error interrupt 28" "0,1"
  
  bitfld.long  0x00 27.              "  EEI27-24 ,Enable error interrupt 27" "0,1"
  bitfld.long  0x00 26.              ",Enable error interrupt 26" "0,1"
  bitfld.long  0x00 25.              ",Enable error interrupt 25" "0,1"
  bitfld.long  0x00 24.              ",Enable error interrupt 24" "0,1"
  
  bitfld.long  0x00 23.              "  EEI23-20 ,Enable error interrupt 23" "0,1"
  bitfld.long  0x00 22.              ",Enable error interrupt 22" "0,1"
  bitfld.long  0x00 21.              ",Enable error interrupt 21" "0,1"
  bitfld.long  0x00 20.              ",Enable error interrupt 20" "0,1"
  
  bitfld.long  0x00 19.              "  EEI19-16 ,Enable error interrupt 19" "0,1"
  bitfld.long  0x00 18.              ",Enable error interrupt 18" "0,1"
  bitfld.long  0x00 17.              ",Enable error interrupt 17" "0,1"
  bitfld.long  0x00 16.              ",Enable error interrupt 16" "0,1"
  TEXTLINE "                  "
  bitfld.long  0x00 15.              "EEI15-12 ,Enable error interrupt 15" "0,1"
  bitfld.long  0x00 14.              ",Enable error interrupt 14" "0,1"
  bitfld.long  0x00 13.              ",Enable error interrupt 13" "0,1"
  bitfld.long  0x00 12.              ",Enable error interrupt 12" "0,1"
  
  bitfld.long  0x00 11.              "  EEI11-08 ,Enable error interrupt 11" "0,1"
  bitfld.long  0x00 10.              ",Enable error interrupt 10" "0,1"
  bitfld.long  0x00 09.              ",Enable error interrupt 09" "0,1"
  bitfld.long  0x00 08.              ",Enable error interrupt 08" "0,1"
  
  bitfld.long  0x00 07.              "  EEI07-04 ,Enable error interrupt 07" "0,1"
  bitfld.long  0x00 06.              ",Enable error interrupt 06" "0,1"
  bitfld.long  0x00 05.              ",Enable error interrupt 05" "0,1"
  bitfld.long  0x00 04.              ",Enable error interrupt 04" "0,1"
  
  bitfld.long  0x00 03.              "  EEI03-00 ,Enable error interrupt 03" "0,1"
  bitfld.long  0x00 02.              ",Enable error interrupt 02" "0,1"
  bitfld.long  0x00 01.              ",Enable error interrupt 01" "0,1"
  bitfld.long  0x00 00.              ",Enable error interrupt 00" "0,1"

TEXTLINE ""

group.byte (0xfff44000+0x0018)++0x03
  line.byte 0x00 "SERQR,eDMA Set Enable Request Register"
  hexmask.byte 0x00 00.--06.  1.     "    SERQ ,Set Enable Request"
  
group.byte (0xfff44000+0x0019)++0x03
  line.byte 0x00 "CERQR,eDMA Clear Enable Request Register"
  hexmask.byte 0x00 00.--06.  1.     "    CERQ ,Clear Enable Request"
  
group.byte (0xfff44000+0x001A)++0x03
  line.byte 0x00 "SEEIR,eDMA Set Enable Error Interrupt Register"
  hexmask.byte 0x00 00.--06.  1.     "    SEEI ,Set enable error interrupt"
  
group.byte (0xfff44000+0x001B)++0x03
  line.byte 0x00 "CEEIR,eDMA Clear Enable Error Interrupt Register"
  hexmask.byte 0x00 00.--06.  1.     "    CEEI ,eDMA Clear Enable Error Interrupt Register"
  
group.byte (0xfff44000+0x001C)++0x03
  line.byte 0x00 "CIRQR,eDMA Clear Interrupt Request Register"
  hexmask.byte 0x00 00.--06.  1.     "    CINT ,Clear interrupt request"
  
wgroup.byte (0xfff44000+0x001D)++0x03
  line.byte 0x00 "CER,eDMA Clear Error Register"
;  hexmask.byte 0x00 00.--06.  1.     "    CERR ,Clear error indicator"
  
wgroup.byte (0xfff44000+0x001E)++0x03
  line.byte 0x00 "SSBR,eDMA Set START Bit Register"
;  hexmask.byte 0x00 00.--06.  1.     "    SSB  ,Set START bit"
  
wgroup.byte (0xfff44000+0x001F)++0x03
  line.byte 0x00 "CDSBR,eDMA Clear DONE Status Bit Register"
;  hexmask.byte 0x00 00.--06.  1.     "    CDSB ,Clear DONE status bit"
  
  
TEXTLINE ""
    
group.long (0xfff44000+0x0024)++0x03
  line.long 0x00 "IRQRL,eDMA Interrupt Request Register L"
  bitfld.long  0x00 31.              "INT31-28 ,eDMA interrupt request 31" "0,1"
  bitfld.long  0x00 30.              ",eDMA interrupt request 30" "0,1"
  bitfld.long  0x00 29.              ",eDMA interrupt request 29" "0,1"
  bitfld.long  0x00 28.              ",eDMA interrupt request 28" "0,1"
  
  bitfld.long  0x00 27.              "  INT27-24 ,eDMA interrupt request 27" "0,1"
  bitfld.long  0x00 26.              ",eDMA interrupt request 26" "0,1"
  bitfld.long  0x00 25.              ",eDMA interrupt request 25" "0,1"
  bitfld.long  0x00 24.              ",eDMA interrupt request 24" "0,1"
  
  bitfld.long  0x00 23.              "  INT23-20 ,eDMA interrupt request 23" "0,1"
  bitfld.long  0x00 22.              ",eDMA interrupt request 22" "0,1"
  bitfld.long  0x00 21.              ",eDMA interrupt request 21" "0,1"
  bitfld.long  0x00 20.              ",eDMA interrupt request 20" "0,1"
  
  bitfld.long  0x00 19.              "  INT19-16 ,eDMA interrupt request 19" "0,1"
  bitfld.long  0x00 18.              ",eDMA interrupt request 18" "0,1"
  bitfld.long  0x00 17.              ",eDMA interrupt request 17" "0,1"
  bitfld.long  0x00 16.              ",eDMA interrupt request 16" "0,1"
  TEXTLINE "                  "
  bitfld.long  0x00 15.              "INT15-12 ,eDMA interrupt request 15" "0,1"
  bitfld.long  0x00 14.              ",eDMA interrupt request 14" "0,1"
  bitfld.long  0x00 13.              ",eDMA interrupt request 13" "0,1"
  bitfld.long  0x00 12.              ",eDMA interrupt request 12" "0,1"
  
  bitfld.long  0x00 11.              "  INT11-08 ,eDMA interrupt request 11" "0,1"
  bitfld.long  0x00 10.              ",eDMA interrupt request 10" "0,1"
  bitfld.long  0x00 09.              ",eDMA interrupt request 09" "0,1"
  bitfld.long  0x00 08.              ",eDMA interrupt request 08" "0,1"
  
  bitfld.long  0x00 07.              "  INT07-04 ,eDMA interrupt request 07" "0,1"
  bitfld.long  0x00 06.              ",eDMA interrupt request 06" "0,1"
  bitfld.long  0x00 05.              ",eDMA interrupt request 05" "0,1"
  bitfld.long  0x00 04.              ",eDMA interrupt request 04" "0,1"
  
  bitfld.long  0x00 03.              "  INT03-00 ,eDMA interrupt request 03" "0,1"
  bitfld.long  0x00 02.              ",eDMA interrupt request 02" "0,1"
  bitfld.long  0x00 01.              ",eDMA interrupt request 01" "0,1"
  bitfld.long  0x00 00.              ",eDMA interrupt request 00" "0,1"


TEXTLINE ""
    
group.long (0xfff44000+0x002C)++0x03
  line.long 0x00 "ERL,eDMA Error Register L"
  bitfld.long  0x00 31.              "ERR31-28 ,eDMA Error 31" "0,1"
  bitfld.long  0x00 30.              ",eDMA Error 30" "0,1"
  bitfld.long  0x00 29.              ",eDMA Error 29" "0,1"
  bitfld.long  0x00 28.              ",eDMA Error 28" "0,1"
  
  bitfld.long  0x00 27.              "  ERR27-24 ,eDMA Error 27" "0,1"
  bitfld.long  0x00 26.              ",eDMA Error 26" "0,1"
  bitfld.long  0x00 25.              ",eDMA Error 25" "0,1"
  bitfld.long  0x00 24.              ",eDMA Error 24" "0,1"
  
  bitfld.long  0x00 23.              "  ERR23-20 ,eDMA Error 23" "0,1"
  bitfld.long  0x00 22.              ",eDMA Error 22" "0,1"
  bitfld.long  0x00 21.              ",eDMA Error 21" "0,1"
  bitfld.long  0x00 20.              ",eDMA Error 20" "0,1"
  
  bitfld.long  0x00 19.              "  ERR19-16 ,eDMA Error 19" "0,1"
  bitfld.long  0x00 18.              ",eDMA Error 18" "0,1"
  bitfld.long  0x00 17.              ",eDMA Error 17" "0,1"
  bitfld.long  0x00 16.              ",eDMA Error 16" "0,1"
  TEXTLINE "                  "
  bitfld.long  0x00 15.              "ERR15-12 ,eDMA Error 15" "0,1"
  bitfld.long  0x00 14.              ",eDMA Error 14" "0,1"
  bitfld.long  0x00 13.              ",eDMA Error 13" "0,1"
  bitfld.long  0x00 12.              ",eDMA Error 12" "0,1"
  
  bitfld.long  0x00 11.              "  ERR11-08 ,eDMA Error 11" "0,1"
  bitfld.long  0x00 10.              ",eDMA Error 10" "0,1"
  bitfld.long  0x00 09.              ",eDMA Error 09" "0,1"
  bitfld.long  0x00 08.              ",eDMA Error 08" "0,1"
  
  bitfld.long  0x00 07.              "  ERR07-04 ,eDMA Error 07" "0,1"
  bitfld.long  0x00 06.              ",eDMA Error 06" "0,1"
  bitfld.long  0x00 05.              ",eDMA Error 05" "0,1"
  bitfld.long  0x00 04.              ",eDMA Error 04" "0,1"
  
  bitfld.long  0x00 03.              "  ERR03-00 ,eDMA Error 03" "0,1"
  bitfld.long  0x00 02.              ",eDMA Error 02" "0,1"
  bitfld.long  0x00 01.              ",eDMA Error 01" "0,1"
  bitfld.long  0x00 00.              ",eDMA Error 00" "0,1"

tree "eDMA Channel Priority Registers"
group.byte (0xfff44000+0x100+00.)++0x00
  line.byte    0x00 "CPR00,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 00 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 00 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 00 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+01.)++0x00
  line.byte    0x00 "CPR01,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 01 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 01 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 01 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+02.)++0x00
  line.byte    0x00 "CPR02,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 02 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 02 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 02 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+03.)++0x00
  line.byte    0x00 "CPR03,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 03 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 03 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 03 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+04.)++0x00
  line.byte    0x00 "CPR04,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 04 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 04 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 04 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+05.)++0x00
  line.byte    0x00 "CPR05,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 05 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 05 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 05 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+06.)++0x00
  line.byte    0x00 "CPR06,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 06 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 06 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 06 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+07.)++0x00
  line.byte    0x00 "CPR07,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 07 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 07 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 07 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+08.)++0x00
  line.byte    0x00 "CPR08,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 08 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 08 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 08 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+09.)++0x00
  line.byte    0x00 "CPR09,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 09 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 09 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 09 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+10.)++0x00
  line.byte    0x00 "CPR10,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 10 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 10 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 10 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+11.)++0x00
  line.byte    0x00 "CPR11,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 11 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 11 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 11 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+12.)++0x00
  line.byte    0x00 "CPR12,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 12 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 12 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 12 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+13.)++0x00
  line.byte    0x00 "CPR13,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 13 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 13 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 13 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+14.)++0x00
  line.byte    0x00 "CPR14,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 14 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 14 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 14 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+15.)++0x00
  line.byte    0x00 "CPR15,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 15 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 15 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 15 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+16.)++0x00
  line.byte    0x00 "CPR16,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 16 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 16 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 16 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+17.)++0x00
  line.byte    0x00 "CPR17,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 17 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 17 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 17 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+18.)++0x00
  line.byte    0x00 "CPR18,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 18 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 18 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 18 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+19.)++0x00
  line.byte    0x00 "CPR19,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 19 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 19 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 19 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+20.)++0x00
  line.byte    0x00 "CPR20,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 20 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 20 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 20 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+21.)++0x00
  line.byte    0x00 "CPR21,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 21 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 21 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 21 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+22.)++0x00
  line.byte    0x00 "CPR22,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 22 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 22 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 22 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+23.)++0x00
  line.byte    0x00 "CPR23,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 23 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 23 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 23 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+24.)++0x00
  line.byte    0x00 "CPR24,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 24 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 24 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 24 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+25.)++0x00
  line.byte    0x00 "CPR25,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 25 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 25 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 25 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+26.)++0x00
  line.byte    0x00 "CPR26,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 26 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 26 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 26 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+27.)++0x00
  line.byte    0x00 "CPR27,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 27 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 27 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 27 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+28.)++0x00
  line.byte    0x00 "CPR28,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 28 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 28 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 28 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+29.)++0x00
  line.byte    0x00 "CPR29,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 29 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 29 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 29 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+30.)++0x00
  line.byte    0x00 "CPR30,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 30 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 30 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 30 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+31.)++0x00
  line.byte    0x00 "CPR31,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 31 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 31 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 31 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
tree.end

tree "eDMA Transfer Control Descriptors"
group.long (0xfff44000+0x1000+(00.)*0x20)++0x1F
  TEXTLINE "Channel 00 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(00.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(00.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(00.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(00.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(00.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(00.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(00.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(00.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(00.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(00.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(00.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(00.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(00.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(01.)*0x20)++0x1F
  TEXTLINE "Channel 01 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(01.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(01.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(01.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(01.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(01.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(01.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(01.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(01.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(01.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(01.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(01.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(01.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(01.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(02.)*0x20)++0x1F
  TEXTLINE "Channel 02 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(02.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(02.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(02.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(02.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(02.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(02.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(02.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(02.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(02.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(02.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(02.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(02.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(02.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(03.)*0x20)++0x1F
  TEXTLINE "Channel 03 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(03.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(03.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(03.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(03.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(03.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(03.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(03.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(03.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(03.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(03.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(03.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(03.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(03.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(04.)*0x20)++0x1F
  TEXTLINE "Channel 04 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(04.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(04.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(04.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(04.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(04.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(04.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(04.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(04.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(04.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(04.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(04.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(04.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(04.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(05.)*0x20)++0x1F
  TEXTLINE "Channel 05 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(05.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(05.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(05.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(05.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(05.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(05.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(05.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(05.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(05.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(05.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(05.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(05.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(05.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(06.)*0x20)++0x1F
  TEXTLINE "Channel 06 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(06.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(06.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(06.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(06.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(06.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(06.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(06.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(06.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(06.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(06.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(06.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(06.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(06.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(07.)*0x20)++0x1F
  TEXTLINE "Channel 07 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(07.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(07.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(07.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(07.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(07.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(07.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(07.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(07.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(07.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(07.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(07.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(07.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(07.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(08.)*0x20)++0x1F
  TEXTLINE "Channel 08 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(08.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(08.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(08.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(08.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(08.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(08.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(08.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(08.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(08.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(08.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(08.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(08.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(08.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(09.)*0x20)++0x1F
  TEXTLINE "Channel 09 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(09.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(09.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(09.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(09.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(09.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(09.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(09.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(09.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(09.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(09.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(09.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(09.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(09.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(10.)*0x20)++0x1F
  TEXTLINE "Channel 10 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(10.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(10.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(10.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(10.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(10.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(10.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(10.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(10.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(10.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(10.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(10.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(10.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(10.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(11.)*0x20)++0x1F
  TEXTLINE "Channel 11 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(11.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(11.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(11.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(11.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(11.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(11.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(11.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(11.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(11.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(11.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(11.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(11.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(11.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(12.)*0x20)++0x1F
  TEXTLINE "Channel 12 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(12.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(12.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(12.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(12.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(12.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(12.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(12.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(12.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(12.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(12.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(12.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(12.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(12.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(13.)*0x20)++0x1F
  TEXTLINE "Channel 13 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(13.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(13.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(13.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(13.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(13.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(13.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(13.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(13.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(13.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(13.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(13.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(13.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(13.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(14.)*0x20)++0x1F
  TEXTLINE "Channel 14 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(14.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(14.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(14.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(14.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(14.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(14.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(14.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(14.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(14.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(14.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(14.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(14.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(14.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(15.)*0x20)++0x1F
  TEXTLINE "Channel 15 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(15.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(15.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(15.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(15.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(15.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(15.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(15.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(15.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(15.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(15.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(15.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(15.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(15.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(16.)*0x20)++0x1F
  TEXTLINE "Channel 16 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(16.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(16.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(16.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(16.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(16.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(16.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(16.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(16.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(16.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(16.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(16.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(16.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(16.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(17.)*0x20)++0x1F
  TEXTLINE "Channel 17 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(17.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(17.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(17.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(17.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(17.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(17.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(17.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(17.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(17.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(17.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(17.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(17.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(17.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(18.)*0x20)++0x1F
  TEXTLINE "Channel 18 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(18.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(18.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(18.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(18.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(18.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(18.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(18.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(18.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(18.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(18.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(18.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(18.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(18.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(19.)*0x20)++0x1F
  TEXTLINE "Channel 19 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(19.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(19.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(19.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(19.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(19.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(19.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(19.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(19.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(19.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(19.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(19.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(19.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(19.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(20.)*0x20)++0x1F
  TEXTLINE "Channel 20 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(20.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(20.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(20.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(20.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(20.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(20.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(20.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(20.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(20.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(20.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(20.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(20.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(20.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(21.)*0x20)++0x1F
  TEXTLINE "Channel 21 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(21.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(21.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(21.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(21.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(21.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(21.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(21.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(21.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(21.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(21.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(21.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(21.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(21.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(22.)*0x20)++0x1F
  TEXTLINE "Channel 22 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(22.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(22.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(22.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(22.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(22.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(22.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(22.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(22.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(22.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(22.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(22.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(22.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(22.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(23.)*0x20)++0x1F
  TEXTLINE "Channel 23 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(23.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(23.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(23.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(23.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(23.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(23.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(23.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(23.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(23.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(23.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(23.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(23.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(23.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(24.)*0x20)++0x1F
  TEXTLINE "Channel 24 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(24.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(24.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(24.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(24.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(24.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(24.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(24.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(24.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(24.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(24.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(24.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(24.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(24.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(25.)*0x20)++0x1F
  TEXTLINE "Channel 25 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(25.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(25.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(25.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(25.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(25.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(25.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(25.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(25.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(25.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(25.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(25.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(25.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(25.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(26.)*0x20)++0x1F
  TEXTLINE "Channel 26 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(26.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(26.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(26.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(26.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(26.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(26.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(26.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(26.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(26.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(26.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(26.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(26.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(26.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(27.)*0x20)++0x1F
  TEXTLINE "Channel 27 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(27.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(27.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(27.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(27.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(27.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(27.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(27.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(27.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(27.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(27.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(27.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(27.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(27.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(28.)*0x20)++0x1F
  TEXTLINE "Channel 28 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(28.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(28.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(28.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(28.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(28.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(28.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(28.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(28.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(28.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(28.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(28.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(28.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(28.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(29.)*0x20)++0x1F
  TEXTLINE "Channel 29 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(29.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(29.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(29.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(29.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(29.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(29.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(29.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(29.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(29.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(29.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(29.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(29.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(29.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(30.)*0x20)++0x1F
  TEXTLINE "Channel 30 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(30.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(30.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(30.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(30.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(30.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(30.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(30.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(30.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(30.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(30.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(30.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(30.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(30.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(31.)*0x20)++0x1F
  TEXTLINE "Channel 31 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(31.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(31.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(31.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(31.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(31.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(31.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(31.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(31.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(31.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(31.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(31.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(31.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(31.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



tree.end

  
tree.end
endif

sif CPUIS("MPC5674*")
tree "eDMA controllers"
tree "Enhanced Direct Memory Access (eDMA) A"


group.long (0xfff44000+0x0000)++0x03
  line.long 0x00 "CR,eDMA Control Register"
  bitfld.long  0x00 14.--15.              "GRP3PRI ,Channel group 3 priority." "0,1,2,3"
  bitfld.long  0x00 12.--13.              "  GRP2PRI ,Channel group 2 priority." "0,1,2,3"
  bitfld.long  0x00 10.--11.              "  GRP1PRI ,Channel group 1 priority." "0,1,2,3"
  bitfld.long  0x00 08.--09.              "  GRP0PRI ,Channel group 0 priority." "0,1,2,3"
  TEXTLINE "                "
  bitfld.long  0x00 03.                   "  ERGA    ,Enable round robin group arbitration" "0,1"
  bitfld.long  0x00 02.                   "  ERCA    ,Enable round robin channel arbitration" "0,1"
  bitfld.long  0x00 01.                   "  EDBG    ,Enable debug" "0,1"
;  bitfld.long  0x00 00.                   "  EBW     ,Enable buffered writes" "0,1"

TEXTLINE ""

group.long (0xfff44000+0x0004)++0x03
  line.long 0x00 "ESR,eDMA Error Status Register"
  bitfld.long  0x00 31.              "VLD ,Logical OR of all EDMA_ERRH and EDMA_ERRL status bits" "0,1"
  bitfld.long  0x00 15.              "  GPE ,Group priority error" "0,1"
  bitfld.long  0x00 14.              "  CPE ,Channel priority error" "0,1"
  hexmask.long 0x00 08.--13.  1.     "  ERRCHN ,Error channel number"
  TEXTLINE "                "
  bitfld.long  0x00 07.              "  SAE ,Source address error" "0,1"
  bitfld.long  0x00 06.              "  SOE ,Source offset error" "0,1"
  bitfld.long  0x00 05.              "  DAE ,Destination address error" "0,1"
  bitfld.long  0x00 04.              "  DOE ,Destination offset error" "0,1"
  bitfld.long  0x00 03.              "  NCE ,Nbytes/CITER configuration error" "0,1"
  bitfld.long  0x00 02.              "  SGE ,Scatter/gather configuration error" "0,1"
  bitfld.long  0x00 01.              "  SBE ,Source bus error" "0,1"
  bitfld.long  0x00 00.              "  DBE ,Destination bus error" "0,1"
  
TEXTLINE ""
  
group.long (0xfff44000+0x0008)++0x03
  line.long 0x00 "ERQRH,eDMA Enable Request Register H"
  bitfld.long  0x00 31.              "ERQ63-60 ,Enable DMA Request 63" "0,1"
  bitfld.long  0x00 30.              ",Enable DMA Request 62" "0,1"
  bitfld.long  0x00 29.              ",Enable DMA Request 61" "0,1"
  bitfld.long  0x00 28.              ",Enable DMA Request 60" "0,1"
  
  bitfld.long  0x00 27.              "  ERQ59-56 ,Enable DMA Request 59" "0,1"
  bitfld.long  0x00 26.              ",Enable DMA Request 58" "0,1"
  bitfld.long  0x00 25.              ",Enable DMA Request 57" "0,1"
  bitfld.long  0x00 24.              ",Enable DMA Request 56" "0,1"
  
  bitfld.long  0x00 23.              "  ERQ55-52 ,Enable DMA Request 55" "0,1"
  bitfld.long  0x00 22.              ",Enable DMA Request 54" "0,1"
  bitfld.long  0x00 21.              ",Enable DMA Request 53" "0,1"
  bitfld.long  0x00 20.              ",Enable DMA Request 52" "0,1"
  
  bitfld.long  0x00 19.              "  ERQ51-48 ,Enable DMA Request 51" "0,1"
  bitfld.long  0x00 18.              ",Enable DMA Request 50" "0,1"
  bitfld.long  0x00 17.              ",Enable DMA Request 49" "0,1"
  bitfld.long  0x00 16.              ",Enable DMA Request 48" "0,1"
  TEXTLINE "                  "
  bitfld.long  0x00 15.              "ERQ47-44 ,Enable DMA Request 47" "0,1"
  bitfld.long  0x00 14.              ",Enable DMA Request 46" "0,1"
  bitfld.long  0x00 13.              ",Enable DMA Request 45" "0,1"
  bitfld.long  0x00 12.              ",Enable DMA Request 44" "0,1"
  
  bitfld.long  0x00 11.              "  ERQ43-40 ,Enable DMA Request 43" "0,1"
  bitfld.long  0x00 10.              ",Enable DMA Request 42" "0,1"
  bitfld.long  0x00 09.              ",Enable DMA Request 41" "0,1"
  bitfld.long  0x00 08.              ",Enable DMA Request 40" "0,1"
  
  bitfld.long  0x00 07.              "  ERQ39-36 ,Enable DMA Request 39" "0,1"
  bitfld.long  0x00 06.              ",Enable DMA Request 38" "0,1"
  bitfld.long  0x00 05.              ",Enable DMA Request 37" "0,1"
  bitfld.long  0x00 04.              ",Enable DMA Request 36" "0,1"
  
  bitfld.long  0x00 03.              "  ERQ35-32 ,Enable DMA Request 35" "0,1"
  bitfld.long  0x00 02.              ",Enable DMA Request 34" "0,1"
  bitfld.long  0x00 01.              ",Enable DMA Request 33" "0,1"
  bitfld.long  0x00 00.              ",Enable DMA Request 32" "0,1"

  
group.long (0xfff44000+0x000C)++0x03
  line.long 0x00 "ERQRL,eDMA Enable Request Register L"
  bitfld.long  0x00 31.              "ERQ31-28 ,Enable DMA Request 31" "0,1"
  bitfld.long  0x00 30.              ",Enable DMA Request 30" "0,1"
  bitfld.long  0x00 29.              ",Enable DMA Request 29" "0,1"
  bitfld.long  0x00 28.              ",Enable DMA Request 28" "0,1"
  
  bitfld.long  0x00 27.              "  ERQ27-24 ,Enable DMA Request 27" "0,1"
  bitfld.long  0x00 26.              ",Enable DMA Request 26" "0,1"
  bitfld.long  0x00 25.              ",Enable DMA Request 25" "0,1"
  bitfld.long  0x00 24.              ",Enable DMA Request 24" "0,1"
  
  bitfld.long  0x00 23.              "  ERQ23-20 ,Enable DMA Request 23" "0,1"
  bitfld.long  0x00 22.              ",Enable DMA Request 22" "0,1"
  bitfld.long  0x00 21.              ",Enable DMA Request 21" "0,1"
  bitfld.long  0x00 20.              ",Enable DMA Request 20" "0,1"
  
  bitfld.long  0x00 19.              "  ERQ19-16 ,Enable DMA Request 19" "0,1"
  bitfld.long  0x00 18.              ",Enable DMA Request 18" "0,1"
  bitfld.long  0x00 17.              ",Enable DMA Request 17" "0,1"
  bitfld.long  0x00 16.              ",Enable DMA Request 16" "0,1"
  TEXTLINE "                  "
  bitfld.long  0x00 15.              "ERQ15-12 ,Enable DMA Request 15" "0,1"
  bitfld.long  0x00 14.              ",Enable DMA Request 14" "0,1"
  bitfld.long  0x00 13.              ",Enable DMA Request 13" "0,1"
  bitfld.long  0x00 12.              ",Enable DMA Request 12" "0,1"
  
  bitfld.long  0x00 11.              "  ERQ11-08 ,Enable DMA Request 11" "0,1"
  bitfld.long  0x00 10.              ",Enable DMA Request 10" "0,1"
  bitfld.long  0x00 09.              ",Enable DMA Request 09" "0,1"
  bitfld.long  0x00 08.              ",Enable DMA Request 08" "0,1"
  
  bitfld.long  0x00 07.              "  ERQ07-04 ,Enable DMA Request 07" "0,1"
  bitfld.long  0x00 06.              ",Enable DMA Request 06" "0,1"
  bitfld.long  0x00 05.              ",Enable DMA Request 05" "0,1"
  bitfld.long  0x00 04.              ",Enable DMA Request 04" "0,1"
  
  bitfld.long  0x00 03.              "  ERQ03-00 ,Enable DMA Request 03" "0,1"
  bitfld.long  0x00 02.              ",Enable DMA Request 02" "0,1"
  bitfld.long  0x00 01.              ",Enable DMA Request 01" "0,1"
  bitfld.long  0x00 00.              ",Enable DMA Request 00" "0,1"

  
TEXTLINE ""
  
group.long (0xfff44000+0x0010)++0x03
  line.long 0x00 "EEIRH,eDMA Enable Error Interrupt Register H"
  bitfld.long  0x00 31.              "EEI63-60 ,Enable error interrupt 63" "0,1"
  bitfld.long  0x00 30.              ",Enable error interrupt 62" "0,1"
  bitfld.long  0x00 29.              ",Enable error interrupt 61" "0,1"
  bitfld.long  0x00 28.              ",Enable error interrupt 60" "0,1"
  
  bitfld.long  0x00 27.              "  EEI59-56 ,Enable error interrupt 59" "0,1"
  bitfld.long  0x00 26.              ",Enable error interrupt 58" "0,1"
  bitfld.long  0x00 25.              ",Enable error interrupt 57" "0,1"
  bitfld.long  0x00 24.              ",Enable error interrupt 56" "0,1"
  
  bitfld.long  0x00 23.              "  EEI55-52 ,Enable error interrupt 55" "0,1"
  bitfld.long  0x00 22.              ",Enable error interrupt 54" "0,1"
  bitfld.long  0x00 21.              ",Enable error interrupt 53" "0,1"
  bitfld.long  0x00 20.              ",Enable error interrupt 52" "0,1"
  
  bitfld.long  0x00 19.              "  EEI51-48 ,Enable error interrupt 51" "0,1"
  bitfld.long  0x00 18.              ",Enable error interrupt 50" "0,1"
  bitfld.long  0x00 17.              ",Enable error interrupt 49" "0,1"
  bitfld.long  0x00 16.              ",Enable error interrupt 48" "0,1"
  TEXTLINE "                  "
  bitfld.long  0x00 15.              "EEI47-44 ,Enable error interrupt 47" "0,1"
  bitfld.long  0x00 14.              ",Enable error interrupt 46" "0,1"
  bitfld.long  0x00 13.              ",Enable error interrupt 45" "0,1"
  bitfld.long  0x00 12.              ",Enable error interrupt 44" "0,1"
  
  bitfld.long  0x00 11.              "  EEI43-40 ,Enable error interrupt 43" "0,1"
  bitfld.long  0x00 10.              ",Enable error interrupt 42" "0,1"
  bitfld.long  0x00 09.              ",Enable error interrupt 41" "0,1"
  bitfld.long  0x00 08.              ",Enable error interrupt 40" "0,1"
  
  bitfld.long  0x00 07.              "  EEI39-36 ,Enable error interrupt 39" "0,1"
  bitfld.long  0x00 06.              ",Enable error interrupt 38" "0,1"
  bitfld.long  0x00 05.              ",Enable error interrupt 37" "0,1"
  bitfld.long  0x00 04.              ",Enable error interrupt 36" "0,1"
  
  bitfld.long  0x00 03.              "  EEI35-32 ,Enable error interrupt 35" "0,1"
  bitfld.long  0x00 02.              ",Enable error interrupt 34" "0,1"
  bitfld.long  0x00 01.              ",Enable error interrupt 33" "0,1"
  bitfld.long  0x00 00.              ",Enable error interrupt 32" "0,1"

  
group.long (0xfff44000+0x0014)++0x03
  line.long 0x00 "EEIRL,eDMA Enable Error Interrupt Register L"
  bitfld.long  0x00 31.              "EEI31-28 ,Enable error interrupt 31" "0,1"
  bitfld.long  0x00 30.              ",Enable error interrupt 30" "0,1"
  bitfld.long  0x00 29.              ",Enable error interrupt 29" "0,1"
  bitfld.long  0x00 28.              ",Enable error interrupt 28" "0,1"
  
  bitfld.long  0x00 27.              "  EEI27-24 ,Enable error interrupt 27" "0,1"
  bitfld.long  0x00 26.              ",Enable error interrupt 26" "0,1"
  bitfld.long  0x00 25.              ",Enable error interrupt 25" "0,1"
  bitfld.long  0x00 24.              ",Enable error interrupt 24" "0,1"
  
  bitfld.long  0x00 23.              "  EEI23-20 ,Enable error interrupt 23" "0,1"
  bitfld.long  0x00 22.              ",Enable error interrupt 22" "0,1"
  bitfld.long  0x00 21.              ",Enable error interrupt 21" "0,1"
  bitfld.long  0x00 20.              ",Enable error interrupt 20" "0,1"
  
  bitfld.long  0x00 19.              "  EEI19-16 ,Enable error interrupt 19" "0,1"
  bitfld.long  0x00 18.              ",Enable error interrupt 18" "0,1"
  bitfld.long  0x00 17.              ",Enable error interrupt 17" "0,1"
  bitfld.long  0x00 16.              ",Enable error interrupt 16" "0,1"
  TEXTLINE "                  "
  bitfld.long  0x00 15.              "EEI15-12 ,Enable error interrupt 15" "0,1"
  bitfld.long  0x00 14.              ",Enable error interrupt 14" "0,1"
  bitfld.long  0x00 13.              ",Enable error interrupt 13" "0,1"
  bitfld.long  0x00 12.              ",Enable error interrupt 12" "0,1"
  
  bitfld.long  0x00 11.              "  EEI11-08 ,Enable error interrupt 11" "0,1"
  bitfld.long  0x00 10.              ",Enable error interrupt 10" "0,1"
  bitfld.long  0x00 09.              ",Enable error interrupt 09" "0,1"
  bitfld.long  0x00 08.              ",Enable error interrupt 08" "0,1"
  
  bitfld.long  0x00 07.              "  EEI07-04 ,Enable error interrupt 07" "0,1"
  bitfld.long  0x00 06.              ",Enable error interrupt 06" "0,1"
  bitfld.long  0x00 05.              ",Enable error interrupt 05" "0,1"
  bitfld.long  0x00 04.              ",Enable error interrupt 04" "0,1"
  
  bitfld.long  0x00 03.              "  EEI03-00 ,Enable error interrupt 03" "0,1"
  bitfld.long  0x00 02.              ",Enable error interrupt 02" "0,1"
  bitfld.long  0x00 01.              ",Enable error interrupt 01" "0,1"
  bitfld.long  0x00 00.              ",Enable error interrupt 00" "0,1"

TEXTLINE ""

group.byte (0xfff44000+0x0018)++0x03
  line.byte 0x00 "SERQR,eDMA Set Enable Request Register"
  hexmask.byte 0x00 00.--06.  1.     "    SERQ ,Set Enable Request"
  
group.byte (0xfff44000+0x0019)++0x03
  line.byte 0x00 "CERQR,eDMA Clear Enable Request Register"
  hexmask.byte 0x00 00.--06.  1.     "    CERQ ,Clear Enable Request"
  
group.byte (0xfff44000+0x001A)++0x03
  line.byte 0x00 "SEEIR,eDMA Set Enable Error Interrupt Register"
  hexmask.byte 0x00 00.--06.  1.     "    SEEI ,Set enable error interrupt"
  
group.byte (0xfff44000+0x001B)++0x03
  line.byte 0x00 "CEEIR,eDMA Clear Enable Error Interrupt Register"
  hexmask.byte 0x00 00.--06.  1.     "    CEEI ,eDMA Clear Enable Error Interrupt Register"
  
group.byte (0xfff44000+0x001C)++0x03
  line.byte 0x00 "CIRQR,eDMA Clear Interrupt Request Register"
  hexmask.byte 0x00 00.--06.  1.     "    CINT ,Clear interrupt request"
  
group.byte (0xfff44000+0x001D)++0x03
  line.byte 0x00 "CER,eDMA Clear Error Register"
  hexmask.byte 0x00 00.--06.  1.     "    CERR ,Clear error indicator"
  
group.byte (0xfff44000+0x001E)++0x03
  line.byte 0x00 "SSBR,eDMA Set START Bit Register"
  hexmask.byte 0x00 00.--06.  1.     "    SSB  ,Set START bit"
  
group.byte (0xfff44000+0x001F)++0x03
  line.byte 0x00 "CDSBR,eDMA Clear DONE Status Bit Register"
  hexmask.byte 0x00 00.--06.  1.     "    CDSB ,Clear DONE status bit"
  
  
TEXTLINE ""
  
group.long (0xfff44000+0x0020)++0x03
  line.long 0x00 "IRQRH,eDMA Interrupt Request Register H"
  bitfld.long  0x00 31.              "INT63-60 ,eDMA interrupt request 63" "0,1"
  bitfld.long  0x00 30.              ",eDMA interrupt request 62" "0,1"
  bitfld.long  0x00 29.              ",eDMA interrupt request 61" "0,1"
  bitfld.long  0x00 28.              ",eDMA interrupt request 60" "0,1"
  
  bitfld.long  0x00 27.              "  INT59-56 ,eDMA interrupt request 59" "0,1"
  bitfld.long  0x00 26.              ",eDMA interrupt request 58" "0,1"
  bitfld.long  0x00 25.              ",eDMA interrupt request 57" "0,1"
  bitfld.long  0x00 24.              ",eDMA interrupt request 56" "0,1"
  
  bitfld.long  0x00 23.              "  INT55-52 ,eDMA interrupt request 55" "0,1"
  bitfld.long  0x00 22.              ",eDMA interrupt request 54" "0,1"
  bitfld.long  0x00 21.              ",eDMA interrupt request 53" "0,1"
  bitfld.long  0x00 20.              ",eDMA interrupt request 52" "0,1"
  
  bitfld.long  0x00 19.              "  INT51-48 ,eDMA interrupt request 51" "0,1"
  bitfld.long  0x00 18.              ",eDMA interrupt request 50" "0,1"
  bitfld.long  0x00 17.              ",eDMA interrupt request 49" "0,1"
  bitfld.long  0x00 16.              ",eDMA interrupt request 48" "0,1"
  TEXTLINE "                  "
  bitfld.long  0x00 15.              "INT47-44 ,eDMA interrupt request 47" "0,1"
  bitfld.long  0x00 14.              ",eDMA interrupt request 46" "0,1"
  bitfld.long  0x00 13.              ",eDMA interrupt request 45" "0,1"
  bitfld.long  0x00 12.              ",eDMA interrupt request 44" "0,1"
  
  bitfld.long  0x00 11.              "  INT43-40 ,eDMA interrupt request 43" "0,1"
  bitfld.long  0x00 10.              ",eDMA interrupt request 42" "0,1"
  bitfld.long  0x00 09.              ",eDMA interrupt request 41" "0,1"
  bitfld.long  0x00 08.              ",eDMA interrupt request 40" "0,1"
  
  bitfld.long  0x00 07.              "  INT39-36 ,eDMA interrupt request 39" "0,1"
  bitfld.long  0x00 06.              ",eDMA interrupt request 38" "0,1"
  bitfld.long  0x00 05.              ",eDMA interrupt request 37" "0,1"
  bitfld.long  0x00 04.              ",eDMA interrupt request 36" "0,1"
  
  bitfld.long  0x00 03.              "  INT35-32 ,eDMA interrupt request 35" "0,1"
  bitfld.long  0x00 02.              ",eDMA interrupt request 34" "0,1"
  bitfld.long  0x00 01.              ",eDMA interrupt request 33" "0,1"
  bitfld.long  0x00 00.              ",eDMA interrupt request 32" "0,1"

  
group.long (0xfff44000+0x0024)++0x03
  line.long 0x00 "IRQRL,eDMA Interrupt Request Register L"
  bitfld.long  0x00 31.              "INT31-28 ,eDMA interrupt request 31" "0,1"
  bitfld.long  0x00 30.              ",eDMA interrupt request 30" "0,1"
  bitfld.long  0x00 29.              ",eDMA interrupt request 29" "0,1"
  bitfld.long  0x00 28.              ",eDMA interrupt request 28" "0,1"
  
  bitfld.long  0x00 27.              "  INT27-24 ,eDMA interrupt request 27" "0,1"
  bitfld.long  0x00 26.              ",eDMA interrupt request 26" "0,1"
  bitfld.long  0x00 25.              ",eDMA interrupt request 25" "0,1"
  bitfld.long  0x00 24.              ",eDMA interrupt request 24" "0,1"
  
  bitfld.long  0x00 23.              "  INT23-20 ,eDMA interrupt request 23" "0,1"
  bitfld.long  0x00 22.              ",eDMA interrupt request 22" "0,1"
  bitfld.long  0x00 21.              ",eDMA interrupt request 21" "0,1"
  bitfld.long  0x00 20.              ",eDMA interrupt request 20" "0,1"
  
  bitfld.long  0x00 19.              "  INT19-16 ,eDMA interrupt request 19" "0,1"
  bitfld.long  0x00 18.              ",eDMA interrupt request 18" "0,1"
  bitfld.long  0x00 17.              ",eDMA interrupt request 17" "0,1"
  bitfld.long  0x00 16.              ",eDMA interrupt request 16" "0,1"
  TEXTLINE "                  "
  bitfld.long  0x00 15.              "INT15-12 ,eDMA interrupt request 15" "0,1"
  bitfld.long  0x00 14.              ",eDMA interrupt request 14" "0,1"
  bitfld.long  0x00 13.              ",eDMA interrupt request 13" "0,1"
  bitfld.long  0x00 12.              ",eDMA interrupt request 12" "0,1"
  
  bitfld.long  0x00 11.              "  INT11-08 ,eDMA interrupt request 11" "0,1"
  bitfld.long  0x00 10.              ",eDMA interrupt request 10" "0,1"
  bitfld.long  0x00 09.              ",eDMA interrupt request 09" "0,1"
  bitfld.long  0x00 08.              ",eDMA interrupt request 08" "0,1"
  
  bitfld.long  0x00 07.              "  INT07-04 ,eDMA interrupt request 07" "0,1"
  bitfld.long  0x00 06.              ",eDMA interrupt request 06" "0,1"
  bitfld.long  0x00 05.              ",eDMA interrupt request 05" "0,1"
  bitfld.long  0x00 04.              ",eDMA interrupt request 04" "0,1"
  
  bitfld.long  0x00 03.              "  INT03-00 ,eDMA interrupt request 03" "0,1"
  bitfld.long  0x00 02.              ",eDMA interrupt request 02" "0,1"
  bitfld.long  0x00 01.              ",eDMA interrupt request 01" "0,1"
  bitfld.long  0x00 00.              ",eDMA interrupt request 00" "0,1"


TEXTLINE ""
  
group.long (0xfff44000+0x0028)++0x03
  line.long 0x00 "ERH,eDMA Error Register H"
  bitfld.long  0x00 31.              "ERR63-60 ,eDMA Error 63" "0,1"
  bitfld.long  0x00 30.              ",eDMA Error 62" "0,1"
  bitfld.long  0x00 29.              ",eDMA Error 61" "0,1"
  bitfld.long  0x00 28.              ",eDMA Error 60" "0,1"
  
  bitfld.long  0x00 27.              "  ERR59-56 ,eDMA Error 59" "0,1"
  bitfld.long  0x00 26.              ",eDMA Error 58" "0,1"
  bitfld.long  0x00 25.              ",eDMA Error 57" "0,1"
  bitfld.long  0x00 24.              ",eDMA Error 56" "0,1"
  
  bitfld.long  0x00 23.              "  ERR55-52 ,eDMA Error 55" "0,1"
  bitfld.long  0x00 22.              ",eDMA Error 54" "0,1"
  bitfld.long  0x00 21.              ",eDMA Error 53" "0,1"
  bitfld.long  0x00 20.              ",eDMA Error 52" "0,1"
  
  bitfld.long  0x00 19.              "  ERR51-48 ,eDMA Error 51" "0,1"
  bitfld.long  0x00 18.              ",eDMA Error 50" "0,1"
  bitfld.long  0x00 17.              ",eDMA Error 49" "0,1"
  bitfld.long  0x00 16.              ",eDMA Error 48" "0,1"
  TEXTLINE "                  "
  bitfld.long  0x00 15.              "ERR47-44 ,eDMA Error 47" "0,1"
  bitfld.long  0x00 14.              ",eDMA Error 46" "0,1"
  bitfld.long  0x00 13.              ",eDMA Error 45" "0,1"
  bitfld.long  0x00 12.              ",eDMA Error 44" "0,1"
  
  bitfld.long  0x00 11.              "  ERR43-40 ,eDMA Error 43" "0,1"
  bitfld.long  0x00 10.              ",eDMA Error 42" "0,1"
  bitfld.long  0x00 09.              ",eDMA Error 41" "0,1"
  bitfld.long  0x00 08.              ",eDMA Error 40" "0,1"
  
  bitfld.long  0x00 07.              "  ERR39-36 ,eDMA Error 39" "0,1"
  bitfld.long  0x00 06.              ",eDMA Error 38" "0,1"
  bitfld.long  0x00 05.              ",eDMA Error 37" "0,1"
  bitfld.long  0x00 04.              ",eDMA Error 36" "0,1"
  
  bitfld.long  0x00 03.              "  ERR35-32 ,eDMA Error 35" "0,1"
  bitfld.long  0x00 02.              ",eDMA Error 34" "0,1"
  bitfld.long  0x00 01.              ",eDMA Error 33" "0,1"
  bitfld.long  0x00 00.              ",eDMA Error 32" "0,1"

  
group.long (0xfff44000+0x002C)++0x03
  line.long 0x00 "ERL,eDMA Error Register L"
  bitfld.long  0x00 31.              "ERR31-28 ,eDMA Error 31" "0,1"
  bitfld.long  0x00 30.              ",eDMA Error 30" "0,1"
  bitfld.long  0x00 29.              ",eDMA Error 29" "0,1"
  bitfld.long  0x00 28.              ",eDMA Error 28" "0,1"
  
  bitfld.long  0x00 27.              "  ERR27-24 ,eDMA Error 27" "0,1"
  bitfld.long  0x00 26.              ",eDMA Error 26" "0,1"
  bitfld.long  0x00 25.              ",eDMA Error 25" "0,1"
  bitfld.long  0x00 24.              ",eDMA Error 24" "0,1"
  
  bitfld.long  0x00 23.              "  ERR23-20 ,eDMA Error 23" "0,1"
  bitfld.long  0x00 22.              ",eDMA Error 22" "0,1"
  bitfld.long  0x00 21.              ",eDMA Error 21" "0,1"
  bitfld.long  0x00 20.              ",eDMA Error 20" "0,1"
  
  bitfld.long  0x00 19.              "  ERR19-16 ,eDMA Error 19" "0,1"
  bitfld.long  0x00 18.              ",eDMA Error 18" "0,1"
  bitfld.long  0x00 17.              ",eDMA Error 17" "0,1"
  bitfld.long  0x00 16.              ",eDMA Error 16" "0,1"
  TEXTLINE "                  "
  bitfld.long  0x00 15.              "ERR15-12 ,eDMA Error 15" "0,1"
  bitfld.long  0x00 14.              ",eDMA Error 14" "0,1"
  bitfld.long  0x00 13.              ",eDMA Error 13" "0,1"
  bitfld.long  0x00 12.              ",eDMA Error 12" "0,1"
  
  bitfld.long  0x00 11.              "  ERR11-08 ,eDMA Error 11" "0,1"
  bitfld.long  0x00 10.              ",eDMA Error 10" "0,1"
  bitfld.long  0x00 09.              ",eDMA Error 09" "0,1"
  bitfld.long  0x00 08.              ",eDMA Error 08" "0,1"
  
  bitfld.long  0x00 07.              "  ERR07-04 ,eDMA Error 07" "0,1"
  bitfld.long  0x00 06.              ",eDMA Error 06" "0,1"
  bitfld.long  0x00 05.              ",eDMA Error 05" "0,1"
  bitfld.long  0x00 04.              ",eDMA Error 04" "0,1"
  
  bitfld.long  0x00 03.              "  ERR03-00 ,eDMA Error 03" "0,1"
  bitfld.long  0x00 02.              ",eDMA Error 02" "0,1"
  bitfld.long  0x00 01.              ",eDMA Error 01" "0,1"
  bitfld.long  0x00 00.              ",eDMA Error 00" "0,1"

tree "eDMA Channel Priority Registers"
group.byte (0xfff44000+0x100+00.)++0x00
  line.byte    0x00 "CPR00,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 00 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 00 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 00 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+01.)++0x00
  line.byte    0x00 "CPR01,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 01 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 01 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 01 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+02.)++0x00
  line.byte    0x00 "CPR02,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 02 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 02 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 02 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+03.)++0x00
  line.byte    0x00 "CPR03,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 03 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 03 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 03 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+04.)++0x00
  line.byte    0x00 "CPR04,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 04 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 04 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 04 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+05.)++0x00
  line.byte    0x00 "CPR05,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 05 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 05 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 05 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+06.)++0x00
  line.byte    0x00 "CPR06,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 06 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 06 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 06 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+07.)++0x00
  line.byte    0x00 "CPR07,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 07 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 07 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 07 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+08.)++0x00
  line.byte    0x00 "CPR08,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 08 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 08 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 08 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+09.)++0x00
  line.byte    0x00 "CPR09,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 09 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 09 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 09 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+10.)++0x00
  line.byte    0x00 "CPR10,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 10 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 10 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 10 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+11.)++0x00
  line.byte    0x00 "CPR11,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 11 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 11 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 11 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+12.)++0x00
  line.byte    0x00 "CPR12,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 12 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 12 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 12 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+13.)++0x00
  line.byte    0x00 "CPR13,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 13 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 13 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 13 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+14.)++0x00
  line.byte    0x00 "CPR14,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 14 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 14 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 14 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+15.)++0x00
  line.byte    0x00 "CPR15,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 15 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 15 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 15 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+16.)++0x00
  line.byte    0x00 "CPR16,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 16 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 16 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 16 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+17.)++0x00
  line.byte    0x00 "CPR17,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 17 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 17 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 17 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+18.)++0x00
  line.byte    0x00 "CPR18,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 18 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 18 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 18 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+19.)++0x00
  line.byte    0x00 "CPR19,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 19 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 19 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 19 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+20.)++0x00
  line.byte    0x00 "CPR20,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 20 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 20 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 20 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+21.)++0x00
  line.byte    0x00 "CPR21,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 21 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 21 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 21 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+22.)++0x00
  line.byte    0x00 "CPR22,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 22 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 22 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 22 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+23.)++0x00
  line.byte    0x00 "CPR23,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 23 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 23 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 23 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+24.)++0x00
  line.byte    0x00 "CPR24,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 24 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 24 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 24 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+25.)++0x00
  line.byte    0x00 "CPR25,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 25 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 25 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 25 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+26.)++0x00
  line.byte    0x00 "CPR26,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 26 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 26 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 26 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+27.)++0x00
  line.byte    0x00 "CPR27,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 27 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 27 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 27 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+28.)++0x00
  line.byte    0x00 "CPR28,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 28 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 28 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 28 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+29.)++0x00
  line.byte    0x00 "CPR29,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 29 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 29 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 29 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+30.)++0x00
  line.byte    0x00 "CPR30,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 30 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 30 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 30 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+31.)++0x00
  line.byte    0x00 "CPR31,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 31 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 31 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 31 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+32.)++0x00
  line.byte    0x00 "CPR32,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 32 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 32 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 32 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+33.)++0x00
  line.byte    0x00 "CPR33,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 33 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 33 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 33 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+34.)++0x00
  line.byte    0x00 "CPR34,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 34 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 34 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 34 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+35.)++0x00
  line.byte    0x00 "CPR35,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 35 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 35 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 35 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+36.)++0x00
  line.byte    0x00 "CPR36,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 36 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 36 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 36 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+37.)++0x00
  line.byte    0x00 "CPR37,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 37 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 37 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 37 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+38.)++0x00
  line.byte    0x00 "CPR38,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 38 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 38 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 38 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+39.)++0x00
  line.byte    0x00 "CPR39,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 39 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 39 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 39 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+40.)++0x00
  line.byte    0x00 "CPR40,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 40 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 40 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 40 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+41.)++0x00
  line.byte    0x00 "CPR41,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 41 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 41 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 41 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+42.)++0x00
  line.byte    0x00 "CPR42,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 42 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 42 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 42 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+43.)++0x00
  line.byte    0x00 "CPR43,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 43 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 43 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 43 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+44.)++0x00
  line.byte    0x00 "CPR44,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 44 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 44 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 44 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+45.)++0x00
  line.byte    0x00 "CPR45,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 45 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 45 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 45 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+46.)++0x00
  line.byte    0x00 "CPR46,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 46 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 46 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 46 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+47.)++0x00
  line.byte    0x00 "CPR47,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 47 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 47 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 47 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+48.)++0x00
  line.byte    0x00 "CPR48,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 48 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 48 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 48 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+49.)++0x00
  line.byte    0x00 "CPR49,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 49 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 49 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 49 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+50.)++0x00
  line.byte    0x00 "CPR50,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 50 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 50 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 50 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+51.)++0x00
  line.byte    0x00 "CPR51,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 51 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 51 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 51 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+52.)++0x00
  line.byte    0x00 "CPR52,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 52 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 52 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 52 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+53.)++0x00
  line.byte    0x00 "CPR53,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 53 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 53 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 53 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+54.)++0x00
  line.byte    0x00 "CPR54,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 54 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 54 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 54 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+55.)++0x00
  line.byte    0x00 "CPR55,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 55 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 55 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 55 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+56.)++0x00
  line.byte    0x00 "CPR56,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 56 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 56 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 56 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+57.)++0x00
  line.byte    0x00 "CPR57,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 57 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 57 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 57 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+58.)++0x00
  line.byte    0x00 "CPR58,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 58 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 58 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 58 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+59.)++0x00
  line.byte    0x00 "CPR59,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 59 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 59 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 59 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+60.)++0x00
  line.byte    0x00 "CPR60,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 60 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 60 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 60 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+61.)++0x00
  line.byte    0x00 "CPR61,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 61 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 61 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 61 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+62.)++0x00
  line.byte    0x00 "CPR62,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 62 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 62 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 62 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff44000+0x100+63.)++0x00
  line.byte    0x00 "CPR63,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 63 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 63 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 63 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

tree.end

tree "eDMA Transfer Control Descriptors"
group.long (0xfff44000+0x1000+(00.)*0x20)++0x1F
  TEXTLINE "Channel 00 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(00.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(00.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(00.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(00.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(00.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(00.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(00.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(00.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(00.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(00.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(00.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(00.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(00.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(01.)*0x20)++0x1F
  TEXTLINE "Channel 01 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(01.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(01.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(01.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(01.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(01.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(01.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(01.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(01.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(01.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(01.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(01.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(01.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(01.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(02.)*0x20)++0x1F
  TEXTLINE "Channel 02 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(02.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(02.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(02.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(02.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(02.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(02.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(02.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(02.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(02.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(02.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(02.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(02.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(02.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(03.)*0x20)++0x1F
  TEXTLINE "Channel 03 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(03.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(03.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(03.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(03.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(03.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(03.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(03.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(03.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(03.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(03.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(03.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(03.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(03.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(04.)*0x20)++0x1F
  TEXTLINE "Channel 04 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(04.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(04.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(04.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(04.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(04.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(04.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(04.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(04.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(04.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(04.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(04.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(04.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(04.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(05.)*0x20)++0x1F
  TEXTLINE "Channel 05 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(05.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(05.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(05.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(05.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(05.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(05.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(05.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(05.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(05.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(05.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(05.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(05.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(05.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(06.)*0x20)++0x1F
  TEXTLINE "Channel 06 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(06.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(06.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(06.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(06.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(06.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(06.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(06.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(06.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(06.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(06.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(06.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(06.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(06.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(07.)*0x20)++0x1F
  TEXTLINE "Channel 07 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(07.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(07.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(07.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(07.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(07.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(07.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(07.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(07.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(07.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(07.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(07.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(07.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(07.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(08.)*0x20)++0x1F
  TEXTLINE "Channel 08 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(08.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(08.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(08.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(08.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(08.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(08.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(08.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(08.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(08.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(08.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(08.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(08.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(08.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(09.)*0x20)++0x1F
  TEXTLINE "Channel 09 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(09.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(09.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(09.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(09.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(09.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(09.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(09.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(09.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(09.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(09.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(09.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(09.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(09.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(10.)*0x20)++0x1F
  TEXTLINE "Channel 10 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(10.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(10.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(10.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(10.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(10.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(10.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(10.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(10.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(10.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(10.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(10.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(10.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(10.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(11.)*0x20)++0x1F
  TEXTLINE "Channel 11 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(11.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(11.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(11.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(11.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(11.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(11.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(11.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(11.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(11.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(11.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(11.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(11.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(11.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(12.)*0x20)++0x1F
  TEXTLINE "Channel 12 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(12.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(12.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(12.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(12.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(12.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(12.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(12.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(12.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(12.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(12.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(12.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(12.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(12.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(13.)*0x20)++0x1F
  TEXTLINE "Channel 13 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(13.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(13.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(13.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(13.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(13.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(13.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(13.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(13.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(13.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(13.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(13.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(13.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(13.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(14.)*0x20)++0x1F
  TEXTLINE "Channel 14 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(14.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(14.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(14.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(14.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(14.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(14.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(14.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(14.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(14.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(14.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(14.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(14.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(14.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(15.)*0x20)++0x1F
  TEXTLINE "Channel 15 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(15.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(15.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(15.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(15.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(15.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(15.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(15.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(15.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(15.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(15.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(15.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(15.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(15.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(16.)*0x20)++0x1F
  TEXTLINE "Channel 16 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(16.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(16.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(16.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(16.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(16.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(16.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(16.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(16.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(16.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(16.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(16.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(16.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(16.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(17.)*0x20)++0x1F
  TEXTLINE "Channel 17 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(17.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(17.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(17.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(17.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(17.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(17.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(17.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(17.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(17.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(17.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(17.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(17.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(17.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(18.)*0x20)++0x1F
  TEXTLINE "Channel 18 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(18.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(18.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(18.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(18.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(18.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(18.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(18.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(18.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(18.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(18.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(18.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(18.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(18.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(19.)*0x20)++0x1F
  TEXTLINE "Channel 19 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(19.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(19.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(19.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(19.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(19.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(19.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(19.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(19.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(19.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(19.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(19.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(19.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(19.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(20.)*0x20)++0x1F
  TEXTLINE "Channel 20 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(20.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(20.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(20.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(20.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(20.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(20.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(20.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(20.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(20.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(20.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(20.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(20.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(20.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(21.)*0x20)++0x1F
  TEXTLINE "Channel 21 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(21.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(21.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(21.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(21.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(21.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(21.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(21.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(21.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(21.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(21.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(21.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(21.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(21.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(22.)*0x20)++0x1F
  TEXTLINE "Channel 22 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(22.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(22.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(22.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(22.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(22.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(22.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(22.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(22.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(22.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(22.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(22.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(22.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(22.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(23.)*0x20)++0x1F
  TEXTLINE "Channel 23 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(23.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(23.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(23.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(23.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(23.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(23.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(23.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(23.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(23.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(23.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(23.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(23.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(23.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(24.)*0x20)++0x1F
  TEXTLINE "Channel 24 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(24.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(24.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(24.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(24.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(24.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(24.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(24.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(24.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(24.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(24.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(24.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(24.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(24.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(25.)*0x20)++0x1F
  TEXTLINE "Channel 25 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(25.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(25.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(25.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(25.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(25.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(25.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(25.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(25.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(25.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(25.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(25.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(25.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(25.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(26.)*0x20)++0x1F
  TEXTLINE "Channel 26 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(26.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(26.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(26.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(26.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(26.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(26.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(26.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(26.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(26.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(26.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(26.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(26.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(26.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(27.)*0x20)++0x1F
  TEXTLINE "Channel 27 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(27.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(27.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(27.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(27.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(27.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(27.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(27.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(27.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(27.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(27.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(27.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(27.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(27.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(28.)*0x20)++0x1F
  TEXTLINE "Channel 28 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(28.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(28.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(28.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(28.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(28.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(28.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(28.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(28.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(28.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(28.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(28.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(28.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(28.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(29.)*0x20)++0x1F
  TEXTLINE "Channel 29 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(29.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(29.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(29.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(29.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(29.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(29.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(29.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(29.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(29.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(29.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(29.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(29.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(29.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(30.)*0x20)++0x1F
  TEXTLINE "Channel 30 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(30.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(30.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(30.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(30.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(30.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(30.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(30.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(30.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(30.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(30.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(30.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(30.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(30.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(31.)*0x20)++0x1F
  TEXTLINE "Channel 31 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(31.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(31.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(31.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(31.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(31.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(31.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(31.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(31.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(31.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(31.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(31.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(31.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(31.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(32.)*0x20)++0x1F
  TEXTLINE "Channel 32 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(32.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(32.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(32.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(32.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(32.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(32.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(32.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(32.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(32.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(32.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(32.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(32.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(32.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(33.)*0x20)++0x1F
  TEXTLINE "Channel 33 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(33.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(33.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(33.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(33.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(33.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(33.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(33.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(33.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(33.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(33.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(33.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(33.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(33.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(34.)*0x20)++0x1F
  TEXTLINE "Channel 34 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(34.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(34.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(34.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(34.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(34.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(34.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(34.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(34.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(34.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(34.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(34.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(34.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(34.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(35.)*0x20)++0x1F
  TEXTLINE "Channel 35 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(35.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(35.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(35.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(35.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(35.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(35.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(35.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(35.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(35.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(35.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(35.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(35.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(35.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(36.)*0x20)++0x1F
  TEXTLINE "Channel 36 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(36.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(36.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(36.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(36.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(36.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(36.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(36.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(36.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(36.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(36.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(36.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(36.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(36.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(37.)*0x20)++0x1F
  TEXTLINE "Channel 37 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(37.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(37.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(37.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(37.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(37.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(37.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(37.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(37.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(37.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(37.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(37.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(37.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(37.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(38.)*0x20)++0x1F
  TEXTLINE "Channel 38 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(38.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(38.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(38.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(38.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(38.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(38.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(38.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(38.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(38.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(38.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(38.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(38.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(38.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(39.)*0x20)++0x1F
  TEXTLINE "Channel 39 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(39.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(39.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(39.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(39.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(39.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(39.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(39.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(39.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(39.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(39.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(39.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(39.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(39.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(40.)*0x20)++0x1F
  TEXTLINE "Channel 40 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(40.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(40.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(40.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(40.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(40.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(40.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(40.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(40.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(40.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(40.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(40.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(40.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(40.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(41.)*0x20)++0x1F
  TEXTLINE "Channel 41 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(41.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(41.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(41.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(41.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(41.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(41.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(41.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(41.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(41.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(41.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(41.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(41.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(41.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(42.)*0x20)++0x1F
  TEXTLINE "Channel 42 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(42.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(42.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(42.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(42.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(42.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(42.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(42.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(42.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(42.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(42.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(42.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(42.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(42.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(43.)*0x20)++0x1F
  TEXTLINE "Channel 43 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(43.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(43.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(43.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(43.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(43.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(43.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(43.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(43.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(43.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(43.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(43.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(43.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(43.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(44.)*0x20)++0x1F
  TEXTLINE "Channel 44 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(44.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(44.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(44.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(44.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(44.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(44.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(44.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(44.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(44.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(44.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(44.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(44.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(44.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(45.)*0x20)++0x1F
  TEXTLINE "Channel 45 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(45.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(45.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(45.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(45.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(45.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(45.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(45.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(45.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(45.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(45.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(45.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(45.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(45.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(46.)*0x20)++0x1F
  TEXTLINE "Channel 46 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(46.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(46.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(46.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(46.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(46.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(46.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(46.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(46.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(46.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(46.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(46.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(46.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(46.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(47.)*0x20)++0x1F
  TEXTLINE "Channel 47 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(47.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(47.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(47.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(47.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(47.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(47.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(47.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(47.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(47.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(47.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(47.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(47.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(47.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(48.)*0x20)++0x1F
  TEXTLINE "Channel 48 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(48.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(48.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(48.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(48.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(48.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(48.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(48.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(48.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(48.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(48.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(48.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(48.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(48.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(49.)*0x20)++0x1F
  TEXTLINE "Channel 49 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(49.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(49.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(49.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(49.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(49.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(49.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(49.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(49.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(49.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(49.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(49.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(49.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(49.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(50.)*0x20)++0x1F
  TEXTLINE "Channel 50 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(50.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(50.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(50.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(50.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(50.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(50.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(50.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(50.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(50.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(50.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(50.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(50.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(50.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(51.)*0x20)++0x1F
  TEXTLINE "Channel 51 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(51.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(51.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(51.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(51.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(51.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(51.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(51.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(51.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(51.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(51.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(51.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(51.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(51.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(52.)*0x20)++0x1F
  TEXTLINE "Channel 52 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(52.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(52.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(52.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(52.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(52.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(52.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(52.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(52.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(52.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(52.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(52.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(52.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(52.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(53.)*0x20)++0x1F
  TEXTLINE "Channel 53 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(53.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(53.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(53.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(53.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(53.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(53.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(53.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(53.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(53.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(53.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(53.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(53.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(53.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(54.)*0x20)++0x1F
  TEXTLINE "Channel 54 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(54.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(54.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(54.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(54.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(54.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(54.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(54.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(54.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(54.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(54.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(54.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(54.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(54.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(55.)*0x20)++0x1F
  TEXTLINE "Channel 55 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(55.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(55.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(55.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(55.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(55.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(55.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(55.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(55.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(55.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(55.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(55.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(55.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(55.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(56.)*0x20)++0x1F
  TEXTLINE "Channel 56 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(56.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(56.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(56.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(56.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(56.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(56.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(56.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(56.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(56.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(56.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(56.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(56.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(56.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(57.)*0x20)++0x1F
  TEXTLINE "Channel 57 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(57.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(57.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(57.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(57.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(57.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(57.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(57.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(57.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(57.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(57.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(57.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(57.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
