  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(57.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(58.)*0x20)++0x1F
  TEXTLINE "Channel 58 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(58.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(58.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(58.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(58.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(58.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(58.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(58.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(58.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(58.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(58.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(58.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(58.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(58.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(59.)*0x20)++0x1F
  TEXTLINE "Channel 59 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(59.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(59.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(59.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(59.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(59.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(59.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(59.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(59.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(59.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(59.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(59.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(59.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(59.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(60.)*0x20)++0x1F
  TEXTLINE "Channel 60 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(60.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(60.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(60.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(60.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(60.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(60.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(60.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(60.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(60.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(60.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(60.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(60.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(60.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(61.)*0x20)++0x1F
  TEXTLINE "Channel 61 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(61.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(61.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(61.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(61.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(61.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(61.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(61.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(61.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(61.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(61.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(61.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(61.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(61.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(62.)*0x20)++0x1F
  TEXTLINE "Channel 62 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(62.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(62.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(62.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(62.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(62.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(62.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(62.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(62.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(62.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(62.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(62.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(62.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(62.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff44000+0x1000+(63.)*0x20)++0x1F
  TEXTLINE "Channel 63 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(63.)*0x20)&0xC0000000)==0)
 group.long (0xfff44000+0x1000+(63.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff44000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff44000+0x1008+(63.)*0x20)&0xC0000000)!=0)
 group.long (0xfff44000+0x1000+(63.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff44000)&0x00000080)==0x00000000
 group.long (0xfff44000+0x1000+(63.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff44000+0x1000+(63.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff44000+0x1014+(63.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(63.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff44000+0x1000+(63.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff44000+0x1000+(63.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff44000+0x101C+(63.)*0x20)&0x80000000)==0x80000000
group.long (0xfff44000+0x1000+(63.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff44000+0x1000+(63.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif




tree.end
  
tree.end
tree "Enhanced Direct Memory Access (eDMA) B"

if data.word(anc:0xc3f90004)==0x5561

 group.long (0xfff54000+0x0000)++0x03
   line.long 0x00 "CR,eDMA Control Register"
   bitfld.long  0x00 17.                     "CX      ,Cancel the remaining data transfer" "0,1"
   bitfld.long  0x00 16.                   "  EX      ,Error cancel transfer" "0,1"
   bitfld.long  0x00 10.                   "  GRP1PRI ,Channel group 1 priority" "0,1"
   bitfld.long  0x00 08.                   "  GRP0PRI ,Channel group 0 priority" "0,1"
   TEXTLINE "                "
   bitfld.long  0x00 07.                   "  EMLM    ,Enable minor loop mapping" "0,1"
   bitfld.long  0x00 06.                   "  CLM     ,Continuous link mode" "0,1"
   bitfld.long  0x00 05.                   "  HALT    ,Halt DMA operations" "0,1"
   bitfld.long  0x00 04.                   "  HOE     ,Halt on error" "0,1"
   TEXTLINE "                "
   bitfld.long  0x00 03.                   "  ERGA    ,Enable round robin group arbitration" "0,1"
   bitfld.long  0x00 02.                   "  ERCA    ,Enable round robin channel arbitration" "0,1"
   bitfld.long  0x00 01.                   "  EDBG    ,Enable debug" "0,1"

 TEXTLINE ""

 group.long (0xfff54000+0x0004)++0x03
   line.long 0x00 "ESR,eDMA Error Status Register"
   bitfld.long  0x00 31.                "VLD ,Logical OR of all EDMA_ERRH and EDMA_ERRL status bits" "0,1"
   bitfld.long  0x00 16.              "  ECX ,Transfer canceled" "0,1"
   bitfld.long  0x00 15.              "  GPE ,Group priority error" "0,1"
   bitfld.long  0x00 14.              "  CPE ,Channel priority error" "0,1"
   hexmask.long.byte 0x00 08.--13.  1. "  ERRCHN ,Error channel number"
   TEXTLINE "                "
   bitfld.long  0x00 07.              "  SAE ,Source address error" "0,1"
   bitfld.long  0x00 06.              "  SOE ,Source offset error" "0,1"
   bitfld.long  0x00 05.              "  DAE ,Destination address error" "0,1"
   bitfld.long  0x00 04.              "  DOE ,Destination offset error" "0,1"
   bitfld.long  0x00 03.              "  NCE ,Nbytes/CITER configuration error" "0,1"
   bitfld.long  0x00 02.              "  SGE ,Scatter/gather configuration error" "0,1"
   bitfld.long  0x00 01.              "  SBE ,Source bus error" "0,1"
   bitfld.long  0x00 00.              "  DBE ,Destination bus error" "0,1"

else

 group.long (0xfff54000+0x0000)++0x03
   line.long 0x00 "CR,eDMA Control Register"
   bitfld.long  0x00 10.--11.                "GRP1PRI ,Channel group 1 priority." "0,1,2,3"
   bitfld.long  0x00 08.--09.              "  GRP0PRI ,Channel group 0 priority." "0,1,2,3"
   bitfld.long  0x00 03.                   "  ERGA    ,Enable round robin group arbitration" "0,1"
   bitfld.long  0x00 02.                   "  ERCA    ,Enable round robin channel arbitration" "0,1"
   bitfld.long  0x00 01.                   "  EDBG    ,Enable debug" "0,1"

 TEXTLINE ""

 group.long (0xfff54000+0x0004)++0x03
   line.long 0x00 "ESR,eDMA Error Status Register"
   bitfld.long  0x00 31.                "VLD ,Logical OR of all EDMA_ERRH and EDMA_ERRL status bits" "0,1"
   bitfld.long  0x00 15.              "  GPE ,Group priority error" "0,1"
   bitfld.long  0x00 14.              "  CPE ,Channel priority error" "0,1"
   hexmask.long.byte 0x00 08.--13.  1.     "  ERRCHN ,Error channel number"
   TEXTLINE "                "
   bitfld.long  0x00 07.              "  SAE ,Source address error" "0,1"
   bitfld.long  0x00 06.              "  SOE ,Source offset error" "0,1"
   bitfld.long  0x00 05.              "  DAE ,Destination address error" "0,1"
   bitfld.long  0x00 04.              "  DOE ,Destination offset error" "0,1"
   bitfld.long  0x00 03.              "  NCE ,Nbytes/CITER configuration error" "0,1"
   bitfld.long  0x00 02.              "  SGE ,Scatter/gather configuration error" "0,1"
   bitfld.long  0x00 01.              "  SBE ,Source bus error" "0,1"
   bitfld.long  0x00 00.              "  DBE ,Destination bus error" "0,1"

endif
  
TEXTLINE ""
    
group.long (0xfff54000+0x000C)++0x03
  line.long 0x00 "ERQRL,eDMA Enable Request Register L"
  bitfld.long  0x00 31.              "ERQ31-28 ,Enable DMA Request 31" "0,1"
  bitfld.long  0x00 30.              ",Enable DMA Request 30" "0,1"
  bitfld.long  0x00 29.              ",Enable DMA Request 29" "0,1"
  bitfld.long  0x00 28.              ",Enable DMA Request 28" "0,1"
  
  bitfld.long  0x00 27.              "  ERQ27-24 ,Enable DMA Request 27" "0,1"
  bitfld.long  0x00 26.              ",Enable DMA Request 26" "0,1"
  bitfld.long  0x00 25.              ",Enable DMA Request 25" "0,1"
  bitfld.long  0x00 24.              ",Enable DMA Request 24" "0,1"
  
  bitfld.long  0x00 23.              "  ERQ23-20 ,Enable DMA Request 23" "0,1"
  bitfld.long  0x00 22.              ",Enable DMA Request 22" "0,1"
  bitfld.long  0x00 21.              ",Enable DMA Request 21" "0,1"
  bitfld.long  0x00 20.              ",Enable DMA Request 20" "0,1"
  
  bitfld.long  0x00 19.              "  ERQ19-16 ,Enable DMA Request 19" "0,1"
  bitfld.long  0x00 18.              ",Enable DMA Request 18" "0,1"
  bitfld.long  0x00 17.              ",Enable DMA Request 17" "0,1"
  bitfld.long  0x00 16.              ",Enable DMA Request 16" "0,1"
  TEXTLINE "                  "
  bitfld.long  0x00 15.              "ERQ15-12 ,Enable DMA Request 15" "0,1"
  bitfld.long  0x00 14.              ",Enable DMA Request 14" "0,1"
  bitfld.long  0x00 13.              ",Enable DMA Request 13" "0,1"
  bitfld.long  0x00 12.              ",Enable DMA Request 12" "0,1"
  
  bitfld.long  0x00 11.              "  ERQ11-08 ,Enable DMA Request 11" "0,1"
  bitfld.long  0x00 10.              ",Enable DMA Request 10" "0,1"
  bitfld.long  0x00 09.              ",Enable DMA Request 09" "0,1"
  bitfld.long  0x00 08.              ",Enable DMA Request 08" "0,1"
  
  bitfld.long  0x00 07.              "  ERQ07-04 ,Enable DMA Request 07" "0,1"
  bitfld.long  0x00 06.              ",Enable DMA Request 06" "0,1"
  bitfld.long  0x00 05.              ",Enable DMA Request 05" "0,1"
  bitfld.long  0x00 04.              ",Enable DMA Request 04" "0,1"
  
  bitfld.long  0x00 03.              "  ERQ03-00 ,Enable DMA Request 03" "0,1"
  bitfld.long  0x00 02.              ",Enable DMA Request 02" "0,1"
  bitfld.long  0x00 01.              ",Enable DMA Request 01" "0,1"
  bitfld.long  0x00 00.              ",Enable DMA Request 00" "0,1"

  
TEXTLINE ""
  
group.long (0xfff54000+0x0014)++0x03
  line.long 0x00 "EEIRL,eDMA Enable Error Interrupt Register L"
  bitfld.long  0x00 31.              "EEI31-28 ,Enable error interrupt 31" "0,1"
  bitfld.long  0x00 30.              ",Enable error interrupt 30" "0,1"
  bitfld.long  0x00 29.              ",Enable error interrupt 29" "0,1"
  bitfld.long  0x00 28.              ",Enable error interrupt 28" "0,1"
  
  bitfld.long  0x00 27.              "  EEI27-24 ,Enable error interrupt 27" "0,1"
  bitfld.long  0x00 26.              ",Enable error interrupt 26" "0,1"
  bitfld.long  0x00 25.              ",Enable error interrupt 25" "0,1"
  bitfld.long  0x00 24.              ",Enable error interrupt 24" "0,1"
  
  bitfld.long  0x00 23.              "  EEI23-20 ,Enable error interrupt 23" "0,1"
  bitfld.long  0x00 22.              ",Enable error interrupt 22" "0,1"
  bitfld.long  0x00 21.              ",Enable error interrupt 21" "0,1"
  bitfld.long  0x00 20.              ",Enable error interrupt 20" "0,1"
  
  bitfld.long  0x00 19.              "  EEI19-16 ,Enable error interrupt 19" "0,1"
  bitfld.long  0x00 18.              ",Enable error interrupt 18" "0,1"
  bitfld.long  0x00 17.              ",Enable error interrupt 17" "0,1"
  bitfld.long  0x00 16.              ",Enable error interrupt 16" "0,1"
  TEXTLINE "                  "
  bitfld.long  0x00 15.              "EEI15-12 ,Enable error interrupt 15" "0,1"
  bitfld.long  0x00 14.              ",Enable error interrupt 14" "0,1"
  bitfld.long  0x00 13.              ",Enable error interrupt 13" "0,1"
  bitfld.long  0x00 12.              ",Enable error interrupt 12" "0,1"
  
  bitfld.long  0x00 11.              "  EEI11-08 ,Enable error interrupt 11" "0,1"
  bitfld.long  0x00 10.              ",Enable error interrupt 10" "0,1"
  bitfld.long  0x00 09.              ",Enable error interrupt 09" "0,1"
  bitfld.long  0x00 08.              ",Enable error interrupt 08" "0,1"
  
  bitfld.long  0x00 07.              "  EEI07-04 ,Enable error interrupt 07" "0,1"
  bitfld.long  0x00 06.              ",Enable error interrupt 06" "0,1"
  bitfld.long  0x00 05.              ",Enable error interrupt 05" "0,1"
  bitfld.long  0x00 04.              ",Enable error interrupt 04" "0,1"
  
  bitfld.long  0x00 03.              "  EEI03-00 ,Enable error interrupt 03" "0,1"
  bitfld.long  0x00 02.              ",Enable error interrupt 02" "0,1"
  bitfld.long  0x00 01.              ",Enable error interrupt 01" "0,1"
  bitfld.long  0x00 00.              ",Enable error interrupt 00" "0,1"

TEXTLINE ""

group.byte (0xfff54000+0x0018)++0x03
  line.byte 0x00 "SERQR,eDMA Set Enable Request Register"
  hexmask.byte 0x00 00.--06.  1.     "    SERQ ,Set Enable Request"
  
group.byte (0xfff54000+0x0019)++0x03
  line.byte 0x00 "CERQR,eDMA Clear Enable Request Register"
  hexmask.byte 0x00 00.--06.  1.     "    CERQ ,Clear Enable Request"
  
group.byte (0xfff54000+0x001A)++0x03
  line.byte 0x00 "SEEIR,eDMA Set Enable Error Interrupt Register"
  hexmask.byte 0x00 00.--06.  1.     "    SEEI ,Set enable error interrupt"
  
group.byte (0xfff54000+0x001B)++0x03
  line.byte 0x00 "CEEIR,eDMA Clear Enable Error Interrupt Register"
  hexmask.byte 0x00 00.--06.  1.     "    CEEI ,eDMA Clear Enable Error Interrupt Register"
  
group.byte (0xfff54000+0x001C)++0x03
  line.byte 0x00 "CIRQR,eDMA Clear Interrupt Request Register"
  hexmask.byte 0x00 00.--06.  1.     "    CINT ,Clear interrupt request"
  
wgroup.byte (0xfff54000+0x001D)++0x03
  line.byte 0x00 "CER,eDMA Clear Error Register"
;  hexmask.byte 0x00 00.--06.  1.     "    CERR ,Clear error indicator"
  
wgroup.byte (0xfff54000+0x001E)++0x03
  line.byte 0x00 "SSBR,eDMA Set START Bit Register"
;  hexmask.byte 0x00 00.--06.  1.     "    SSB  ,Set START bit"
  
wgroup.byte (0xfff54000+0x001F)++0x03
  line.byte 0x00 "CDSBR,eDMA Clear DONE Status Bit Register"
;  hexmask.byte 0x00 00.--06.  1.     "    CDSB ,Clear DONE status bit"
  
  
TEXTLINE ""
    
group.long (0xfff54000+0x0024)++0x03
  line.long 0x00 "IRQRL,eDMA Interrupt Request Register L"
  bitfld.long  0x00 31.              "INT31-28 ,eDMA interrupt request 31" "0,1"
  bitfld.long  0x00 30.              ",eDMA interrupt request 30" "0,1"
  bitfld.long  0x00 29.              ",eDMA interrupt request 29" "0,1"
  bitfld.long  0x00 28.              ",eDMA interrupt request 28" "0,1"
  
  bitfld.long  0x00 27.              "  INT27-24 ,eDMA interrupt request 27" "0,1"
  bitfld.long  0x00 26.              ",eDMA interrupt request 26" "0,1"
  bitfld.long  0x00 25.              ",eDMA interrupt request 25" "0,1"
  bitfld.long  0x00 24.              ",eDMA interrupt request 24" "0,1"
  
  bitfld.long  0x00 23.              "  INT23-20 ,eDMA interrupt request 23" "0,1"
  bitfld.long  0x00 22.              ",eDMA interrupt request 22" "0,1"
  bitfld.long  0x00 21.              ",eDMA interrupt request 21" "0,1"
  bitfld.long  0x00 20.              ",eDMA interrupt request 20" "0,1"
  
  bitfld.long  0x00 19.              "  INT19-16 ,eDMA interrupt request 19" "0,1"
  bitfld.long  0x00 18.              ",eDMA interrupt request 18" "0,1"
  bitfld.long  0x00 17.              ",eDMA interrupt request 17" "0,1"
  bitfld.long  0x00 16.              ",eDMA interrupt request 16" "0,1"
  TEXTLINE "                  "
  bitfld.long  0x00 15.              "INT15-12 ,eDMA interrupt request 15" "0,1"
  bitfld.long  0x00 14.              ",eDMA interrupt request 14" "0,1"
  bitfld.long  0x00 13.              ",eDMA interrupt request 13" "0,1"
  bitfld.long  0x00 12.              ",eDMA interrupt request 12" "0,1"
  
  bitfld.long  0x00 11.              "  INT11-08 ,eDMA interrupt request 11" "0,1"
  bitfld.long  0x00 10.              ",eDMA interrupt request 10" "0,1"
  bitfld.long  0x00 09.              ",eDMA interrupt request 09" "0,1"
  bitfld.long  0x00 08.              ",eDMA interrupt request 08" "0,1"
  
  bitfld.long  0x00 07.              "  INT07-04 ,eDMA interrupt request 07" "0,1"
  bitfld.long  0x00 06.              ",eDMA interrupt request 06" "0,1"
  bitfld.long  0x00 05.              ",eDMA interrupt request 05" "0,1"
  bitfld.long  0x00 04.              ",eDMA interrupt request 04" "0,1"
  
  bitfld.long  0x00 03.              "  INT03-00 ,eDMA interrupt request 03" "0,1"
  bitfld.long  0x00 02.              ",eDMA interrupt request 02" "0,1"
  bitfld.long  0x00 01.              ",eDMA interrupt request 01" "0,1"
  bitfld.long  0x00 00.              ",eDMA interrupt request 00" "0,1"


TEXTLINE ""
    
group.long (0xfff54000+0x002C)++0x03
  line.long 0x00 "ERL,eDMA Error Register L"
  bitfld.long  0x00 31.              "ERR31-28 ,eDMA Error 31" "0,1"
  bitfld.long  0x00 30.              ",eDMA Error 30" "0,1"
  bitfld.long  0x00 29.              ",eDMA Error 29" "0,1"
  bitfld.long  0x00 28.              ",eDMA Error 28" "0,1"
  
  bitfld.long  0x00 27.              "  ERR27-24 ,eDMA Error 27" "0,1"
  bitfld.long  0x00 26.              ",eDMA Error 26" "0,1"
  bitfld.long  0x00 25.              ",eDMA Error 25" "0,1"
  bitfld.long  0x00 24.              ",eDMA Error 24" "0,1"
  
  bitfld.long  0x00 23.              "  ERR23-20 ,eDMA Error 23" "0,1"
  bitfld.long  0x00 22.              ",eDMA Error 22" "0,1"
  bitfld.long  0x00 21.              ",eDMA Error 21" "0,1"
  bitfld.long  0x00 20.              ",eDMA Error 20" "0,1"
  
  bitfld.long  0x00 19.              "  ERR19-16 ,eDMA Error 19" "0,1"
  bitfld.long  0x00 18.              ",eDMA Error 18" "0,1"
  bitfld.long  0x00 17.              ",eDMA Error 17" "0,1"
  bitfld.long  0x00 16.              ",eDMA Error 16" "0,1"
  TEXTLINE "                  "
  bitfld.long  0x00 15.              "ERR15-12 ,eDMA Error 15" "0,1"
  bitfld.long  0x00 14.              ",eDMA Error 14" "0,1"
  bitfld.long  0x00 13.              ",eDMA Error 13" "0,1"
  bitfld.long  0x00 12.              ",eDMA Error 12" "0,1"
  
  bitfld.long  0x00 11.              "  ERR11-08 ,eDMA Error 11" "0,1"
  bitfld.long  0x00 10.              ",eDMA Error 10" "0,1"
  bitfld.long  0x00 09.              ",eDMA Error 09" "0,1"
  bitfld.long  0x00 08.              ",eDMA Error 08" "0,1"
  
  bitfld.long  0x00 07.              "  ERR07-04 ,eDMA Error 07" "0,1"
  bitfld.long  0x00 06.              ",eDMA Error 06" "0,1"
  bitfld.long  0x00 05.              ",eDMA Error 05" "0,1"
  bitfld.long  0x00 04.              ",eDMA Error 04" "0,1"
  
  bitfld.long  0x00 03.              "  ERR03-00 ,eDMA Error 03" "0,1"
  bitfld.long  0x00 02.              ",eDMA Error 02" "0,1"
  bitfld.long  0x00 01.              ",eDMA Error 01" "0,1"
  bitfld.long  0x00 00.              ",eDMA Error 00" "0,1"

tree "eDMA Channel Priority Registers"
group.byte (0xfff54000+0x100+00.)++0x00
  line.byte    0x00 "CPR00,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 00 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 00 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 00 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff54000+0x100+01.)++0x00
  line.byte    0x00 "CPR01,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 01 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 01 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 01 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff54000+0x100+02.)++0x00
  line.byte    0x00 "CPR02,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 02 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 02 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 02 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff54000+0x100+03.)++0x00
  line.byte    0x00 "CPR03,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 03 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 03 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 03 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff54000+0x100+04.)++0x00
  line.byte    0x00 "CPR04,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 04 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 04 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 04 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff54000+0x100+05.)++0x00
  line.byte    0x00 "CPR05,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 05 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 05 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 05 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff54000+0x100+06.)++0x00
  line.byte    0x00 "CPR06,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 06 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 06 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 06 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff54000+0x100+07.)++0x00
  line.byte    0x00 "CPR07,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 07 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 07 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 07 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff54000+0x100+08.)++0x00
  line.byte    0x00 "CPR08,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 08 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 08 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 08 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff54000+0x100+09.)++0x00
  line.byte    0x00 "CPR09,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 09 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 09 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 09 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff54000+0x100+10.)++0x00
  line.byte    0x00 "CPR10,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 10 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 10 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 10 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff54000+0x100+11.)++0x00
  line.byte    0x00 "CPR11,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 11 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 11 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 11 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff54000+0x100+12.)++0x00
  line.byte    0x00 "CPR12,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 12 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 12 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 12 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff54000+0x100+13.)++0x00
  line.byte    0x00 "CPR13,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 13 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 13 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 13 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff54000+0x100+14.)++0x00
  line.byte    0x00 "CPR14,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 14 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 14 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 14 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff54000+0x100+15.)++0x00
  line.byte    0x00 "CPR15,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 15 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 15 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 15 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff54000+0x100+16.)++0x00
  line.byte    0x00 "CPR16,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 16 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 16 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 16 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff54000+0x100+17.)++0x00
  line.byte    0x00 "CPR17,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 17 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 17 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 17 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff54000+0x100+18.)++0x00
  line.byte    0x00 "CPR18,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 18 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 18 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 18 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff54000+0x100+19.)++0x00
  line.byte    0x00 "CPR19,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 19 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 19 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 19 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff54000+0x100+20.)++0x00
  line.byte    0x00 "CPR20,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 20 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 20 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 20 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff54000+0x100+21.)++0x00
  line.byte    0x00 "CPR21,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 21 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 21 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 21 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff54000+0x100+22.)++0x00
  line.byte    0x00 "CPR22,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 22 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 22 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 22 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff54000+0x100+23.)++0x00
  line.byte    0x00 "CPR23,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 23 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 23 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 23 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff54000+0x100+24.)++0x00
  line.byte    0x00 "CPR24,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 24 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 24 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 24 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff54000+0x100+25.)++0x00
  line.byte    0x00 "CPR25,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 25 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 25 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 25 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff54000+0x100+26.)++0x00
  line.byte    0x00 "CPR26,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 26 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 26 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 26 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff54000+0x100+27.)++0x00
  line.byte    0x00 "CPR27,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 27 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 27 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 27 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff54000+0x100+28.)++0x00
  line.byte    0x00 "CPR28,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 28 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 28 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 28 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff54000+0x100+29.)++0x00
  line.byte    0x00 "CPR29,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 29 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 29 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 29 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff54000+0x100+30.)++0x00
  line.byte    0x00 "CPR30,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 30 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 30 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 30 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
group.byte (0xfff54000+0x100+31.)++0x00
  line.byte    0x00 "CPR31,eDMA Channel Priority Register"
  bitfld.byte  0x00 07.              "ECP ,Enable channel 31 preemption" "0,1"
  bitfld.byte  0x00 04.--05.         "  GRPPRI ,Channel 31 current group priority" "0,1,2,3"
  bitfld.byte  0x00 00.--03.         "  CHPRI ,Channel 31 current arbitration priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
tree.end

tree "eDMA Transfer Control Descriptors"
group.long (0xfff54000+0x1000+(00.)*0x20)++0x1F
  TEXTLINE "Channel 00 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff54000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff54000+0x1008+(00.)*0x20)&0xC0000000)==0)
 group.long (0xfff54000+0x1000+(00.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff54000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff54000+0x1008+(00.)*0x20)&0xC0000000)!=0)
 group.long (0xfff54000+0x1000+(00.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff54000)&0x00000080)==0x00000000
 group.long (0xfff54000+0x1000+(00.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff54000+0x1000+(00.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff54000+0x1014+(00.)*0x20)&0x80000000)==0x80000000
group.long (0xfff54000+0x1000+(00.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff54000+0x1000+(00.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff54000+0x1000+(00.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff54000+0x101C+(00.)*0x20)&0x80000000)==0x80000000
group.long (0xfff54000+0x1000+(00.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff54000+0x1000+(00.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff54000+0x1000+(01.)*0x20)++0x1F
  TEXTLINE "Channel 01 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff54000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff54000+0x1008+(01.)*0x20)&0xC0000000)==0)
 group.long (0xfff54000+0x1000+(01.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff54000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff54000+0x1008+(01.)*0x20)&0xC0000000)!=0)
 group.long (0xfff54000+0x1000+(01.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff54000)&0x00000080)==0x00000000
 group.long (0xfff54000+0x1000+(01.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff54000+0x1000+(01.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff54000+0x1014+(01.)*0x20)&0x80000000)==0x80000000
group.long (0xfff54000+0x1000+(01.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff54000+0x1000+(01.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff54000+0x1000+(01.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff54000+0x101C+(01.)*0x20)&0x80000000)==0x80000000
group.long (0xfff54000+0x1000+(01.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff54000+0x1000+(01.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff54000+0x1000+(02.)*0x20)++0x1F
  TEXTLINE "Channel 02 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff54000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff54000+0x1008+(02.)*0x20)&0xC0000000)==0)
 group.long (0xfff54000+0x1000+(02.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff54000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff54000+0x1008+(02.)*0x20)&0xC0000000)!=0)
 group.long (0xfff54000+0x1000+(02.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff54000)&0x00000080)==0x00000000
 group.long (0xfff54000+0x1000+(02.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff54000+0x1000+(02.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff54000+0x1014+(02.)*0x20)&0x80000000)==0x80000000
group.long (0xfff54000+0x1000+(02.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff54000+0x1000+(02.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff54000+0x1000+(02.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff54000+0x101C+(02.)*0x20)&0x80000000)==0x80000000
group.long (0xfff54000+0x1000+(02.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff54000+0x1000+(02.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff54000+0x1000+(03.)*0x20)++0x1F
  TEXTLINE "Channel 03 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff54000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff54000+0x1008+(03.)*0x20)&0xC0000000)==0)
 group.long (0xfff54000+0x1000+(03.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff54000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff54000+0x1008+(03.)*0x20)&0xC0000000)!=0)
 group.long (0xfff54000+0x1000+(03.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff54000)&0x00000080)==0x00000000
 group.long (0xfff54000+0x1000+(03.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff54000+0x1000+(03.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff54000+0x1014+(03.)*0x20)&0x80000000)==0x80000000
group.long (0xfff54000+0x1000+(03.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff54000+0x1000+(03.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff54000+0x1000+(03.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff54000+0x101C+(03.)*0x20)&0x80000000)==0x80000000
group.long (0xfff54000+0x1000+(03.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff54000+0x1000+(03.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff54000+0x1000+(04.)*0x20)++0x1F
  TEXTLINE "Channel 04 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff54000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff54000+0x1008+(04.)*0x20)&0xC0000000)==0)
 group.long (0xfff54000+0x1000+(04.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff54000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff54000+0x1008+(04.)*0x20)&0xC0000000)!=0)
 group.long (0xfff54000+0x1000+(04.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff54000)&0x00000080)==0x00000000
 group.long (0xfff54000+0x1000+(04.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff54000+0x1000+(04.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff54000+0x1014+(04.)*0x20)&0x80000000)==0x80000000
group.long (0xfff54000+0x1000+(04.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff54000+0x1000+(04.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff54000+0x1000+(04.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff54000+0x101C+(04.)*0x20)&0x80000000)==0x80000000
group.long (0xfff54000+0x1000+(04.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff54000+0x1000+(04.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff54000+0x1000+(05.)*0x20)++0x1F
  TEXTLINE "Channel 05 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff54000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff54000+0x1008+(05.)*0x20)&0xC0000000)==0)
 group.long (0xfff54000+0x1000+(05.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff54000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff54000+0x1008+(05.)*0x20)&0xC0000000)!=0)
 group.long (0xfff54000+0x1000+(05.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff54000)&0x00000080)==0x00000000
 group.long (0xfff54000+0x1000+(05.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff54000+0x1000+(05.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff54000+0x1014+(05.)*0x20)&0x80000000)==0x80000000
group.long (0xfff54000+0x1000+(05.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff54000+0x1000+(05.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff54000+0x1000+(05.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff54000+0x101C+(05.)*0x20)&0x80000000)==0x80000000
group.long (0xfff54000+0x1000+(05.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff54000+0x1000+(05.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff54000+0x1000+(06.)*0x20)++0x1F
  TEXTLINE "Channel 06 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff54000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff54000+0x1008+(06.)*0x20)&0xC0000000)==0)
 group.long (0xfff54000+0x1000+(06.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff54000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff54000+0x1008+(06.)*0x20)&0xC0000000)!=0)
 group.long (0xfff54000+0x1000+(06.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff54000)&0x00000080)==0x00000000
 group.long (0xfff54000+0x1000+(06.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff54000+0x1000+(06.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff54000+0x1014+(06.)*0x20)&0x80000000)==0x80000000
group.long (0xfff54000+0x1000+(06.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff54000+0x1000+(06.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff54000+0x1000+(06.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff54000+0x101C+(06.)*0x20)&0x80000000)==0x80000000
group.long (0xfff54000+0x1000+(06.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff54000+0x1000+(06.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff54000+0x1000+(07.)*0x20)++0x1F
  TEXTLINE "Channel 07 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff54000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff54000+0x1008+(07.)*0x20)&0xC0000000)==0)
 group.long (0xfff54000+0x1000+(07.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff54000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff54000+0x1008+(07.)*0x20)&0xC0000000)!=0)
 group.long (0xfff54000+0x1000+(07.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff54000)&0x00000080)==0x00000000
 group.long (0xfff54000+0x1000+(07.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff54000+0x1000+(07.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff54000+0x1014+(07.)*0x20)&0x80000000)==0x80000000
group.long (0xfff54000+0x1000+(07.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff54000+0x1000+(07.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff54000+0x1000+(07.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff54000+0x101C+(07.)*0x20)&0x80000000)==0x80000000
group.long (0xfff54000+0x1000+(07.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff54000+0x1000+(07.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff54000+0x1000+(08.)*0x20)++0x1F
  TEXTLINE "Channel 08 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff54000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff54000+0x1008+(08.)*0x20)&0xC0000000)==0)
 group.long (0xfff54000+0x1000+(08.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff54000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff54000+0x1008+(08.)*0x20)&0xC0000000)!=0)
 group.long (0xfff54000+0x1000+(08.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff54000)&0x00000080)==0x00000000
 group.long (0xfff54000+0x1000+(08.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff54000+0x1000+(08.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff54000+0x1014+(08.)*0x20)&0x80000000)==0x80000000
group.long (0xfff54000+0x1000+(08.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff54000+0x1000+(08.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff54000+0x1000+(08.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff54000+0x101C+(08.)*0x20)&0x80000000)==0x80000000
group.long (0xfff54000+0x1000+(08.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff54000+0x1000+(08.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff54000+0x1000+(09.)*0x20)++0x1F
  TEXTLINE "Channel 09 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff54000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff54000+0x1008+(09.)*0x20)&0xC0000000)==0)
 group.long (0xfff54000+0x1000+(09.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff54000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff54000+0x1008+(09.)*0x20)&0xC0000000)!=0)
 group.long (0xfff54000+0x1000+(09.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff54000)&0x00000080)==0x00000000
 group.long (0xfff54000+0x1000+(09.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff54000+0x1000+(09.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff54000+0x1014+(09.)*0x20)&0x80000000)==0x80000000
group.long (0xfff54000+0x1000+(09.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff54000+0x1000+(09.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff54000+0x1000+(09.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff54000+0x101C+(09.)*0x20)&0x80000000)==0x80000000
group.long (0xfff54000+0x1000+(09.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff54000+0x1000+(09.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff54000+0x1000+(10.)*0x20)++0x1F
  TEXTLINE "Channel 10 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff54000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff54000+0x1008+(10.)*0x20)&0xC0000000)==0)
 group.long (0xfff54000+0x1000+(10.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff54000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff54000+0x1008+(10.)*0x20)&0xC0000000)!=0)
 group.long (0xfff54000+0x1000+(10.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff54000)&0x00000080)==0x00000000
 group.long (0xfff54000+0x1000+(10.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff54000+0x1000+(10.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff54000+0x1014+(10.)*0x20)&0x80000000)==0x80000000
group.long (0xfff54000+0x1000+(10.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff54000+0x1000+(10.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff54000+0x1000+(10.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff54000+0x101C+(10.)*0x20)&0x80000000)==0x80000000
group.long (0xfff54000+0x1000+(10.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff54000+0x1000+(10.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff54000+0x1000+(11.)*0x20)++0x1F
  TEXTLINE "Channel 11 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff54000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff54000+0x1008+(11.)*0x20)&0xC0000000)==0)
 group.long (0xfff54000+0x1000+(11.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff54000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff54000+0x1008+(11.)*0x20)&0xC0000000)!=0)
 group.long (0xfff54000+0x1000+(11.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff54000)&0x00000080)==0x00000000
 group.long (0xfff54000+0x1000+(11.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff54000+0x1000+(11.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff54000+0x1014+(11.)*0x20)&0x80000000)==0x80000000
group.long (0xfff54000+0x1000+(11.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff54000+0x1000+(11.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff54000+0x1000+(11.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff54000+0x101C+(11.)*0x20)&0x80000000)==0x80000000
group.long (0xfff54000+0x1000+(11.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff54000+0x1000+(11.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff54000+0x1000+(12.)*0x20)++0x1F
  TEXTLINE "Channel 12 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff54000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff54000+0x1008+(12.)*0x20)&0xC0000000)==0)
 group.long (0xfff54000+0x1000+(12.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff54000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff54000+0x1008+(12.)*0x20)&0xC0000000)!=0)
 group.long (0xfff54000+0x1000+(12.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff54000)&0x00000080)==0x00000000
 group.long (0xfff54000+0x1000+(12.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff54000+0x1000+(12.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff54000+0x1014+(12.)*0x20)&0x80000000)==0x80000000
group.long (0xfff54000+0x1000+(12.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff54000+0x1000+(12.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff54000+0x1000+(12.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff54000+0x101C+(12.)*0x20)&0x80000000)==0x80000000
group.long (0xfff54000+0x1000+(12.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff54000+0x1000+(12.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff54000+0x1000+(13.)*0x20)++0x1F
  TEXTLINE "Channel 13 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff54000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff54000+0x1008+(13.)*0x20)&0xC0000000)==0)
 group.long (0xfff54000+0x1000+(13.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff54000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff54000+0x1008+(13.)*0x20)&0xC0000000)!=0)
 group.long (0xfff54000+0x1000+(13.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff54000)&0x00000080)==0x00000000
 group.long (0xfff54000+0x1000+(13.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff54000+0x1000+(13.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff54000+0x1014+(13.)*0x20)&0x80000000)==0x80000000
group.long (0xfff54000+0x1000+(13.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff54000+0x1000+(13.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff54000+0x1000+(13.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff54000+0x101C+(13.)*0x20)&0x80000000)==0x80000000
group.long (0xfff54000+0x1000+(13.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff54000+0x1000+(13.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff54000+0x1000+(14.)*0x20)++0x1F
  TEXTLINE "Channel 14 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff54000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff54000+0x1008+(14.)*0x20)&0xC0000000)==0)
 group.long (0xfff54000+0x1000+(14.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff54000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff54000+0x1008+(14.)*0x20)&0xC0000000)!=0)
 group.long (0xfff54000+0x1000+(14.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff54000)&0x00000080)==0x00000000
 group.long (0xfff54000+0x1000+(14.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff54000+0x1000+(14.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff54000+0x1014+(14.)*0x20)&0x80000000)==0x80000000
group.long (0xfff54000+0x1000+(14.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff54000+0x1000+(14.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff54000+0x1000+(14.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff54000+0x101C+(14.)*0x20)&0x80000000)==0x80000000
group.long (0xfff54000+0x1000+(14.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff54000+0x1000+(14.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff54000+0x1000+(15.)*0x20)++0x1F
  TEXTLINE "Channel 15 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff54000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff54000+0x1008+(15.)*0x20)&0xC0000000)==0)
 group.long (0xfff54000+0x1000+(15.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff54000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff54000+0x1008+(15.)*0x20)&0xC0000000)!=0)
 group.long (0xfff54000+0x1000+(15.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff54000)&0x00000080)==0x00000000
 group.long (0xfff54000+0x1000+(15.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff54000+0x1000+(15.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff54000+0x1014+(15.)*0x20)&0x80000000)==0x80000000
group.long (0xfff54000+0x1000+(15.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff54000+0x1000+(15.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff54000+0x1000+(15.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff54000+0x101C+(15.)*0x20)&0x80000000)==0x80000000
group.long (0xfff54000+0x1000+(15.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff54000+0x1000+(15.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff54000+0x1000+(16.)*0x20)++0x1F
  TEXTLINE "Channel 16 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff54000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff54000+0x1008+(16.)*0x20)&0xC0000000)==0)
 group.long (0xfff54000+0x1000+(16.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff54000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff54000+0x1008+(16.)*0x20)&0xC0000000)!=0)
 group.long (0xfff54000+0x1000+(16.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff54000)&0x00000080)==0x00000000
 group.long (0xfff54000+0x1000+(16.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff54000+0x1000+(16.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff54000+0x1014+(16.)*0x20)&0x80000000)==0x80000000
group.long (0xfff54000+0x1000+(16.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff54000+0x1000+(16.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff54000+0x1000+(16.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff54000+0x101C+(16.)*0x20)&0x80000000)==0x80000000
group.long (0xfff54000+0x1000+(16.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff54000+0x1000+(16.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff54000+0x1000+(17.)*0x20)++0x1F
  TEXTLINE "Channel 17 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff54000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff54000+0x1008+(17.)*0x20)&0xC0000000)==0)
 group.long (0xfff54000+0x1000+(17.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff54000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff54000+0x1008+(17.)*0x20)&0xC0000000)!=0)
 group.long (0xfff54000+0x1000+(17.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff54000)&0x00000080)==0x00000000
 group.long (0xfff54000+0x1000+(17.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff54000+0x1000+(17.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff54000+0x1014+(17.)*0x20)&0x80000000)==0x80000000
group.long (0xfff54000+0x1000+(17.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff54000+0x1000+(17.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff54000+0x1000+(17.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff54000+0x101C+(17.)*0x20)&0x80000000)==0x80000000
group.long (0xfff54000+0x1000+(17.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff54000+0x1000+(17.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff54000+0x1000+(18.)*0x20)++0x1F
  TEXTLINE "Channel 18 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff54000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff54000+0x1008+(18.)*0x20)&0xC0000000)==0)
 group.long (0xfff54000+0x1000+(18.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff54000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff54000+0x1008+(18.)*0x20)&0xC0000000)!=0)
 group.long (0xfff54000+0x1000+(18.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff54000)&0x00000080)==0x00000000
 group.long (0xfff54000+0x1000+(18.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff54000+0x1000+(18.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff54000+0x1014+(18.)*0x20)&0x80000000)==0x80000000
group.long (0xfff54000+0x1000+(18.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff54000+0x1000+(18.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff54000+0x1000+(18.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff54000+0x101C+(18.)*0x20)&0x80000000)==0x80000000
group.long (0xfff54000+0x1000+(18.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff54000+0x1000+(18.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff54000+0x1000+(19.)*0x20)++0x1F
  TEXTLINE "Channel 19 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff54000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff54000+0x1008+(19.)*0x20)&0xC0000000)==0)
 group.long (0xfff54000+0x1000+(19.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff54000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff54000+0x1008+(19.)*0x20)&0xC0000000)!=0)
 group.long (0xfff54000+0x1000+(19.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff54000)&0x00000080)==0x00000000
 group.long (0xfff54000+0x1000+(19.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff54000+0x1000+(19.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff54000+0x1014+(19.)*0x20)&0x80000000)==0x80000000
group.long (0xfff54000+0x1000+(19.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff54000+0x1000+(19.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff54000+0x1000+(19.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff54000+0x101C+(19.)*0x20)&0x80000000)==0x80000000
group.long (0xfff54000+0x1000+(19.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff54000+0x1000+(19.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff54000+0x1000+(20.)*0x20)++0x1F
  TEXTLINE "Channel 20 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff54000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff54000+0x1008+(20.)*0x20)&0xC0000000)==0)
 group.long (0xfff54000+0x1000+(20.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff54000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff54000+0x1008+(20.)*0x20)&0xC0000000)!=0)
 group.long (0xfff54000+0x1000+(20.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff54000)&0x00000080)==0x00000000
 group.long (0xfff54000+0x1000+(20.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff54000+0x1000+(20.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff54000+0x1014+(20.)*0x20)&0x80000000)==0x80000000
group.long (0xfff54000+0x1000+(20.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff54000+0x1000+(20.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff54000+0x1000+(20.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff54000+0x101C+(20.)*0x20)&0x80000000)==0x80000000
group.long (0xfff54000+0x1000+(20.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff54000+0x1000+(20.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff54000+0x1000+(21.)*0x20)++0x1F
  TEXTLINE "Channel 21 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff54000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff54000+0x1008+(21.)*0x20)&0xC0000000)==0)
 group.long (0xfff54000+0x1000+(21.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff54000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff54000+0x1008+(21.)*0x20)&0xC0000000)!=0)
 group.long (0xfff54000+0x1000+(21.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff54000)&0x00000080)==0x00000000
 group.long (0xfff54000+0x1000+(21.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff54000+0x1000+(21.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff54000+0x1014+(21.)*0x20)&0x80000000)==0x80000000
group.long (0xfff54000+0x1000+(21.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff54000+0x1000+(21.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff54000+0x1000+(21.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff54000+0x101C+(21.)*0x20)&0x80000000)==0x80000000
group.long (0xfff54000+0x1000+(21.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff54000+0x1000+(21.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff54000+0x1000+(22.)*0x20)++0x1F
  TEXTLINE "Channel 22 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff54000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff54000+0x1008+(22.)*0x20)&0xC0000000)==0)
 group.long (0xfff54000+0x1000+(22.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff54000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff54000+0x1008+(22.)*0x20)&0xC0000000)!=0)
 group.long (0xfff54000+0x1000+(22.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff54000)&0x00000080)==0x00000000
 group.long (0xfff54000+0x1000+(22.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff54000+0x1000+(22.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff54000+0x1014+(22.)*0x20)&0x80000000)==0x80000000
group.long (0xfff54000+0x1000+(22.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff54000+0x1000+(22.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff54000+0x1000+(22.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff54000+0x101C+(22.)*0x20)&0x80000000)==0x80000000
group.long (0xfff54000+0x1000+(22.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff54000+0x1000+(22.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff54000+0x1000+(23.)*0x20)++0x1F
  TEXTLINE "Channel 23 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff54000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff54000+0x1008+(23.)*0x20)&0xC0000000)==0)
 group.long (0xfff54000+0x1000+(23.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff54000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff54000+0x1008+(23.)*0x20)&0xC0000000)!=0)
 group.long (0xfff54000+0x1000+(23.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff54000)&0x00000080)==0x00000000
 group.long (0xfff54000+0x1000+(23.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff54000+0x1000+(23.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff54000+0x1014+(23.)*0x20)&0x80000000)==0x80000000
group.long (0xfff54000+0x1000+(23.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff54000+0x1000+(23.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff54000+0x1000+(23.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff54000+0x101C+(23.)*0x20)&0x80000000)==0x80000000
group.long (0xfff54000+0x1000+(23.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff54000+0x1000+(23.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff54000+0x1000+(24.)*0x20)++0x1F
  TEXTLINE "Channel 24 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff54000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff54000+0x1008+(24.)*0x20)&0xC0000000)==0)
 group.long (0xfff54000+0x1000+(24.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff54000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff54000+0x1008+(24.)*0x20)&0xC0000000)!=0)
 group.long (0xfff54000+0x1000+(24.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff54000)&0x00000080)==0x00000000
 group.long (0xfff54000+0x1000+(24.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff54000+0x1000+(24.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff54000+0x1014+(24.)*0x20)&0x80000000)==0x80000000
group.long (0xfff54000+0x1000+(24.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff54000+0x1000+(24.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff54000+0x1000+(24.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff54000+0x101C+(24.)*0x20)&0x80000000)==0x80000000
group.long (0xfff54000+0x1000+(24.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff54000+0x1000+(24.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff54000+0x1000+(25.)*0x20)++0x1F
  TEXTLINE "Channel 25 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff54000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff54000+0x1008+(25.)*0x20)&0xC0000000)==0)
 group.long (0xfff54000+0x1000+(25.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff54000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff54000+0x1008+(25.)*0x20)&0xC0000000)!=0)
 group.long (0xfff54000+0x1000+(25.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff54000)&0x00000080)==0x00000000
 group.long (0xfff54000+0x1000+(25.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff54000+0x1000+(25.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff54000+0x1014+(25.)*0x20)&0x80000000)==0x80000000
group.long (0xfff54000+0x1000+(25.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff54000+0x1000+(25.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff54000+0x1000+(25.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff54000+0x101C+(25.)*0x20)&0x80000000)==0x80000000
group.long (0xfff54000+0x1000+(25.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff54000+0x1000+(25.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff54000+0x1000+(26.)*0x20)++0x1F
  TEXTLINE "Channel 26 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff54000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff54000+0x1008+(26.)*0x20)&0xC0000000)==0)
 group.long (0xfff54000+0x1000+(26.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff54000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff54000+0x1008+(26.)*0x20)&0xC0000000)!=0)
 group.long (0xfff54000+0x1000+(26.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff54000)&0x00000080)==0x00000000
 group.long (0xfff54000+0x1000+(26.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff54000+0x1000+(26.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff54000+0x1014+(26.)*0x20)&0x80000000)==0x80000000
group.long (0xfff54000+0x1000+(26.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff54000+0x1000+(26.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff54000+0x1000+(26.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff54000+0x101C+(26.)*0x20)&0x80000000)==0x80000000
group.long (0xfff54000+0x1000+(26.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff54000+0x1000+(26.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff54000+0x1000+(27.)*0x20)++0x1F
  TEXTLINE "Channel 27 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff54000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff54000+0x1008+(27.)*0x20)&0xC0000000)==0)
 group.long (0xfff54000+0x1000+(27.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff54000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff54000+0x1008+(27.)*0x20)&0xC0000000)!=0)
 group.long (0xfff54000+0x1000+(27.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff54000)&0x00000080)==0x00000000
 group.long (0xfff54000+0x1000+(27.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff54000+0x1000+(27.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff54000+0x1014+(27.)*0x20)&0x80000000)==0x80000000
group.long (0xfff54000+0x1000+(27.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff54000+0x1000+(27.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff54000+0x1000+(27.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff54000+0x101C+(27.)*0x20)&0x80000000)==0x80000000
group.long (0xfff54000+0x1000+(27.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff54000+0x1000+(27.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff54000+0x1000+(28.)*0x20)++0x1F
  TEXTLINE "Channel 28 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff54000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff54000+0x1008+(28.)*0x20)&0xC0000000)==0)
 group.long (0xfff54000+0x1000+(28.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff54000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff54000+0x1008+(28.)*0x20)&0xC0000000)!=0)
 group.long (0xfff54000+0x1000+(28.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff54000)&0x00000080)==0x00000000
 group.long (0xfff54000+0x1000+(28.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff54000+0x1000+(28.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff54000+0x1014+(28.)*0x20)&0x80000000)==0x80000000
group.long (0xfff54000+0x1000+(28.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff54000+0x1000+(28.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff54000+0x1000+(28.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff54000+0x101C+(28.)*0x20)&0x80000000)==0x80000000
group.long (0xfff54000+0x1000+(28.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff54000+0x1000+(28.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff54000+0x1000+(29.)*0x20)++0x1F
  TEXTLINE "Channel 29 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff54000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff54000+0x1008+(29.)*0x20)&0xC0000000)==0)
 group.long (0xfff54000+0x1000+(29.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff54000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff54000+0x1008+(29.)*0x20)&0xC0000000)!=0)
 group.long (0xfff54000+0x1000+(29.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff54000)&0x00000080)==0x00000000
 group.long (0xfff54000+0x1000+(29.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff54000+0x1000+(29.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff54000+0x1014+(29.)*0x20)&0x80000000)==0x80000000
group.long (0xfff54000+0x1000+(29.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff54000+0x1000+(29.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff54000+0x1000+(29.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff54000+0x101C+(29.)*0x20)&0x80000000)==0x80000000
group.long (0xfff54000+0x1000+(29.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff54000+0x1000+(29.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff54000+0x1000+(30.)*0x20)++0x1F
  TEXTLINE "Channel 30 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff54000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff54000+0x1008+(30.)*0x20)&0xC0000000)==0)
 group.long (0xfff54000+0x1000+(30.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff54000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff54000+0x1008+(30.)*0x20)&0xC0000000)!=0)
 group.long (0xfff54000+0x1000+(30.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff54000)&0x00000080)==0x00000000
 group.long (0xfff54000+0x1000+(30.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff54000+0x1000+(30.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff54000+0x1014+(30.)*0x20)&0x80000000)==0x80000000
group.long (0xfff54000+0x1000+(30.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff54000+0x1000+(30.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff54000+0x1000+(30.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff54000+0x101C+(30.)*0x20)&0x80000000)==0x80000000
group.long (0xfff54000+0x1000+(30.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff54000+0x1000+(30.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



group.long (0xfff54000+0x1000+(31.)*0x20)++0x1F
  TEXTLINE "Channel 31 Transfer Control Descriptor"
  line.long    0x00 "Word 0,Word 0" 
  hexmask.long 0x00 00.--31. 1.           "SADDR  ,Source Address"

  line.long    0x04 "Word 1,Word 1" 
  hexmask.byte 0x04 03.--07. 1.           "SMOD   ,Source Address Modulo"
  bitfld.long  0x04 24.--26.              "       SSIZE ,Source data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.byte 0x05 03.--07. 1.           "  DMOD ,Destination Address Modulo"
  bitfld.long  0x04 16.--18.              "  DSIZE ,Destination data transfer size" "8 bit,16 bit,32 bit,64 bit,16 byte,32 byte,res.,res."
  hexmask.word 0x06 00.--15. 1.           "  SOFF ,Source address signed offset"

if ((data.long(anc:0xfff54000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff54000+0x1008+(31.)*0x20)&0xC0000000)==0)
 group.long (0xfff54000+0x1000+(31.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 00.--29. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif ((data.long(anc:0xfff54000)&0x00000080)==0x00000080)&&((data.long(anc:0xfff54000+0x1008+(31.)*0x20)&0xC0000000)!=0)
 group.long (0xfff54000+0x1000+(31.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   bitfld.long  0x08 31.                "SMLOE ,Source minor loop offset enable" "0,1"
   bitfld.long  0x08 30.              "  DMLOE ,Destination minor loop offset enable" "0,1"
   hexmask.long 0x08 10.--29. 1.      "  MLOFF ,Inner -minor- byte transfer count or Minor loop offset"
   hexmask.long.word 0x08 00.--09. 1.      "  NBYTES ,Inner -minor- byte transfer count"
elif (data.long(anc:0xfff54000)&0x00000080)==0x00000000
 group.long (0xfff54000+0x1000+(31.)*0x20)++0x1F
   line.long    0x08 "Word 2,Word 2" 
   hexmask.long 0x08 00.--31. 1.           "NBYTES ,Inner -minor- byte transfer count"
endif

group.long (0xfff54000+0x1000+(31.)*0x20)++0x1F
  line.long    0x0C "Word 3,Word 3" 
  hexmask.long 0x0C 00.--31. 1.           "SLAST  ,Last source address adjustment"

  line.long    0x10 "Word 4,Word 4" 
  hexmask.long 0x10 00.--31. 1.           "DADDR  ,Destination address"

if   (d.l(a:0xfff54000+0x1014+(31.)*0x20)&0x80000000)==0x80000000
group.long (0xfff54000+0x1000+(31.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 09.--14. 1.           "  CITER.LINKCH ,Link channel number"
  hexmask.word 0x14 00.--08. 1.           "  CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

else

group.long (0xfff54000+0x1000+(31.)*0x20)++0x1F
  line.long    0x14 "Word 5,Word 5" 
  bitfld.long  0x14 31.                     "CITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"
  hexmask.word 0x14 00.--14. 1.           "                     CITER ,Current -major- iteration count"
  hexmask.word 0x16 00.--15. 1.           "  DOFF ,Destination address signed offset"

endif





group.long (0xfff54000+0x1000+(31.)*0x20)++0x1F
  line.long    0x18 "Word 6,Word 6" 
  hexmask.long 0x18 00.--31. 1.           "DLAST_SGA ,Last destination address adjustment or the memory address for the next Transfer Control Descriptor to be loaded into this channel (scatter/gather)"





if (d.l(a:0xfff54000+0x101C+(31.)*0x20)&0x80000000)==0x80000000
group.long (0xfff54000+0x1000+(31.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 09.--14. 1.           "  BITER.LINKCH ,Link channel number"
  hexmask.word 0x1C 00.--08. 1.           "  BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
else

group.long (0xfff54000+0x1000+(31.)*0x20)++0x1F
  line.long    0x1C "Word 7,Word 7" 
  bitfld.long  0x1C 31.                     "BITER.E_LINK ,Enable channel-to-channel linking on minor loop complete" "0,1"

  hexmask.word 0x1C 00.--14. 1.           "                     BITER ,Current -major- iteration count"

  bitfld.long  0x1C 14.--15.              "  BWC ,Bandwidth control" "no stalls,dynamic,4 cycles,8 cycles"
  TEXTLINE "                "
  hexmask.word 0x1E 08.--13. 1.           "  MAJOR.LINKCH ,Link channel number"
  bitfld.long  0x1C 07.                   "  DONE     ,Channel done" "0,1"
  bitfld.long  0x1C 06.                   "  ACTIVE  ,Channel active" "0,1"
  bitfld.long  0x1C 05.                   "  MAJOR.E_LINK ,Enable channel-to-channel linking on major loop complete" "0,1"
  bitfld.long  0x1C 04.                   "  E_SG ,Enable scatter/gather processing" "0,1"
  
  
  TEXTLINE "                "
  bitfld.long  0x1C 03.                   "  D_REQ        ,Disable request" "0,1"
  bitfld.long  0x1C 02.                   "     INT_HALF ,Enable an interrupt when major counter is half complete" "0,1"
  bitfld.long  0x1C 01.                   "  INT_MAJ ,Enable an interrupt when major iteration count completes" "0,1"
  bitfld.long  0x1C 00.                   "  START        ,Channel start" "0,1"
  TEXTLINE ""
  
endif



tree.end

  
tree.end
tree.end
endif

width 12.

tree "Interrupt Controller"

group.long 0xfff48000++0x03
  line.long    0x00 "MCR,INTC Module Configuration Register"
  bitfld.long  0x00 05.                  "VTES ,Vector Table Entry Size" "0,1"
  bitfld.long  0x00 00.                  "  HVEN ,Hardware Vector Enable" "0,1"

;group.long 0xfff48004++0x03
;  line.long    0x00 "BCR,INTC Test Register"

group.long 0xfff48008++0x03
  line.long    0x00 "CPR,INTC Current Priority Register"
  bitfld.long  0x00 00.--03.              "PRI ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

if   (d.l(a:0xfff48000)&0x00000001)==0x00000001

group.long 0xfff48010++0x03
  line.long    0x00 "IACKR,INTC Interrupt Acknowledge Register - must not be read speculatively in software vector mode"
  hexmask.long  0x00 11.--31. 1.          "VTBA ,Vector Table Base Address"
  hexmask.long  0x00 02.--10. 1.          "  INTVEC ,Interrupt Vector"

else

wgroup.long 0xfff48010++0x03
  hide.long    0x00 "IACKR,INTC Interrupt Acknowledge Register - must not be read speculatively in software vector mode"
  in

endif

group.long 0xfff48018++0x03
  line.long    0x00 "EOIR,INTC End of Interrupt Register"

group.long 0xfff48020++0x03
  line.long    0x00 "SSCIR0_3,INTC Software Set/Clear Interrupt Registers"
  bitfld.long  0x00 25.              "SET0 ,Set Flag" "0,1"
  bitfld.long  0x00 24.              "  CLR0 ,Clear Flag" "0,1"
  bitfld.long  0x00 17.              "  SET1 ,Set Flag" "0,1"
  bitfld.long  0x00 16.              "  CLR1 ,Clear Flag" "0,1"
  bitfld.long  0x00 09.              "  SET2 ,Set Flag" "0,1"
  bitfld.long  0x00 08.              "  CLR2 ,Clear Flag" "0,1"
  bitfld.long  0x00 01.              "  SET3 ,Set Flag" "0,1"
  bitfld.long  0x00 00.              "  CLR3 ,Clear Flag" "0,1"

group.long 0xfff48024++0x03
  line.long    0x00 "SSCIR4_7,INTC Software Set/Clear Interrupt Registers"
  bitfld.long  0x00 25.              "SET4 ,Set Flag" "0,1"
  bitfld.long  0x00 24.              "  CLR4 ,Clear Flag" "0,1"
  bitfld.long  0x00 17.              "  SET5 ,Set Flag" "0,1"
  bitfld.long  0x00 16.              "  CLR5 ,Clear Flag" "0,1"
  bitfld.long  0x00 09.              "  SET6 ,Set Flag" "0,1"
  bitfld.long  0x00 08.              "  CLR6 ,Clear Flag" "0,1"
  bitfld.long  0x00 01.              "  SET7 ,Set Flag" "0,1"
  bitfld.long  0x00 00.              "  CLR7 ,Clear Flag" "0,1"


tree "Interrupt Priority Registers"

group.long (0xfff48040+000.)++0x03
  line.long    0x00 "INTC_PSR000.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI000 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI001 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI002 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI003 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+004.)++0x03
  line.long    0x00 "INTC_PSR004.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI004 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI005 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI006 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI007 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+008.)++0x03
  line.long    0x00 "INTC_PSR008.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI008 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI009 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI010 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI011 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+012.)++0x03
  line.long    0x00 "INTC_PSR012.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI012 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI013 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI014 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI015 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+016.)++0x03
  line.long    0x00 "INTC_PSR016.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI016 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI017 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI018 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI019 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+020.)++0x03
  line.long    0x00 "INTC_PSR020.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI020 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI021 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI022 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI023 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+024.)++0x03
  line.long    0x00 "INTC_PSR024.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI024 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI025 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI026 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI027 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+028.)++0x03
  line.long    0x00 "INTC_PSR028.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI028 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI029 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI030 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI031 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+032.)++0x03
  line.long    0x00 "INTC_PSR032.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI032 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI033 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI034 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI035 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+036.)++0x03
  line.long    0x00 "INTC_PSR036.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI036 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI037 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI038 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI039 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+040.)++0x03
  line.long    0x00 "INTC_PSR040.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI040 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI041 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI042 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI043 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+044.)++0x03
  line.long    0x00 "INTC_PSR044.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI044 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI045 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI046 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI047 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+048.)++0x03
  line.long    0x00 "INTC_PSR048.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI048 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI049 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI050 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI051 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+052.)++0x03
  line.long    0x00 "INTC_PSR052.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI052 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI053 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI054 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI055 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+056.)++0x03
  line.long    0x00 "INTC_PSR056.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI056 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI057 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI058 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI059 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+060.)++0x03
  line.long    0x00 "INTC_PSR060.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI060 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI061 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI062 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI063 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+064.)++0x03
  line.long    0x00 "INTC_PSR064.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI064 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI065 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI066 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI067 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+068.)++0x03
  line.long    0x00 "INTC_PSR068.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI068 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI069 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI070 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI071 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+072.)++0x03
  line.long    0x00 "INTC_PSR072.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI072 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI073 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI074 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI075 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+076.)++0x03
  line.long    0x00 "INTC_PSR076.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI076 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI077 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI078 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI079 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+080.)++0x03
  line.long    0x00 "INTC_PSR080.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI080 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI081 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI082 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI083 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+084.)++0x03
  line.long    0x00 "INTC_PSR084.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI084 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI085 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI086 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI087 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+088.)++0x03
  line.long    0x00 "INTC_PSR088.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI088 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI089 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI090 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI091 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+092.)++0x03
  line.long    0x00 "INTC_PSR092.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI092 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI093 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI094 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI095 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+096.)++0x03
  line.long    0x00 "INTC_PSR096.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI096 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI097 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI098 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI099 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+100.)++0x03
  line.long    0x00 "INTC_PSR100.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI100 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI101 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI102 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI103 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+104.)++0x03
  line.long    0x00 "INTC_PSR104.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI104 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI105 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI106 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI107 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+108.)++0x03
  line.long    0x00 "INTC_PSR108.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI108 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI109 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI110 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI111 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+112.)++0x03
  line.long    0x00 "INTC_PSR112.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI112 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI113 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI114 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI115 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+116.)++0x03
  line.long    0x00 "INTC_PSR116.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI116 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI117 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI118 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI119 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+120.)++0x03
  line.long    0x00 "INTC_PSR120.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI120 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI121 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI122 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI123 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+124.)++0x03
  line.long    0x00 "INTC_PSR124.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI124 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI125 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI126 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI127 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+128.)++0x03
  line.long    0x00 "INTC_PSR128.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI128 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI129 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI130 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI131 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+132.)++0x03
  line.long    0x00 "INTC_PSR132.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI132 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI133 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI134 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI135 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+136.)++0x03
  line.long    0x00 "INTC_PSR136.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI136 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI137 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI138 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI139 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+140.)++0x03
  line.long    0x00 "INTC_PSR140.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI140 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI141 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI142 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI143 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+144.)++0x03
  line.long    0x00 "INTC_PSR144.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI144 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI145 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI146 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI147 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+148.)++0x03
  line.long    0x00 "INTC_PSR148.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI148 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI149 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI150 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI151 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+152.)++0x03
  line.long    0x00 "INTC_PSR152.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI152 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI153 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI154 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI155 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+156.)++0x03
  line.long    0x00 "INTC_PSR156.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI156 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI157 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI158 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI159 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+160.)++0x03
  line.long    0x00 "INTC_PSR160.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI160 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI161 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI162 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI163 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+164.)++0x03
  line.long    0x00 "INTC_PSR164.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI164 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI165 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI166 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI167 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+168.)++0x03
  line.long    0x00 "INTC_PSR168.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI168 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI169 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI170 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI171 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+172.)++0x03
  line.long    0x00 "INTC_PSR172.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI172 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI173 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI174 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI175 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+176.)++0x03
  line.long    0x00 "INTC_PSR176.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI176 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI177 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI178 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI179 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+180.)++0x03
  line.long    0x00 "INTC_PSR180.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI180 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI181 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI182 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI183 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+184.)++0x03
  line.long    0x00 "INTC_PSR184.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI184 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI185 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI186 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI187 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+188.)++0x03
  line.long    0x00 "INTC_PSR188.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI188 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI189 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI190 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI191 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+192.)++0x03
  line.long    0x00 "INTC_PSR192.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI192 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI193 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI194 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI195 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+196.)++0x03
  line.long    0x00 "INTC_PSR196.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI196 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI197 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI198 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI199 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+200.)++0x03
  line.long    0x00 "INTC_PSR200.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI200 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI201 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI202 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI203 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+204.)++0x03
  line.long    0x00 "INTC_PSR204.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI204 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI205 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI206 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI207 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+208.)++0x03
  line.long    0x00 "INTC_PSR208.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI208 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI209 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI210 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI211 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+212.)++0x03
  line.long    0x00 "INTC_PSR212.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI212 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI213 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI214 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI215 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+216.)++0x03
  line.long    0x00 "INTC_PSR216.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI216 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI217 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI218 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI219 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+220.)++0x03
  line.long    0x00 "INTC_PSR220.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI220 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI221 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI222 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI223 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+224.)++0x03
  line.long    0x00 "INTC_PSR224.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI224 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI225 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI226 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI227 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+228.)++0x03
  line.long    0x00 "INTC_PSR228.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI228 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI229 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI230 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI231 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+232.)++0x03
  line.long    0x00 "INTC_PSR232.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI232 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI233 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI234 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI235 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+236.)++0x03
  line.long    0x00 "INTC_PSR236.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI236 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI237 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI238 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI239 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+240.)++0x03
  line.long    0x00 "INTC_PSR240.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI240 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI241 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI242 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI243 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+244.)++0x03
  line.long    0x00 "INTC_PSR244.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI244 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI245 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI246 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI247 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+248.)++0x03
  line.long    0x00 "INTC_PSR248.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI248 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI249 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI250 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI251 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+252.)++0x03
  line.long    0x00 "INTC_PSR252.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI252 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI253 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI254 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI255 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+256.)++0x03
  line.long    0x00 "INTC_PSR256.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI256 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI257 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI258 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI259 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+260.)++0x03
  line.long    0x00 "INTC_PSR260.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI260 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI261 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI262 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI263 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+264.)++0x03
  line.long    0x00 "INTC_PSR264.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI264 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI265 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI266 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI267 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+268.)++0x03
  line.long    0x00 "INTC_PSR268.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI268 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI269 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI270 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI271 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+272.)++0x03
  line.long    0x00 "INTC_PSR272.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI272 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI273 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI274 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI275 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+276.)++0x03
  line.long    0x00 "INTC_PSR276.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI276 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI277 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI278 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI279 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+280.)++0x03
  line.long    0x00 "INTC_PSR280.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI280 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI281 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI282 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI283 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+284.)++0x03
  line.long    0x00 "INTC_PSR284.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI284 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI285 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI286 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI287 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+288.)++0x03
  line.long    0x00 "INTC_PSR288.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI288 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI289 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI290 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI291 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+292.)++0x03
  line.long    0x00 "INTC_PSR292.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI292 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI293 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI294 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI295 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+296.)++0x03
  line.long    0x00 "INTC_PSR296.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI296 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI297 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI298 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI299 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+300.)++0x03
  line.long    0x00 "INTC_PSR300.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI300 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI301 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI302 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI303 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+304.)++0x03
  line.long    0x00 "INTC_PSR304.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI304 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI305 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI306 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI307 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+308.)++0x03
  line.long    0x00 "INTC_PSR308.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI308 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI309 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI310 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI311 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+312.)++0x03
  line.long    0x00 "INTC_PSR312.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI312 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI313 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI314 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI315 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+316.)++0x03
  line.long    0x00 "INTC_PSR316.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI316 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI317 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI318 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI319 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+320.)++0x03
  line.long    0x00 "INTC_PSR320.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI320 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI321 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI322 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI323 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+324.)++0x03
  line.long    0x00 "INTC_PSR324.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI324 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI325 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI326 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI327 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+328.)++0x03
  line.long    0x00 "INTC_PSR328.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI328 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI329 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI330 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI331 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+332.)++0x03
  line.long    0x00 "INTC_PSR332.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI332 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI333 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI334 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI335 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+336.)++0x03
  line.long    0x00 "INTC_PSR336.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI336 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI337 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI338 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI339 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+340.)++0x03
  line.long    0x00 "INTC_PSR340.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI340 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI341 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI342 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI343 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+344.)++0x03
  line.long    0x00 "INTC_PSR344.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI344 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI345 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI346 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI347 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+348.)++0x03
  line.long    0x00 "INTC_PSR348.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI348 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI349 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI350 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI351 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+352.)++0x03
  line.long    0x00 "INTC_PSR352.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI352 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI353 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI354 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI355 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+356.)++0x03
  line.long    0x00 "INTC_PSR356.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI356 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI357 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI358 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI359 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+360.)++0x03
  line.long    0x00 "INTC_PSR360.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI360 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI361 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI362 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI363 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+364.)++0x03
  line.long    0x00 "INTC_PSR364.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI364 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI365 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI366 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI367 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+368.)++0x03
  line.long    0x00 "INTC_PSR368.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI368 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI369 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI370 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI371 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+372.)++0x03
  line.long    0x00 "INTC_PSR372.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI372 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI373 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI374 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI375 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+376.)++0x03
  line.long    0x00 "INTC_PSR376.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI376 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI377 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI378 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI379 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+380.)++0x03
  line.long    0x00 "INTC_PSR380.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI380 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI381 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI382 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI383 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+384.)++0x03
  line.long    0x00 "INTC_PSR384.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI384 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI385 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI386 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI387 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+388.)++0x03
  line.long    0x00 "INTC_PSR388.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI388 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI389 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI390 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI391 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+392.)++0x03
  line.long    0x00 "INTC_PSR392.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI392 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI393 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI394 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI395 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+396.)++0x03
  line.long    0x00 "INTC_PSR396.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI396 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI397 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI398 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI399 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+400.)++0x03
  line.long    0x00 "INTC_PSR400.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI400 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI401 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI402 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI403 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+404.)++0x03
  line.long    0x00 "INTC_PSR404.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI404 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI405 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI406 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI407 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+408.)++0x03
  line.long    0x00 "INTC_PSR408.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI408 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI409 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI410 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI411 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+412.)++0x03
  line.long    0x00 "INTC_PSR412.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI412 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI413 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI414 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI415 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+416.)++0x03
  line.long    0x00 "INTC_PSR416.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI416 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI417 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI418 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI419 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+420.)++0x03
  line.long    0x00 "INTC_PSR420.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI420 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI421 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI422 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI423 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+424.)++0x03
  line.long    0x00 "INTC_PSR424.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI424 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI425 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI426 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI427 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+428.)++0x03
  line.long    0x00 "INTC_PSR428.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI428 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI429 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI430 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI431 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+432.)++0x03
  line.long    0x00 "INTC_PSR432.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI432 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI433 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI434 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI435 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+436.)++0x03
  line.long    0x00 "INTC_PSR436.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI436 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI437 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI438 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI439 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+440.)++0x03
  line.long    0x00 "INTC_PSR440.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI440 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI441 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI442 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI443 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+444.)++0x03
  line.long    0x00 "INTC_PSR444.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI444 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI445 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI446 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI447 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+448.)++0x03
  line.long    0x00 "INTC_PSR448.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI448 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI449 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI450 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI451 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+452.)++0x03
  line.long    0x00 "INTC_PSR452.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI452 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI453 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI454 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI455 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+456.)++0x03
  line.long    0x00 "INTC_PSR456.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI456 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI457 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI458 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI459 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+460.)++0x03
  line.long    0x00 "INTC_PSR460.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI460 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI461 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI462 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI463 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+464.)++0x03
  line.long    0x00 "INTC_PSR464.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI464 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI465 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI466 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI467 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+468.)++0x03
  line.long    0x00 "INTC_PSR468.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI468 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI469 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI470 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI471 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+472.)++0x03
  line.long    0x00 "INTC_PSR472.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI472 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI473 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI474 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI475 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+476.)++0x03
  line.long    0x00 "INTC_PSR476.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI476 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI477 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI478 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI479 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+480.)++0x03
  line.long    0x00 "INTC_PSR480.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI480 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI481 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI482 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI483 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+484.)++0x03
  line.long    0x00 "INTC_PSR484.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI484 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI485 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI486 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI487 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+488.)++0x03
  line.long    0x00 "INTC_PSR488.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI488 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI489 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI490 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI491 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+492.)++0x03
  line.long    0x00 "INTC_PSR492.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI492 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI493 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI494 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI495 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+496.)++0x03
  line.long    0x00 "INTC_PSR496.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI496 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI497 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI498 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI499 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+500.)++0x03
  line.long    0x00 "INTC_PSR500.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI500 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI501 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI502 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI503 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+504.)++0x03
  line.long    0x00 "INTC_PSR504.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI504 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI505 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI506 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI507 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group.long (0xfff48040+508.)++0x03
  line.long    0x00 "INTC_PSR508.,INTC Current Priority Register"
  bitfld.long  0x00 24.--27.              "PRI508 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 16.--19.              "PRI509 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.              "PRI510 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.              "PRI511 ,Priority" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"


tree.end

tree.end

width 9.

sif CPUIS("MPC5674*")
tree "Frequency Modulated Phase Locked Loop (FMPLL)"

group.long 0xC3F80004++0x03
  line.long    0x00 "SYNSR,Synthesizer Status Register"
  eventfld.long  0x00 09.              "LOLF     ,Loss of lock flag" "0,1"
  bitfld.long  0x00 08.              "  LOC      ,Loss Of clock status" "0,1"
  bitfld.long  0x00 07.              "  MODE ,Clock mode." "off,clock"
  bitfld.long  0x00 06.              " PLLSEL ,PLL mode select" "off,normal"
TEXTLINE "                "
  bitfld.long  0x00 05.              "  PLLREF ,PLL clock reference source" "Ext,Xtal"
  bitfld.long  0x00 04.               " LOCKS    ,Sticky PLL lock status bit" "0,1"
  bitfld.long  0x00 03.              "  LOCK ,PLL lock status bit" "0,1"
  eventfld.long  0x00 02.            "     LOCF   ,Loss of clock flag" "0,1"
TEXTLINE "                "
  eventfld.long  0x00 02.            "  CALDONE  ,Calibration Complete" "0,1"
  eventfld.long  0x00 02.            "  CALPASS  ,Calibration Passed" "0,1"
TEXTLINE ""

group.long 0xC3F80008++0x03
  line.long    0x00 "ESYNCR1,PLL Enhanced Synthesizer Control Register 1"
  bitfld.long  0x00 28.--30.             "CLKCFG  ,Clock Configuration" "0,1,2,3,4,5,6,7"
  bitfld.long  0x00 16.--19.             "  EPREDIV    ,Enhanced Pre-Divider" "1:1,1:2,1:3,1:4,1:5,1:6,res.,1:8,res.,1:10,res.,res.,res.,res.,res.,res."
  hexmask.long.byte 0x00 00.--07. 1. 0.  "  EMFD    ,Enhanced Multiplication Factor Divider"

group.long 0xC3F8000C++0x03
  line.long    0x00 "ESYNCR2,PLL Enhanced Synthesizer Control Register 2"
  bitfld.long  0x00 23.                "LOCEN   ,Loss of clock enable" "0,1"
  bitfld.long  0x00 22.              "  LOLRE      ,Loss of lock reset enable" "0,1"
  bitfld.long  0x00 21.              "     LOCRE   ,Loss of clock reset enable" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 20.              "  LOLIRQ  ,Loss of lock interrupt request" "0,1"
  bitfld.long  0x00 19.              "  LOCIRQ     ,Loss of clock interrupt request" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 16.--17.         "  ERATE   ,Enhanced modulation rate" "1/80,1/40,1/20,res."
  bitfld.long  0x00 15.              "                CLKCFG_DIS ,The CLKCFG_DIS bit is used to disable the ability to change the PLL mode using the CLKCFG bits" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 08.--10.         "  EDEPTH  ,Enhanced modulation rate" "0%,0.25%~0.5%,0.75%~1%,1.25%~1.5%,1.75%~2%,res.,res.,res." 
  hexmask.long.byte 0x00 00.--05. 1. 0.  "          ERFD    ,Enhanced Reduced Frequency Divider"

tree.end

else
tree "Frequency Modulated Phase Locked Loop (FMPLL)"

group.long 0xC3F80000++0x03
  line.long    0x00 "SYNCR,Synthesizer Control Register"
  bitfld.long  0x00 28.--30.         "PREDIV ,Multiplication factor divider" "1/1,1/2,1/3,1/4,1/5,res,res,res"
  bitfld.long  0x00 23.--27.         "  MFD    ,Multiplication factor divider" " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
  bitfld.long  0x00 19.--21.         "  RFD    ,Reduced frequency divider"   "1/1,1/2,1/4,1/8,1/16,1/32,1/64,1/128"
  bitfld.long  0x00 18.              "  LOCEN  ,Loss of clock enable" "0,1"
  bitfld.long  0x00 17.              "        LOLRE   ,Loss of lock reset enable" "0,1"
  bitfld.long  0x00 16.              "     LOCRE ,Loss of clock reset enable" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  DISCLK ,Disable CLKOUT" "0,1"
  bitfld.long  0x00 14.              "    LOLIRQ  ,Loss of lock interrupt request" "0,1"
  bitfld.long  0x00 13.              "  LOCIRQ     ,Loss of clock interrupt request" "0,1"
  bitfld.long  0x00 12.              "  RATE   ,Modulation rate" "fref/80,fref/40"
  bitfld.long  0x00 10.--11.         "  DEPTH   ,The DEPTH bit field controls the frequency modulation depth and enables the frequency modulation" "0,1.0,2.0,res."
  hexmask.long.word 0x00 00.--09.  1.     "  EXP  ,Expected difference value"
TEXTLINE ""


group.long 0xC3F80004++0x03
  line.long    0x00 "SYNSR,Synthesizer Status Register"
  eventfld.long  0x00 09.              "LOLF    ,Loss of lock flag" "0,1"
  bitfld.long  0x00 08.              "   LOC     ,Loss Of clock status" "0,1"
  bitfld.long  0x00 07.              "  MODE  ,Clock mode." "bypass, clock"
  bitfld.long  0x00 06.              "  PLLSEL ,PLL mode select" "1:1,normal"
  bitfld.long  0x00 05.              "   PLLREF  ,PLL clock reference source" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 04.              "  LOCKS   ,Sticky PLL lock status bit" "0,1"
  bitfld.long  0x00 03.              "   LOCK    ,PLL lock status bit" "0,1"
  eventfld.long  0x00 02.              "  LOCF       ,Loss of clock flag" "0,1"
  bitfld.long  0x00 01.              "  CALDONE     ,Calibration complete" "0,1"
  bitfld.long  0x00 00.              "   CALPASS ,Calibration passed" "0,1"

sif (CPU()=="MPC5633M")||(CPU()=="MPC5634M")||(cpu()=="SPC563M60")||(cpu()=="SPC563M64")

  group.long 0xC3F80008++0x03
    line.long    0x00 "ESYNCR1,PLL Enhanced Synthesizer Control Register 1"
    bitfld.long  0x00 31.                    "EMODE   ,Enhanced PLL Mode" "0,1"
    bitfld.long  0x00 28.--30.             "   CLKCFG  ,Clock Configuration" "0,1,2,3,4,5,6,7"
    bitfld.long  0x00 16.--19.             "  EPREDIV ,Enhanced Pre-Divider" " 1/1, 1/2, 1/3, 1/4, 1/5, 1/6,res., 1/8,res.,1:10,res.,res.,res.,res.,res.,res."
    hexmask.long.byte 0x00 00.--07. 1. 0.  "  EMFD       ,Enhanced Multiplication Factor Divider"

  group.long 0xC3F8000C++0x03
    line.long    0x00 "ESYNCR2,PLL Enhanced Synthesizer Control Register 2"
    bitfld.long  0x00 23.                "LOCEN   ,Loss of clock enable" "0,1"
    bitfld.long  0x00 22.              "   LOLRE   ,Loss of lock reset enable" "0,1"
    bitfld.long  0x00 21.              "  LOCRE      ,Loss of clock reset enable" "0,1"
    bitfld.long  0x00 20.              "  LOLIRQ      ,Loss of lock interrupt request" "0,1"
  TEXTLINE "                "
    bitfld.long  0x00 19.              "  LOCIRQ  ,Loss of clock interrupt request" "0,1"
    bitfld.long  0x00 16.--17.         "   ERATE ,Enhanced modulation rate" "1/80,1/40,1/20,res."
    bitfld.long  0x00 08.--10.         " EDEPTH  ,Enhanced modulation rate" "0%,0.25~0.5%,0.75~1%,1.25~1.5%,1.75~2%,res.,res.,res." 
TEXTLINE "                "
    hexmask.long.byte 0x00 00.--05. 1. 0.  "  ERFD   ,Enhanced Reduced Frequency Divider"

  group.long 0xC3F80018++0x03
    line.long    0x00 "SYNFMMR,SYNFMMR"
    bitfld.long  0x00 31.                    "BSY     ,Busy" "0,1"
    bitfld.long  0x00 30.                    "   MOD_EN  ," "0,1"
    bitfld.long  0x00 29.                    "  MOD_SEL    ," "0,1"
    hexmask.long.word  0x00 16.--28. 1. 0.   "  MODPERIOD ," 
    hexmask.long.word  0x00 00.--14. 1. 0.   "  INC_STEP  ," 

endif

tree.end

endif



tree "External Bus Interface (EBI)"

sif (CPUIS("MPC5674*"))
group.long 0xC3F84000++0x03
  line.long    0x00 "MCR,EBI Module Configuration Register"
  bitfld.long  0x00 15.                  "ACGE ,Automatic CLKOUT gating enable" "0,1"
  bitfld.long  0x00 06.                  "  MDIS ,Module disable mode" "0,1"
  bitfld.long  0x00 02.                  "  D16_31 ,Data Bus 16_31 Select" "AD[0:15],AD[16:31]"
  bitfld.long  0x00 01.                  "  AD_MUX ,Address on Data Bus Multiplexing Mode" "0,1"
  bitfld.long  0x00 00.                  "  DBM  ,Data bus mode" "32-bit,16-bit"
else
group.long 0xC3F84000++0x03
  line.long    0x00 "MCR,EBI Module Configuration Register"
  bitfld.long  0x00 26.                  "SIZEN ,SIZE enable" "0,1"
  bitfld.long  0x00 24.--25.             "  SIZE ,Transfer size" "32-bit,byte,16-bit,res."
  bitfld.long  0x00 15.                  "  ACGE ,Automatic CLKOUT gating enable" "0,1"
  bitfld.long  0x00 14.                  "  EXTM ,External master mode" "0,1"
  bitfld.long  0x00 13.                  "  EARB ,External arbitration" "0,1"
  bitfld.long  0x00 11.--12.             "  EARP ,External arbitration request priority" "MCU,equal,ext master,res."
  bitfld.long  0x00 06.                  "  MDIS ,Module disable mode" "0,1"
sif (CPU()=="MPC5633M")||(CPU()=="MPC5634M")||(CPU()=="SPC563M60")||(CPU()=="SPC563M64")
TEXTLINE "                "
  bitfld.long  0x00 02.                  "  D16_31 ,Data Bus 16_31 Select" "AD[0:15],AD[16:31]"
  bitfld.long  0x00 01.                  "      AD_MUX ,Address on Data Bus Multiplexing Mode" "0,1"
endif
  bitfld.long  0x00 00.                  "        DBM  ,Data bus mode" "32-bit,16-bit"

endif


group.long 0xC3F84008++0x03
  line.long    0x00 "TESR,EBI Transfer Error Status Register"
  eventfld.long  0x00 01.                  "TEAF ,Transfer error acknowledge flag (w1c)" "0,1"
  eventfld.long  0x00 00.                  "  BMTF ,Bus monitor timeout flag (w1c)" "0,1"
  
group.long 0xC3F8400C++0x03
  line.long    0x00 "BMCR,EBI Bus Monitor Control Register"
  hexmask.byte 0x02 00.--07.   1.        "BMT ,Bus monitor timing"
  bitfld.long  0x00 07.                  "  BME  ,Bus monitor enable" "0,1"

TEXTLINE ""

sif (CPU()!="MPC5674")&&(CPU()!="MPC5674F")
group.long (0xC3F84010)++0x03
  line.long    0x00 "BR0,EBI Base Register"
  hexmask.long 0x00 15.--31.   0x00008000 "BA ,Base address"
  bitfld.long  0x00 11.                  "  PS ,Port size" "32-bit,16-bit"
  bitfld.long  0x00 06.                  "  BL ,Burst length" "8-word,4-word"
  bitfld.long  0x00 05.                  "  WEBS ,Write enable/byte select" "/WE[0:3],/BE[0:3]"
  bitfld.long  0x00 04.                  "  TBDIP ,Toggle burst data in progress" "0,1"
  bitfld.long  0x00 01.                  "  BI ,Burst inhibit" "0,1"
  bitfld.long  0x00 00.                  "  V ,Valid bit" "0,1"
  
  
group.long (0xC3F84018)++0x03
  line.long    0x00 "BR1,EBI Base Register"
  hexmask.long 0x00 15.--31.   0x00008000 "BA ,Base address"
  bitfld.long  0x00 11.                  "  PS ,Port size" "32-bit,16-bit"
  bitfld.long  0x00 06.                  "  BL ,Burst length" "8-word,4-word"
  bitfld.long  0x00 05.                  "  WEBS ,Write enable/byte select" "/WE[0:3],/BE[0:3]"
  bitfld.long  0x00 04.                  "  TBDIP ,Toggle burst data in progress" "0,1"
  bitfld.long  0x00 01.                  "  BI ,Burst inhibit" "0,1"
  bitfld.long  0x00 00.                  "  V ,Valid bit" "0,1"
  
  
group.long (0xC3F84020)++0x03
  line.long    0x00 "BR2,EBI Base Register"
  hexmask.long 0x00 15.--31.   0x00008000 "BA ,Base address"
  bitfld.long  0x00 11.                  "  PS ,Port size" "32-bit,16-bit"
  bitfld.long  0x00 06.                  "  BL ,Burst length" "8-word,4-word"
  bitfld.long  0x00 05.                  "  WEBS ,Write enable/byte select" "/WE[0:3],/BE[0:3]"
  bitfld.long  0x00 04.                  "  TBDIP ,Toggle burst data in progress" "0,1"
  bitfld.long  0x00 01.                  "  BI ,Burst inhibit" "0,1"
  bitfld.long  0x00 00.                  "  V ,Valid bit" "0,1"
  
  
group.long (0xC3F84028)++0x03
  line.long    0x00 "BR3,EBI Base Register"
  hexmask.long 0x00 15.--31.   0x00008000 "BA ,Base address"
  bitfld.long  0x00 11.                  "  PS ,Port size" "32-bit,16-bit"
  bitfld.long  0x00 06.                  "  BL ,Burst length" "8-word,4-word"
  bitfld.long  0x00 05.                  "  WEBS ,Write enable/byte select" "/WE[0:3],/BE[0:3]"
  bitfld.long  0x00 04.                  "  TBDIP ,Toggle burst data in progress" "0,1"
  bitfld.long  0x00 01.                  "  BI ,Burst inhibit" "0,1"
  bitfld.long  0x00 00.                  "  V ,Valid bit" "0,1"
  
  
endif

sif (CPU()=="MPC5553")||(CPU()=="MPC5534")||(CPU()=="MPC5565")||(CPU()=="MPC5566")||(CPU()=="MPC5567")||(CPUIS("MPC5674*"))||(CPU()=="MPC5633M")||(CPU()=="MPC5634M")||(CPU()=="SPC563M60")||(CPU()=="SPC563M64")
group.long (0xC3F84040)++0x03
  line.long    0x00 "CAL_BR0,EBI Base Register"
  hexmask.long 0x00 15.--31.   0x00008000 "BA ,Base address"
  bitfld.long  0x00 11.                  "  PS ,Port size" "32-bit,16-bit"
  bitfld.long  0x00 06.                  "  BL ,Burst length" "8-word,4-word"
  bitfld.long  0x00 05.                  "  WEBS ,Write enable/byte select" "/WE[0:3],/BE[0:3]"
  bitfld.long  0x00 04.                  "  TBDIP ,Toggle burst data in progress" "0,1"
  bitfld.long  0x00 01.                  "  BI ,Burst inhibit" "0,1"
  bitfld.long  0x00 00.                  "  V ,Valid bit" "0,1"
  
  
group.long (0xC3F84048)++0x03
  line.long    0x00 "CAL_BR1,EBI Base Register"
  hexmask.long 0x00 15.--31.   0x00008000 "BA ,Base address"
  bitfld.long  0x00 11.                  "  PS ,Port size" "32-bit,16-bit"
  bitfld.long  0x00 06.                  "  BL ,Burst length" "8-word,4-word"
  bitfld.long  0x00 05.                  "  WEBS ,Write enable/byte select" "/WE[0:3],/BE[0:3]"
  bitfld.long  0x00 04.                  "  TBDIP ,Toggle burst data in progress" "0,1"
  bitfld.long  0x00 01.                  "  BI ,Burst inhibit" "0,1"
  bitfld.long  0x00 00.                  "  V ,Valid bit" "0,1"
  
  
group.long (0xC3F84050)++0x03
  line.long    0x00 "CAL_BR2,EBI Base Register"
  hexmask.long 0x00 15.--31.   0x00008000 "BA ,Base address"
  bitfld.long  0x00 11.                  "  PS ,Port size" "32-bit,16-bit"
  bitfld.long  0x00 06.                  "  BL ,Burst length" "8-word,4-word"
  bitfld.long  0x00 05.                  "  WEBS ,Write enable/byte select" "/WE[0:3],/BE[0:3]"
  bitfld.long  0x00 04.                  "  TBDIP ,Toggle burst data in progress" "0,1"
  bitfld.long  0x00 01.                  "  BI ,Burst inhibit" "0,1"
  bitfld.long  0x00 00.                  "  V ,Valid bit" "0,1"
  
  
group.long (0xC3F84058)++0x03
  line.long    0x00 "CAL_BR3,EBI Base Register"
  hexmask.long 0x00 15.--31.   0x00008000 "BA ,Base address"
  bitfld.long  0x00 11.                  "  PS ,Port size" "32-bit,16-bit"
  bitfld.long  0x00 06.                  "  BL ,Burst length" "8-word,4-word"
  bitfld.long  0x00 05.                  "  WEBS ,Write enable/byte select" "/WE[0:3],/BE[0:3]"
  bitfld.long  0x00 04.                  "  TBDIP ,Toggle burst data in progress" "0,1"
  bitfld.long  0x00 01.                  "  BI ,Burst inhibit" "0,1"
  bitfld.long  0x00 00.                  "  V ,Valid bit" "0,1"
  
  
endif

TEXTLINE ""

sif (CPU()!="MPC5674")&&(CPU()!="MPC5674F")
group.long (0xC3F84014)++0x03
  line.long    0x00 "OR0,EBI Option Register"
  hexmask.long 0x00 15.--31.   0x00008000 "AM ,Address mask"
  bitfld.long  0x00 04.--07.              "  SCY ,Cycle length in clocks" "2 clks,3 clks,4 clks,5 clks,6 clks,7 clks,8 clks,9 clks,10 clks,11 clks,12 clks,13 clks,14 clks,15 clks,16 clks,17 clks"
  bitfld.long  0x00 01.--02.              "  BSCY ,Burst beats length in clocks" "0 clks,1 clks,2 clks,3 clks"

  
group.long (0xC3F8401C)++0x03
  line.long    0x00 "OR1,EBI Option Register"
  hexmask.long 0x00 15.--31.   0x00008000 "AM ,Address mask"
  bitfld.long  0x00 04.--07.              "  SCY ,Cycle length in clocks" "2 clks,3 clks,4 clks,5 clks,6 clks,7 clks,8 clks,9 clks,10 clks,11 clks,12 clks,13 clks,14 clks,15 clks,16 clks,17 clks"
  bitfld.long  0x00 01.--02.              "  BSCY ,Burst beats length in clocks" "0 clks,1 clks,2 clks,3 clks"

  
group.long (0xC3F84024)++0x03
  line.long    0x00 "OR2,EBI Option Register"
  hexmask.long 0x00 15.--31.   0x00008000 "AM ,Address mask"
  bitfld.long  0x00 04.--07.              "  SCY ,Cycle length in clocks" "2 clks,3 clks,4 clks,5 clks,6 clks,7 clks,8 clks,9 clks,10 clks,11 clks,12 clks,13 clks,14 clks,15 clks,16 clks,17 clks"
  bitfld.long  0x00 01.--02.              "  BSCY ,Burst beats length in clocks" "0 clks,1 clks,2 clks,3 clks"

  
group.long (0xC3F8402C)++0x03
  line.long    0x00 "OR3,EBI Option Register"
  hexmask.long 0x00 15.--31.   0x00008000 "AM ,Address mask"
  bitfld.long  0x00 04.--07.              "  SCY ,Cycle length in clocks" "2 clks,3 clks,4 clks,5 clks,6 clks,7 clks,8 clks,9 clks,10 clks,11 clks,12 clks,13 clks,14 clks,15 clks,16 clks,17 clks"
  bitfld.long  0x00 01.--02.              "  BSCY ,Burst beats length in clocks" "0 clks,1 clks,2 clks,3 clks"

  
endif

sif (CPU()=="MPC5553")||(CPU()=="MPC5534")||(CPU()=="MPC5565")||(CPU()=="MPC5566")||(CPU()=="MPC5567")||(CPUIS("MPC5674*"))||(CPU()=="MPC5633M")||(CPU()=="MPC5634M")||(CPU()=="SPC563M60")||(CPU()=="SPC563M64")
group.long (0xC3F84044)++0x03
  line.long    0x00 "CAL_OR0,EBI Option Register"
  hexmask.long 0x00 15.--31.   0x00008000 "AM ,Address mask"
  bitfld.long  0x00 04.--07.              "  SCY ,Cycle length in clocks" "2 clks,3 clks,4 clks,5 clks,6 clks,7 clks,8 clks,9 clks,10 clks,11 clks,12 clks,13 clks,14 clks,15 clks,16 clks,17 clks"
  bitfld.long  0x00 01.--02.              "  BSCY ,Burst beats length in clocks" "0 clks,1 clks,2 clks,3 clks"

  
group.long (0xC3F8404C)++0x03
  line.long    0x00 "CAL_OR1,EBI Option Register"
  hexmask.long 0x00 15.--31.   0x00008000 "AM ,Address mask"
  bitfld.long  0x00 04.--07.              "  SCY ,Cycle length in clocks" "2 clks,3 clks,4 clks,5 clks,6 clks,7 clks,8 clks,9 clks,10 clks,11 clks,12 clks,13 clks,14 clks,15 clks,16 clks,17 clks"
  bitfld.long  0x00 01.--02.              "  BSCY ,Burst beats length in clocks" "0 clks,1 clks,2 clks,3 clks"

  
group.long (0xC3F84054)++0x03
  line.long    0x00 "CAL_OR2,EBI Option Register"
  hexmask.long 0x00 15.--31.   0x00008000 "AM ,Address mask"
  bitfld.long  0x00 04.--07.              "  SCY ,Cycle length in clocks" "2 clks,3 clks,4 clks,5 clks,6 clks,7 clks,8 clks,9 clks,10 clks,11 clks,12 clks,13 clks,14 clks,15 clks,16 clks,17 clks"
  bitfld.long  0x00 01.--02.              "  BSCY ,Burst beats length in clocks" "0 clks,1 clks,2 clks,3 clks"

  
group.long (0xC3F8405C)++0x03
  line.long    0x00 "CAL_OR3,EBI Option Register"
  hexmask.long 0x00 15.--31.   0x00008000 "AM ,Address mask"
  bitfld.long  0x00 04.--07.              "  SCY ,Cycle length in clocks" "2 clks,3 clks,4 clks,5 clks,6 clks,7 clks,8 clks,9 clks,10 clks,11 clks,12 clks,13 clks,14 clks,15 clks,16 clks,17 clks"
  bitfld.long  0x00 01.--02.              "  BSCY ,Burst beats length in clocks" "0 clks,1 clks,2 clks,3 clks"

  
endif

tree.end


sif (cpu()=="MPC5533")||(cpu()=="MPC5534")||(cpu()=="MPC5553")||(cpu()=="MPC5554")||(cpu()=="MPC5561")||(cpu()=="MPC5565")||(cpu()=="MPC5566")||(cpu()=="MPC5567")

tree "Flash Memory"

group.long (0xC3F88000+0x000)++0x03
  line.long    0x00 "MCR,Module Configuration Register"
  bitfld.long  0x00 24.--27.             "SIZE ,Array space size. Dependent upon the size of the Flash module" "256K,512K,768K,1M,1.25M,1.5M,1.75M,2M,2.25M,2.5M,2.75M,3M,3.25M,3.5M,3.75M,4M"
  bitfld.long  0x00 20.--22.             "  LAS ,Low address space" "2x 128k,4x 64k,4x 16k + 4x 48k,16x 16k,8x 16k + 2x 64k,10x 16k + 2x 48k,2x 16k + 2x 48k + 2x 64k,not used"
  bitfld.long  0x00 16.                  "  MAS ,Mid address space size" "2x 128k,4x 64k"

TEXTLINE "                "
  eventfld.long  0x00 15.                  "  EER  ,ECC event error" "0,1"
  eventfld.long  0x00 14.                  "  RWE  ,Read while write event error" "0,1"
  bitfld.long  0x00 11.                  "   PEAS ,Program/erase access space" "0,1"
  bitfld.long  0x00 10.                  "  DONE ,State machine status" "0,1"
  bitfld.long  0x00 09.                  "  PEG  ,Program/erase good" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 06.                  "  STOP ,Stop mode enabled" "0,1"
  bitfld.long  0x00 04.                  "  PGM  ,Program" "0,1"
  bitfld.long  0x00 03.                  "  PSUS  ,Program suspend" "0,1"
  bitfld.long  0x00 02.                  "  ERS  ,Erase" "0,1"
  bitfld.long  0x00 01.                  "  ESUS ,Erase suspend" "0,1"
  bitfld.long  0x00 00.                  "  EHV  ,Enable high voltage" "0,1"
TEXTLINE ""

  
group.long (0xC3F88000+0x004)++0x03
  line.long    0x00 "LMLR,Low/Mid Address Space Block Locking Register"
  bitfld.long  0x00 31.                  "LME  ,Low and mid address lock enable" "0,1"
  bitfld.long  0x00 20.                  " SLOCK ,Shadow lock" "0,1"

  bitfld.long  0x00 19.                  "    MLOCK03-00 ,Mid address block 3 lock" "0,1"
  bitfld.long  0x00 18.                  ",Mid address block 2 lock" "0,1"
  bitfld.long  0x00 17.                  ",Mid address block 1 lock" "0,1"
  bitfld.long  0x00 16.                  ",Mid address block 0 lock" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.                  "  LLOCK15-12 ,Low address block 15 lock" "0,1"
  bitfld.long  0x00 14.                  ",Low address block 14 lock" "0,1"
  bitfld.long  0x00 13.                  ",Low address block 13 lock" "0,1"
  bitfld.long  0x00 12.                  ",Low address block 12 lock" "0,1"
  
  bitfld.long  0x00 11.                  "   LLOCK11-08  ,Low address block 11 lock" "0,1"
  bitfld.long  0x00 10.                  ",Low address block 10 lock" "0,1"
  bitfld.long  0x00 09.                  ",Low address block 9 lock" "0,1"
  bitfld.long  0x00 08.                  ",Low address block 8 lock" "0,1"
  
  bitfld.long  0x00 07.                  "  LLOCK07-04  ,Low address block 7 lock" "0,1"
  bitfld.long  0x00 06.                  ",Low address block 6 lock" "0,1"
  bitfld.long  0x00 05.                  ",Low address block 5 lock" "0,1"
  bitfld.long  0x00 04.                  ",Low address block 4 lock" "0,1"
  
  bitfld.long  0x00 03.                  "  LLOCK03-00  ,Low address block 3 lock" "0,1"
  bitfld.long  0x00 02.                  ",Low address block 2 lock" "0,1"
  bitfld.long  0x00 01.                  ",Low address block 1 lock" "0,1"
  bitfld.long  0x00 00.                  ",Low address block 0 lock" "0,1"
TEXTLINE ""
  
group.long (0xC3F88000+0x008)++0x03
  line.long    0x00 "HLR,High Address Space Block Locking Register"
  bitfld.long  0x00 31.                  "HBE ,High address lock enable" "0,1"

  bitfld.long  0x00 27.                  "             HBLOCK27-24 ,High address space block 27 lock" "0,1"
  bitfld.long  0x00 26.                  ",High address space block 26 lock" "0,1"
  bitfld.long  0x00 25.                  ",High address space block 25 lock" "0,1"
  bitfld.long  0x00 24.                  ",High address space block 24 lock" "0,1"
  
  bitfld.long  0x00 23.                  "  HBLOCK23-20 ,High address space block 23 lock" "0,1"
  bitfld.long  0x00 22.                  ",High address space block 22 lock" "0,1"
  bitfld.long  0x00 21.                  ",High address space block 21 lock" "0,1"
  bitfld.long  0x00 20.                  ",High address space block 20 lock" "0,1"
  
  bitfld.long  0x00 19.                  "  HBLOCK19-16 ,High address space block 19 lock" "0,1"
  bitfld.long  0x00 18.                  ",High address space block 18 lock" "0,1"
  bitfld.long  0x00 17.                  ",High address space block 17 lock" "0,1"
  bitfld.long  0x00 16.                  ",High address space block 16 lock" "0,1"
TEXTLINE "                "
  
  bitfld.long  0x00 15.                  "  HBLOCK15-12 ,High address space block 15 lock" "0,1"
  bitfld.long  0x00 14.                  ",High address space block 14 lock" "0,1"
  bitfld.long  0x00 13.                  ",High address space block 13 lock" "0,1"
  bitfld.long  0x00 12.                  ",High address space block 12 lock" "0,1"
  
  bitfld.long  0x00 11.                  "  HBLOCK11-08 ,High address space block 11 lock" "0,1"
  bitfld.long  0x00 10.                  ",High address space block 10 lock" "0,1"
  bitfld.long  0x00 09.                  ",High address space block 9 lock" "0,1"
  bitfld.long  0x00 08.                  ",High address space block 8 lock" "0,1"
  
  bitfld.long  0x00 07.                  "  HBLOCK07-04 ,High address space block 7 lock" "0,1"
  bitfld.long  0x00 06.                  ",High address space block 6 lock" "0,1"
  bitfld.long  0x00 05.                  ",High address space block 5 lock" "0,1"
  bitfld.long  0x00 04.                  ",High address space block 4 lock" "0,1"
  
  bitfld.long  0x00 03.                  "  HBLOCK03-00 ,High address space block 3 lock" "0,1"
  bitfld.long  0x00 02.                  ",High address space block 2 lock" "0,1"
  bitfld.long  0x00 01.                  ",High address space block 1 lock" "0,1"
  bitfld.long  0x00 00.                  ",High address space block 0 lock" "0,1"
TEXTLINE ""
  
  
group.long (0xC3F88000+0x00C)++0x03
  line.long    0x00 "SLMLR,Secondary Low/Mid Address Space Block Locking Register"
  bitfld.long  0x00 31.                  "SME ,Secondary low and mid address lock enable" "0,1"
  bitfld.long  0x00 20.                  "  SSLOCK ,Secondary shadow lock" "0,1"

  bitfld.long  0x00 19.                  "   SMLOCK03-00 ,Secondary Mid address block 3 lock" "0,1"
  bitfld.long  0x00 18.                  ",Secondary Mid address block 2 lock" "0,1"
  bitfld.long  0x00 17.                  ",Secondary Mid address block 1 lock" "0,1"
  bitfld.long  0x00 16.                  ",Secondary Mid address block 0 lock" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.                  "  SLLOCK15-12 ,Secondary Low address block 15 lock" "0,1"
  bitfld.long  0x00 14.                  ",Secondary Low address block 14 lock" "0,1"
  bitfld.long  0x00 13.                  ",Secondary Low address block 13 lock" "0,1"
  bitfld.long  0x00 12.                  ",Secondary Low address block 12 lock" "0,1"
  
  bitfld.long  0x00 11.                  "  SLLOCK11-08 ,Secondary Low address block 11 lock" "0,1"
  bitfld.long  0x00 10.                  ",Secondary Low address block 10 lock" "0,1"
  bitfld.long  0x00 09.                  ",Secondary Low address block 9 lock" "0,1"
  bitfld.long  0x00 08.                  ",Secondary Low address block 8 lock" "0,1"
  
  bitfld.long  0x00 07.                  "  SLLOCK07-04 ,Secondary Low address block 7 lock" "0,1"
  bitfld.long  0x00 06.                  ",Secondary Low address block 6 lock" "0,1"
  bitfld.long  0x00 05.                  ",Secondary Low address block 5 lock" "0,1"
  bitfld.long  0x00 04.                  ",Secondary Low address block 4 lock" "0,1"
  
  bitfld.long  0x00 03.                  "  SLLOCK03-00 ,Secondary Low address block 3 lock" "0,1"
  bitfld.long  0x00 02.                  ",Secondary Low address block 2 lock" "0,1"
  bitfld.long  0x00 01.                  ",Secondary Low address block 1 lock" "0,1"
  bitfld.long  0x00 00.                  ",Secondary Low address block 0 lock" "0,1"
TEXTLINE ""
  
group.long (0xC3F88000+0x010)++0x03
  line.long    0x00 "LMSR,Low/Mid Address Space Block Select Register"

  bitfld.long  0x00 19.                  "MSEL03-00   ,Mid address block 3 select" "0,1"
  bitfld.long  0x00 18.                  ",Mid address block 2 select" "0,1"
  bitfld.long  0x00 17.                  ",Mid address block 1 select" "0,1"
  bitfld.long  0x00 16.                  ",Mid address block 0 select" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.                  "  LSEL15-12   ,Low address block 15 select" "0,1"
  bitfld.long  0x00 14.                  ",Low address block 14 select" "0,1"
  bitfld.long  0x00 13.                  ",Low address block 13 select" "0,1"
  bitfld.long  0x00 12.                  ",Low address block 12 select" "0,1"
  
  bitfld.long  0x00 11.                  "  LSEL11-08   ,Low address block 11 select" "0,1"
  bitfld.long  0x00 10.                  ",Low address block 10 select" "0,1"
  bitfld.long  0x00 09.                  ",Low address block 9 select" "0,1"
  bitfld.long  0x00 08.                  ",Low address block 8 select" "0,1"
  
  bitfld.long  0x00 07.                  "  LSEL07-04   ,Low address block 7 select" "0,1"
  bitfld.long  0x00 06.                  ",Low address block 6 select" "0,1"
  bitfld.long  0x00 05.                  ",Low address block 5 select" "0,1"
  bitfld.long  0x00 04.                  ",Low address block 4 select" "0,1"
  
  bitfld.long  0x00 03.                  "  LSEL03-00   ,Low address block 3 select" "0,1"
  bitfld.long  0x00 02.                  ",Low address block 2 select" "0,1"
  bitfld.long  0x00 01.                  ",Low address block 1 select" "0,1"
  bitfld.long  0x00 00.                  ",Low address block 0 select" "0,1"
TEXTLINE ""
  

group.long (0xC3F88000+0x014)++0x03
  line.long    0x00 "HSR,High Address Space Block Select Register"

  bitfld.long  0x00 27.                  "HBSEL27-24  ,High address space block 27 select" "0,1"
  bitfld.long  0x00 26.                  ",High address space block 26 select" "0,1"
  bitfld.long  0x00 25.                  ",High address space block 25 select" "0,1"
  bitfld.long  0x00 24.                  ",High address space block 24 select" "0,1"
  
  bitfld.long  0x00 23.                  "  HBSEL23-20  ,High address space block 23 select" "0,1"
  bitfld.long  0x00 22.                  ",High address space block 22 select" "0,1"
  bitfld.long  0x00 21.                  ",High address space block 21 select" "0,1"
  bitfld.long  0x00 20.                  ",High address space block 20 select" "0,1"
  
  bitfld.long  0x00 19.                  "  HBSEL19-16  ,High address space block 19 select" "0,1"
  bitfld.long  0x00 18.                  ",High address space block 18 select" "0,1"
  bitfld.long  0x00 17.                  ",High address space block 17 select" "0,1"
  bitfld.long  0x00 16.                  ",High address space block 16 select" "0,1"
TEXTLINE "                "
  
  bitfld.long  0x00 15.                  "  HBSEL15-12  ,High address space block 15 select" "0,1"
  bitfld.long  0x00 14.                  ",High address space block 14 select" "0,1"
  bitfld.long  0x00 13.                  ",High address space block 13 select" "0,1"
  bitfld.long  0x00 12.                  ",High address space block 12 select" "0,1"
  
  bitfld.long  0x00 11.                  "  HBSEL11-08  ,High address space block 11 select" "0,1"
  bitfld.long  0x00 10.                  ",High address space block 10 select" "0,1"
  bitfld.long  0x00 09.                  ",High address space block 9 select" "0,1"
  bitfld.long  0x00 08.                  ",High address space block 8 select" "0,1"
  
  bitfld.long  0x00 07.                  "  HBSEL07-04  ,High address space block 7 select" "0,1"
  bitfld.long  0x00 06.                  ",High address space block 6 select" "0,1"
  bitfld.long  0x00 05.                  ",High address space block 5 select" "0,1"
  bitfld.long  0x00 04.                  ",High address space block 4 select" "0,1"
  
  bitfld.long  0x00 03.                  "  HBSEL03-00  ,High address space block 3 select" "0,1"
  bitfld.long  0x00 02.                  ",High address space block 2 select" "0,1"
  bitfld.long  0x00 01.                  ",High address space block 1 select" "0,1"
  bitfld.long  0x00 00.                  ",High address space block 0 select" "0,1"
TEXTLINE ""

group.long (0xC3F88000+0x018)++0x03
  line.long    0x00 "AR,Address Register"
TEXTLINE ""


group.long (0xC3F88000+0x01C)++0x03
  line.long    0x00 "BIUCR,Flash Bus Interface Unit Control Register"
  bitfld.long  0x00 27.                  "MPFE11--08 ,Master 11 prefetch enable" "0,1"
  bitfld.long  0x00 26.                  ",Master 10 prefetch enable" "0,1"
  bitfld.long  0x00 25.                  ",Master 09 prefetch enable" "0,1"
  bitfld.long  0x00 24.                  ",Master 08 prefetch enable" "0,1"

  bitfld.long  0x00 23.                  "  MPFE07--04 ,Master 07 prefetch enable" "0,1"
  bitfld.long  0x00 22.                  ",Master 06 prefetch enable" "0,1"
  bitfld.long  0x00 21.                  ",Master 05 prefetch enable" "0,1"
  bitfld.long  0x00 20.                  ",Master 04 prefetch enable" "0,1"

  bitfld.long  0x00 19.                  "  MPFE03--00 ,Master 03 prefetch enable" "0,1"
  bitfld.long  0x00 18.                  ",Master 02 prefetch enable" "0,1"
  bitfld.long  0x00 17.                  ",Master 01 prefetch enable" "0,1"
  bitfld.long  0x00 16.                  ",Master 00 prefetch enable" "0,1"
  TEXTLINE "                "
  bitfld.long  0x00 13.--15.             "  APC ,Address pipelining control" "back-to-back,1 hold cycle,2 hold cycles,3 hold cycles,4 hold cycles,5 hold cycles,6 hold cycles,no pipelining"
  bitfld.long  0x00 11.--12.             "  WWSC ,Write wait state control" "0,1,2,3"
  bitfld.long  0x00 08.--10.             "  RWSC ,Read wait state control" "0,1,2,3,4,5,6,7"
  TEXTLINE "                "
  bitfld.long  0x00 06.--07.             "  DPFEN ,Data prefetch enable" "disabled,data burst,res.,any data read"
  bitfld.long  0x00 04.--05.             "  IPFEN ,Instruction prefetch enable" "disabled,inst read,res.,any inst read"
  bitfld.long  0x00 01.--03.             "  PFLIM ,Prefetch limit" "disabled,1 line,-2 lines,-3 lines,-4 lines,-5 lines,unlimited,res."
  bitfld.long  0x00 00.                  "  BFEN ,PFBIU line read buffers enable" "0,1"
TEXTLINE ""
 
 
group.long (0xC3F88000+0x020)++0x03
  line.long    0x00 "BIUAPR,Flash Bus Interface Unit Access Protection Register"
  bitfld.long  0x00 16.--17.             "M8AP ,Master 8 access protection" "none,read,write,both"
  TEXTLINE "                "
  bitfld.long  0x00 14.--15.             "  M7AP ,Master 7 access protection" "none,read,write,both"
  bitfld.long  0x00 12.--13.             "  M6AP ,Master 6 access protection" "none,read,write,both"
  bitfld.long  0x00 10.--11.             "  M5AP ,Master 5 access protection" "none,read,write,both"
  bitfld.long  0x00 08.--09.             "  M4AP ,Master 4 access protection" "none,read,write,both"
  TEXTLINE "                "
  bitfld.long  0x00 06.--07.             "  M3AP ,Master 3 access protection" "none,read,write,both"
  bitfld.long  0x00 04.--05.             "  M2AP ,Master 2 access protection" "none,read,write,both"
  bitfld.long  0x00 02.--03.             "  M1AP ,Master 1 access protection" "none,read,write,both"
  bitfld.long  0x00 00.--01.             "  M0AP ,Master 0 access protection" "none,read,write,both"
 


tree.end

endif

sif CPUIS("MPC5674*")
 tree "Flash Memory"

tree "Flash A"

group.long (0xC3F88000+0x000)++0x03
  line.long    0x00 "MCR,Module Configuration Register"
  bitfld.long  0x00 24.--27.             "SIZE ,Array space size. Dependent upon the size of the Flash module" "256K,512K,768K,1M,1.25M,1.5M,1.75M,2M,2.25M,2.5M,2.75M,3M,3.25M,3.5M,3.75M,4M"
  bitfld.long  0x00 20.--22.             "  LAS ,Low address space" "2x 128k,4x 64k,4x 16k + 4x 48k,16x 16k,8x 16k + 2x 64k,10x 16k + 2x 48k,2x 16k + 2x 48k + 2x 64k,not used"
  bitfld.long  0x00 16.                  "  MAS ,Mid address space size" "2x 128k,4x 64k"

TEXTLINE "                "
  eventfld.long  0x00 15.                  "  EER  ,ECC event error" "0,1"
  eventfld.long  0x00 14.                  "  RWE  ,Read while write event error" "0,1"
  bitfld.long  0x00 11.                  "   PEAS ,Program/erase access space" "0,1"
  bitfld.long  0x00 10.                  "  DONE ,State machine status" "0,1"
  bitfld.long  0x00 09.                  "  PEG  ,Program/erase good" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 06.                  "  STOP ,Stop mode enabled" "0,1"
  bitfld.long  0x00 04.                  "  PGM  ,Program" "0,1"
  bitfld.long  0x00 03.                  "  PSUS  ,Program suspend" "0,1"
  bitfld.long  0x00 02.                  "  ERS  ,Erase" "0,1"
  bitfld.long  0x00 01.                  "  ESUS ,Erase suspend" "0,1"
  bitfld.long  0x00 00.                  "  EHV  ,Enable high voltage" "0,1"
TEXTLINE ""

  
group.long (0xC3F88000+0x004)++0x03
  line.long    0x00 "LMLR,Low/Mid Address Space Block Locking Register"
  bitfld.long  0x00 31.                  "LME  ,Low and mid address lock enable" "0,1"
  bitfld.long  0x00 20.                  " SLOCK ,Shadow lock" "0,1"

  bitfld.long  0x00 19.                  "    MLOCK03-00 ,Mid address block 3 lock" "0,1"
  bitfld.long  0x00 18.                  ",Mid address block 2 lock" "0,1"
  bitfld.long  0x00 17.                  ",Mid address block 1 lock" "0,1"
  bitfld.long  0x00 16.                  ",Mid address block 0 lock" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.                  "  LLOCK15-12 ,Low address block 15 lock" "0,1"
  bitfld.long  0x00 14.                  ",Low address block 14 lock" "0,1"
  bitfld.long  0x00 13.                  ",Low address block 13 lock" "0,1"
  bitfld.long  0x00 12.                  ",Low address block 12 lock" "0,1"
  
  bitfld.long  0x00 11.                  "   LLOCK11-08  ,Low address block 11 lock" "0,1"
  bitfld.long  0x00 10.                  ",Low address block 10 lock" "0,1"
  bitfld.long  0x00 09.                  ",Low address block 9 lock" "0,1"
  bitfld.long  0x00 08.                  ",Low address block 8 lock" "0,1"
  
  bitfld.long  0x00 07.                  "  LLOCK07-04  ,Low address block 7 lock" "0,1"
  bitfld.long  0x00 06.                  ",Low address block 6 lock" "0,1"
  bitfld.long  0x00 05.                  ",Low address block 5 lock" "0,1"
  bitfld.long  0x00 04.                  ",Low address block 4 lock" "0,1"
  
  bitfld.long  0x00 03.                  "  LLOCK03-00  ,Low address block 3 lock" "0,1"
  bitfld.long  0x00 02.                  ",Low address block 2 lock" "0,1"
  bitfld.long  0x00 01.                  ",Low address block 1 lock" "0,1"
  bitfld.long  0x00 00.                  ",Low address block 0 lock" "0,1"
TEXTLINE ""
  
group.long (0xC3F88000+0x008)++0x03
  line.long    0x00 "HLR,High Address Space Block Locking Register"
  bitfld.long  0x00 31.                  "HBE ,High address lock enable" "0,1"

  bitfld.long  0x00 27.                  "             HBLOCK27-24 ,High address space block 27 lock" "0,1"
  bitfld.long  0x00 26.                  ",High address space block 26 lock" "0,1"
  bitfld.long  0x00 25.                  ",High address space block 25 lock" "0,1"
  bitfld.long  0x00 24.                  ",High address space block 24 lock" "0,1"
  
  bitfld.long  0x00 23.                  "  HBLOCK23-20 ,High address space block 23 lock" "0,1"
  bitfld.long  0x00 22.                  ",High address space block 22 lock" "0,1"
  bitfld.long  0x00 21.                  ",High address space block 21 lock" "0,1"
  bitfld.long  0x00 20.                  ",High address space block 20 lock" "0,1"
  
  bitfld.long  0x00 19.                  "  HBLOCK19-16 ,High address space block 19 lock" "0,1"
  bitfld.long  0x00 18.                  ",High address space block 18 lock" "0,1"
  bitfld.long  0x00 17.                  ",High address space block 17 lock" "0,1"
  bitfld.long  0x00 16.                  ",High address space block 16 lock" "0,1"
TEXTLINE "                "
  
  bitfld.long  0x00 15.                  "  HBLOCK15-12 ,High address space block 15 lock" "0,1"
  bitfld.long  0x00 14.                  ",High address space block 14 lock" "0,1"
  bitfld.long  0x00 13.                  ",High address space block 13 lock" "0,1"
  bitfld.long  0x00 12.                  ",High address space block 12 lock" "0,1"
  
  bitfld.long  0x00 11.                  "  HBLOCK11-08 ,High address space block 11 lock" "0,1"
  bitfld.long  0x00 10.                  ",High address space block 10 lock" "0,1"
  bitfld.long  0x00 09.                  ",High address space block 9 lock" "0,1"
  bitfld.long  0x00 08.                  ",High address space block 8 lock" "0,1"
  
  bitfld.long  0x00 07.                  "  HBLOCK07-04 ,High address space block 7 lock" "0,1"
  bitfld.long  0x00 06.                  ",High address space block 6 lock" "0,1"
  bitfld.long  0x00 05.                  ",High address space block 5 lock" "0,1"
  bitfld.long  0x00 04.                  ",High address space block 4 lock" "0,1"
  
  bitfld.long  0x00 03.                  "  HBLOCK03-00 ,High address space block 3 lock" "0,1"
  bitfld.long  0x00 02.                  ",High address space block 2 lock" "0,1"
  bitfld.long  0x00 01.                  ",High address space block 1 lock" "0,1"
  bitfld.long  0x00 00.                  ",High address space block 0 lock" "0,1"
TEXTLINE ""
  
  
group.long (0xC3F88000+0x00C)++0x03
  line.long    0x00 "SLMLR,Secondary Low/Mid Address Space Block Locking Register"
  bitfld.long  0x00 31.                  "SME ,Secondary low and mid address lock enable" "0,1"
  bitfld.long  0x00 20.                  "  SSLOCK ,Secondary shadow lock" "0,1"

  bitfld.long  0x00 19.                  "   SMLOCK03-00 ,Secondary Mid address block 3 lock" "0,1"
  bitfld.long  0x00 18.                  ",Secondary Mid address block 2 lock" "0,1"
  bitfld.long  0x00 17.                  ",Secondary Mid address block 1 lock" "0,1"
  bitfld.long  0x00 16.                  ",Secondary Mid address block 0 lock" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.                  "  SLLOCK15-12 ,Secondary Low address block 15 lock" "0,1"
  bitfld.long  0x00 14.                  ",Secondary Low address block 14 lock" "0,1"
  bitfld.long  0x00 13.                  ",Secondary Low address block 13 lock" "0,1"
  bitfld.long  0x00 12.                  ",Secondary Low address block 12 lock" "0,1"
  
  bitfld.long  0x00 11.                  "  SLLOCK11-08 ,Secondary Low address block 11 lock" "0,1"
  bitfld.long  0x00 10.                  ",Secondary Low address block 10 lock" "0,1"
  bitfld.long  0x00 09.                  ",Secondary Low address block 9 lock" "0,1"
  bitfld.long  0x00 08.                  ",Secondary Low address block 8 lock" "0,1"
  
  bitfld.long  0x00 07.                  "  SLLOCK07-04 ,Secondary Low address block 7 lock" "0,1"
  bitfld.long  0x00 06.                  ",Secondary Low address block 6 lock" "0,1"
  bitfld.long  0x00 05.                  ",Secondary Low address block 5 lock" "0,1"
  bitfld.long  0x00 04.                  ",Secondary Low address block 4 lock" "0,1"
  
  bitfld.long  0x00 03.                  "  SLLOCK03-00 ,Secondary Low address block 3 lock" "0,1"
  bitfld.long  0x00 02.                  ",Secondary Low address block 2 lock" "0,1"
  bitfld.long  0x00 01.                  ",Secondary Low address block 1 lock" "0,1"
  bitfld.long  0x00 00.                  ",Secondary Low address block 0 lock" "0,1"
TEXTLINE ""
  
group.long (0xC3F88000+0x010)++0x03
  line.long    0x00 "LMSR,Low/Mid Address Space Block Select Register"

  bitfld.long  0x00 19.                  "MSEL03-00   ,Mid address block 3 select" "0,1"
  bitfld.long  0x00 18.                  ",Mid address block 2 select" "0,1"
  bitfld.long  0x00 17.                  ",Mid address block 1 select" "0,1"
  bitfld.long  0x00 16.                  ",Mid address block 0 select" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.                  "  LSEL15-12   ,Low address block 15 select" "0,1"
  bitfld.long  0x00 14.                  ",Low address block 14 select" "0,1"
  bitfld.long  0x00 13.                  ",Low address block 13 select" "0,1"
  bitfld.long  0x00 12.                  ",Low address block 12 select" "0,1"
  
  bitfld.long  0x00 11.                  "  LSEL11-08   ,Low address block 11 select" "0,1"
  bitfld.long  0x00 10.                  ",Low address block 10 select" "0,1"
  bitfld.long  0x00 09.                  ",Low address block 9 select" "0,1"
  bitfld.long  0x00 08.                  ",Low address block 8 select" "0,1"
  
  bitfld.long  0x00 07.                  "  LSEL07-04   ,Low address block 7 select" "0,1"
  bitfld.long  0x00 06.                  ",Low address block 6 select" "0,1"
  bitfld.long  0x00 05.                  ",Low address block 5 select" "0,1"
  bitfld.long  0x00 04.                  ",Low address block 4 select" "0,1"
  
  bitfld.long  0x00 03.                  "  LSEL03-00   ,Low address block 3 select" "0,1"
  bitfld.long  0x00 02.                  ",Low address block 2 select" "0,1"
  bitfld.long  0x00 01.                  ",Low address block 1 select" "0,1"
  bitfld.long  0x00 00.                  ",Low address block 0 select" "0,1"
TEXTLINE ""
  

group.long (0xC3F88000+0x014)++0x03
  line.long    0x00 "HSR,High Address Space Block Select Register"

  bitfld.long  0x00 27.                  "HBSEL27-24  ,High address space block 27 select" "0,1"
  bitfld.long  0x00 26.                  ",High address space block 26 select" "0,1"
  bitfld.long  0x00 25.                  ",High address space block 25 select" "0,1"
  bitfld.long  0x00 24.                  ",High address space block 24 select" "0,1"
  
  bitfld.long  0x00 23.                  "  HBSEL23-20  ,High address space block 23 select" "0,1"
  bitfld.long  0x00 22.                  ",High address space block 22 select" "0,1"
  bitfld.long  0x00 21.                  ",High address space block 21 select" "0,1"
  bitfld.long  0x00 20.                  ",High address space block 20 select" "0,1"
  
  bitfld.long  0x00 19.                  "  HBSEL19-16  ,High address space block 19 select" "0,1"
  bitfld.long  0x00 18.                  ",High address space block 18 select" "0,1"
  bitfld.long  0x00 17.                  ",High address space block 17 select" "0,1"
  bitfld.long  0x00 16.                  ",High address space block 16 select" "0,1"
TEXTLINE "                "
  
  bitfld.long  0x00 15.                  "  HBSEL15-12  ,High address space block 15 select" "0,1"
  bitfld.long  0x00 14.                  ",High address space block 14 select" "0,1"
  bitfld.long  0x00 13.                  ",High address space block 13 select" "0,1"
  bitfld.long  0x00 12.                  ",High address space block 12 select" "0,1"
  
  bitfld.long  0x00 11.                  "  HBSEL11-08  ,High address space block 11 select" "0,1"
  bitfld.long  0x00 10.                  ",High address space block 10 select" "0,1"
  bitfld.long  0x00 09.                  ",High address space block 9 select" "0,1"
  bitfld.long  0x00 08.                  ",High address space block 8 select" "0,1"
  
  bitfld.long  0x00 07.                  "  HBSEL07-04  ,High address space block 7 select" "0,1"
  bitfld.long  0x00 06.                  ",High address space block 6 select" "0,1"
  bitfld.long  0x00 05.                  ",High address space block 5 select" "0,1"
  bitfld.long  0x00 04.                  ",High address space block 4 select" "0,1"
  
  bitfld.long  0x00 03.                  "  HBSEL03-00  ,High address space block 3 select" "0,1"
  bitfld.long  0x00 02.                  ",High address space block 2 select" "0,1"
  bitfld.long  0x00 01.                  ",High address space block 1 select" "0,1"
  bitfld.long  0x00 00.                  ",High address space block 0 select" "0,1"
TEXTLINE ""

group.long (0xC3F88000+0x018)++0x03
  line.long    0x00 "AR,Address Register"
TEXTLINE ""


group.long (0xC3F88000+0x01C)++0x03
  line.long    0x00 "BIUCR,Flash Bus Interface Unit Control Register"
  bitfld.long  0x00 27.                  "MPFE11--08 ,Master 11 prefetch enable" "0,1"
  bitfld.long  0x00 26.                  ",Master 10 prefetch enable" "0,1"
  bitfld.long  0x00 25.                  ",Master 09 prefetch enable" "0,1"
  bitfld.long  0x00 24.                  ",Master 08 prefetch enable" "0,1"

  bitfld.long  0x00 23.                  "  MPFE07--04 ,Master 07 prefetch enable" "0,1"
  bitfld.long  0x00 22.                  ",Master 06 prefetch enable" "0,1"
  bitfld.long  0x00 21.                  ",Master 05 prefetch enable" "0,1"
  bitfld.long  0x00 20.                  ",Master 04 prefetch enable" "0,1"

  bitfld.long  0x00 19.                  "  MPFE03--00 ,Master 03 prefetch enable" "0,1"
  bitfld.long  0x00 18.                  ",Master 02 prefetch enable" "0,1"
  bitfld.long  0x00 17.                  ",Master 01 prefetch enable" "0,1"
  bitfld.long  0x00 16.                  ",Master 00 prefetch enable" "0,1"
  TEXTLINE "                "
  bitfld.long  0x00 13.--15.             "  APC ,Address pipelining control" "back-to-back,1 hold cycle,2 hold cycles,3 hold cycles,4 hold cycles,5 hold cycles,6 hold cycles,no pipelining"
  bitfld.long  0x00 11.--12.             "  WWSC ,Write wait state control" "0,1,2,3"
  bitfld.long  0x00 08.--10.             "  RWSC ,Read wait state control" "0,1,2,3,4,5,6,7"
  TEXTLINE "                "
  bitfld.long  0x00 06.--07.             "  DPFEN ,Data prefetch enable" "disabled,data burst,res.,any data read"
  bitfld.long  0x00 04.--05.             "  IPFEN ,Instruction prefetch enable" "disabled,inst read,res.,any inst read"
  bitfld.long  0x00 01.--03.             "  PFLIM ,Prefetch limit" "disabled,1 line,-2 lines,-3 lines,-4 lines,-5 lines,unlimited,res."
  bitfld.long  0x00 00.                  "  BFEN ,PFBIU line read buffers enable" "0,1"
TEXTLINE ""
 
 
group.long (0xC3F88000+0x020)++0x03
  line.long    0x00 "BIUAPR,Flash Bus Interface Unit Access Protection Register"
  bitfld.long  0x00 16.--17.             "M8AP ,Master 8 access protection" "none,read,write,both"
  TEXTLINE "                "
  bitfld.long  0x00 14.--15.             "  M7AP ,Master 7 access protection" "none,read,write,both"
  bitfld.long  0x00 12.--13.             "  M6AP ,Master 6 access protection" "none,read,write,both"
  bitfld.long  0x00 10.--11.             "  M5AP ,Master 5 access protection" "none,read,write,both"
  bitfld.long  0x00 08.--09.             "  M4AP ,Master 4 access protection" "none,read,write,both"
  TEXTLINE "                "
  bitfld.long  0x00 06.--07.             "  M3AP ,Master 3 access protection" "none,read,write,both"
  bitfld.long  0x00 04.--05.             "  M2AP ,Master 2 access protection" "none,read,write,both"
  bitfld.long  0x00 02.--03.             "  M1AP ,Master 1 access protection" "none,read,write,both"
  bitfld.long  0x00 00.--01.             "  M0AP ,Master 0 access protection" "none,read,write,both"
 


tree.end


tree "Flash B"

group.long (0xC3F8C000+0x000)++0x03
  line.long    0x00 "MCR,Module Configuration Register"
  bitfld.long  0x00 24.--27.             "SIZE ,Array space size. Dependent upon the size of the Flash module" "256K,512K,768K,1M,1.25M,1.5M,1.75M,2M,2.25M,2.5M,2.75M,3M,3.25M,3.5M,3.75M,4M"
  bitfld.long  0x00 20.--22.             "  LAS ,Low address space" "2x 128k,4x 64k,4x 16k + 4x 48k,16x 16k,8x 16k + 2x 64k,10x 16k + 2x 48k,2x 16k + 2x 48k + 2x 64k,not used"
  bitfld.long  0x00 16.                  "  MAS ,Mid address space size" "2x 128k,4x 64k"

TEXTLINE "                "
  eventfld.long  0x00 15.                  "  EER  ,ECC event error" "0,1"
  eventfld.long  0x00 14.                  "  RWE  ,Read while write event error" "0,1"
  bitfld.long  0x00 11.                  "   PEAS ,Program/erase access space" "0,1"
  bitfld.long  0x00 10.                  "  DONE ,State machine status" "0,1"
  bitfld.long  0x00 09.                  "  PEG  ,Program/erase good" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 06.                  "  STOP ,Stop mode enabled" "0,1"
  bitfld.long  0x00 04.                  "  PGM  ,Program" "0,1"
  bitfld.long  0x00 03.                  "  PSUS  ,Program suspend" "0,1"
  bitfld.long  0x00 02.                  "  ERS  ,Erase" "0,1"
  bitfld.long  0x00 01.                  "  ESUS ,Erase suspend" "0,1"
  bitfld.long  0x00 00.                  "  EHV  ,Enable high voltage" "0,1"
TEXTLINE ""

  
group.long (0xC3F8C000+0x004)++0x03
  line.long    0x00 "LMLR,Low/Mid Address Space Block Locking Register"
  bitfld.long  0x00 31.                  "LME  ,Low and mid address lock enable" "0,1"
  bitfld.long  0x00 20.                  " SLOCK ,Shadow lock" "0,1"

  bitfld.long  0x00 19.                  "    MLOCK03-00 ,Mid address block 3 lock" "0,1"
  bitfld.long  0x00 18.                  ",Mid address block 2 lock" "0,1"
  bitfld.long  0x00 17.                  ",Mid address block 1 lock" "0,1"
  bitfld.long  0x00 16.                  ",Mid address block 0 lock" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.                  "  LLOCK15-12 ,Low address block 15 lock" "0,1"
  bitfld.long  0x00 14.                  ",Low address block 14 lock" "0,1"
  bitfld.long  0x00 13.                  ",Low address block 13 lock" "0,1"
  bitfld.long  0x00 12.                  ",Low address block 12 lock" "0,1"
  
  bitfld.long  0x00 11.                  "   LLOCK11-08  ,Low address block 11 lock" "0,1"
  bitfld.long  0x00 10.                  ",Low address block 10 lock" "0,1"
  bitfld.long  0x00 09.                  ",Low address block 9 lock" "0,1"
  bitfld.long  0x00 08.                  ",Low address block 8 lock" "0,1"
  
  bitfld.long  0x00 07.                  "  LLOCK07-04  ,Low address block 7 lock" "0,1"
  bitfld.long  0x00 06.                  ",Low address block 6 lock" "0,1"
  bitfld.long  0x00 05.                  ",Low address block 5 lock" "0,1"
  bitfld.long  0x00 04.                  ",Low address block 4 lock" "0,1"
  
  bitfld.long  0x00 03.                  "  LLOCK03-00  ,Low address block 3 lock" "0,1"
  bitfld.long  0x00 02.                  ",Low address block 2 lock" "0,1"
  bitfld.long  0x00 01.                  ",Low address block 1 lock" "0,1"
  bitfld.long  0x00 00.                  ",Low address block 0 lock" "0,1"
TEXTLINE ""
  
group.long (0xC3F8C000+0x008)++0x03
  line.long    0x00 "HLR,High Address Space Block Locking Register"
  bitfld.long  0x00 31.                  "HBE ,High address lock enable" "0,1"

  bitfld.long  0x00 27.                  "             HBLOCK27-24 ,High address space block 27 lock" "0,1"
  bitfld.long  0x00 26.                  ",High address space block 26 lock" "0,1"
  bitfld.long  0x00 25.                  ",High address space block 25 lock" "0,1"
  bitfld.long  0x00 24.                  ",High address space block 24 lock" "0,1"
  
  bitfld.long  0x00 23.                  "  HBLOCK23-20 ,High address space block 23 lock" "0,1"
  bitfld.long  0x00 22.                  ",High address space block 22 lock" "0,1"
  bitfld.long  0x00 21.                  ",High address space block 21 lock" "0,1"
  bitfld.long  0x00 20.                  ",High address space block 20 lock" "0,1"
  
  bitfld.long  0x00 19.                  "  HBLOCK19-16 ,High address space block 19 lock" "0,1"
  bitfld.long  0x00 18.                  ",High address space block 18 lock" "0,1"
  bitfld.long  0x00 17.                  ",High address space block 17 lock" "0,1"
  bitfld.long  0x00 16.                  ",High address space block 16 lock" "0,1"
TEXTLINE "                "
  
  bitfld.long  0x00 15.                  "  HBLOCK15-12 ,High address space block 15 lock" "0,1"
  bitfld.long  0x00 14.                  ",High address space block 14 lock" "0,1"
  bitfld.long  0x00 13.                  ",High address space block 13 lock" "0,1"
  bitfld.long  0x00 12.                  ",High address space block 12 lock" "0,1"
  
  bitfld.long  0x00 11.                  "  HBLOCK11-08 ,High address space block 11 lock" "0,1"
  bitfld.long  0x00 10.                  ",High address space block 10 lock" "0,1"
  bitfld.long  0x00 09.                  ",High address space block 9 lock" "0,1"
  bitfld.long  0x00 08.                  ",High address space block 8 lock" "0,1"
  
  bitfld.long  0x00 07.                  "  HBLOCK07-04 ,High address space block 7 lock" "0,1"
  bitfld.long  0x00 06.                  ",High address space block 6 lock" "0,1"
  bitfld.long  0x00 05.                  ",High address space block 5 lock" "0,1"
  bitfld.long  0x00 04.                  ",High address space block 4 lock" "0,1"
  
  bitfld.long  0x00 03.                  "  HBLOCK03-00 ,High address space block 3 lock" "0,1"
  bitfld.long  0x00 02.                  ",High address space block 2 lock" "0,1"
  bitfld.long  0x00 01.                  ",High address space block 1 lock" "0,1"
  bitfld.long  0x00 00.                  ",High address space block 0 lock" "0,1"
TEXTLINE ""
  
  
group.long (0xC3F8C000+0x00C)++0x03
  line.long    0x00 "SLMLR,Secondary Low/Mid Address Space Block Locking Register"
  bitfld.long  0x00 31.                  "SME ,Secondary low and mid address lock enable" "0,1"
  bitfld.long  0x00 20.                  "  SSLOCK ,Secondary shadow lock" "0,1"

  bitfld.long  0x00 19.                  "   SMLOCK03-00 ,Secondary Mid address block 3 lock" "0,1"
  bitfld.long  0x00 18.                  ",Secondary Mid address block 2 lock" "0,1"
  bitfld.long  0x00 17.                  ",Secondary Mid address block 1 lock" "0,1"
  bitfld.long  0x00 16.                  ",Secondary Mid address block 0 lock" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.                  "  SLLOCK15-12 ,Secondary Low address block 15 lock" "0,1"
  bitfld.long  0x00 14.                  ",Secondary Low address block 14 lock" "0,1"
  bitfld.long  0x00 13.                  ",Secondary Low address block 13 lock" "0,1"
  bitfld.long  0x00 12.                  ",Secondary Low address block 12 lock" "0,1"
  
  bitfld.long  0x00 11.                  "  SLLOCK11-08 ,Secondary Low address block 11 lock" "0,1"
  bitfld.long  0x00 10.                  ",Secondary Low address block 10 lock" "0,1"
  bitfld.long  0x00 09.                  ",Secondary Low address block 9 lock" "0,1"
  bitfld.long  0x00 08.                  ",Secondary Low address block 8 lock" "0,1"
  
  bitfld.long  0x00 07.                  "  SLLOCK07-04 ,Secondary Low address block 7 lock" "0,1"
  bitfld.long  0x00 06.                  ",Secondary Low address block 6 lock" "0,1"
  bitfld.long  0x00 05.                  ",Secondary Low address block 5 lock" "0,1"
  bitfld.long  0x00 04.                  ",Secondary Low address block 4 lock" "0,1"
  
  bitfld.long  0x00 03.                  "  SLLOCK03-00 ,Secondary Low address block 3 lock" "0,1"
  bitfld.long  0x00 02.                  ",Secondary Low address block 2 lock" "0,1"
  bitfld.long  0x00 01.                  ",Secondary Low address block 1 lock" "0,1"
  bitfld.long  0x00 00.                  ",Secondary Low address block 0 lock" "0,1"
TEXTLINE ""
  
group.long (0xC3F8C000+0x010)++0x03
  line.long    0x00 "LMSR,Low/Mid Address Space Block Select Register"

  bitfld.long  0x00 19.                  "MSEL03-00   ,Mid address block 3 select" "0,1"
  bitfld.long  0x00 18.                  ",Mid address block 2 select" "0,1"
  bitfld.long  0x00 17.                  ",Mid address block 1 select" "0,1"
  bitfld.long  0x00 16.                  ",Mid address block 0 select" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.                  "  LSEL15-12   ,Low address block 15 select" "0,1"
  bitfld.long  0x00 14.                  ",Low address block 14 select" "0,1"
  bitfld.long  0x00 13.                  ",Low address block 13 select" "0,1"
  bitfld.long  0x00 12.                  ",Low address block 12 select" "0,1"
  
  bitfld.long  0x00 11.                  "  LSEL11-08   ,Low address block 11 select" "0,1"
  bitfld.long  0x00 10.                  ",Low address block 10 select" "0,1"
  bitfld.long  0x00 09.                  ",Low address block 9 select" "0,1"
  bitfld.long  0x00 08.                  ",Low address block 8 select" "0,1"
  
  bitfld.long  0x00 07.                  "  LSEL07-04   ,Low address block 7 select" "0,1"
  bitfld.long  0x00 06.                  ",Low address block 6 select" "0,1"
  bitfld.long  0x00 05.                  ",Low address block 5 select" "0,1"
  bitfld.long  0x00 04.                  ",Low address block 4 select" "0,1"
  
  bitfld.long  0x00 03.                  "  LSEL03-00   ,Low address block 3 select" "0,1"
  bitfld.long  0x00 02.                  ",Low address block 2 select" "0,1"
  bitfld.long  0x00 01.                  ",Low address block 1 select" "0,1"
  bitfld.long  0x00 00.                  ",Low address block 0 select" "0,1"
TEXTLINE ""
  

group.long (0xC3F8C000+0x014)++0x03
  line.long    0x00 "HSR,High Address Space Block Select Register"

  bitfld.long  0x00 27.                  "HBSEL27-24  ,High address space block 27 select" "0,1"
  bitfld.long  0x00 26.                  ",High address space block 26 select" "0,1"
  bitfld.long  0x00 25.                  ",High address space block 25 select" "0,1"
  bitfld.long  0x00 24.                  ",High address space block 24 select" "0,1"
  
  bitfld.long  0x00 23.                  "  HBSEL23-20  ,High address space block 23 select" "0,1"
  bitfld.long  0x00 22.                  ",High address space block 22 select" "0,1"
  bitfld.long  0x00 21.                  ",High address space block 21 select" "0,1"
  bitfld.long  0x00 20.                  ",High address space block 20 select" "0,1"
  
  bitfld.long  0x00 19.                  "  HBSEL19-16  ,High address space block 19 select" "0,1"
  bitfld.long  0x00 18.                  ",High address space block 18 select" "0,1"
  bitfld.long  0x00 17.                  ",High address space block 17 select" "0,1"
  bitfld.long  0x00 16.                  ",High address space block 16 select" "0,1"
TEXTLINE "                "
  
  bitfld.long  0x00 15.                  "  HBSEL15-12  ,High address space block 15 select" "0,1"
  bitfld.long  0x00 14.                  ",High address space block 14 select" "0,1"
  bitfld.long  0x00 13.                  ",High address space block 13 select" "0,1"
  bitfld.long  0x00 12.                  ",High address space block 12 select" "0,1"
  
  bitfld.long  0x00 11.                  "  HBSEL11-08  ,High address space block 11 select" "0,1"
  bitfld.long  0x00 10.                  ",High address space block 10 select" "0,1"
  bitfld.long  0x00 09.                  ",High address space block 9 select" "0,1"
  bitfld.long  0x00 08.                  ",High address space block 8 select" "0,1"
  
  bitfld.long  0x00 07.                  "  HBSEL07-04  ,High address space block 7 select" "0,1"
  bitfld.long  0x00 06.                  ",High address space block 6 select" "0,1"
  bitfld.long  0x00 05.                  ",High address space block 5 select" "0,1"
  bitfld.long  0x00 04.                  ",High address space block 4 select" "0,1"
  
  bitfld.long  0x00 03.                  "  HBSEL03-00  ,High address space block 3 select" "0,1"
  bitfld.long  0x00 02.                  ",High address space block 2 select" "0,1"
  bitfld.long  0x00 01.                  ",High address space block 1 select" "0,1"
  bitfld.long  0x00 00.                  ",High address space block 0 select" "0,1"
TEXTLINE ""

group.long (0xC3F8C000+0x018)++0x03
  line.long    0x00 "AR,Address Register"
TEXTLINE ""


group.long (0xC3F8C000+0x01C)++0x03
  line.long    0x00 "BIUCR,Flash Bus Interface Unit Control Register"
  bitfld.long  0x00 27.                  "MPFE11--08 ,Master 11 prefetch enable" "0,1"
  bitfld.long  0x00 26.                  ",Master 10 prefetch enable" "0,1"
  bitfld.long  0x00 25.                  ",Master 09 prefetch enable" "0,1"
  bitfld.long  0x00 24.                  ",Master 08 prefetch enable" "0,1"

  bitfld.long  0x00 23.                  "  MPFE07--04 ,Master 07 prefetch enable" "0,1"
  bitfld.long  0x00 22.                  ",Master 06 prefetch enable" "0,1"
  bitfld.long  0x00 21.                  ",Master 05 prefetch enable" "0,1"
  bitfld.long  0x00 20.                  ",Master 04 prefetch enable" "0,1"

  bitfld.long  0x00 19.                  "  MPFE03--00 ,Master 03 prefetch enable" "0,1"
  bitfld.long  0x00 18.                  ",Master 02 prefetch enable" "0,1"
  bitfld.long  0x00 17.                  ",Master 01 prefetch enable" "0,1"
  bitfld.long  0x00 16.                  ",Master 00 prefetch enable" "0,1"
  TEXTLINE "                "
  bitfld.long  0x00 13.--15.             "  APC ,Address pipelining control" "back-to-back,1 hold cycle,2 hold cycles,3 hold cycles,4 hold cycles,5 hold cycles,6 hold cycles,no pipelining"
  bitfld.long  0x00 11.--12.             "  WWSC ,Write wait state control" "0,1,2,3"
  bitfld.long  0x00 08.--10.             "  RWSC ,Read wait state control" "0,1,2,3,4,5,6,7"
  TEXTLINE "                "
  bitfld.long  0x00 06.--07.             "  DPFEN ,Data prefetch enable" "disabled,data burst,res.,any data read"
  bitfld.long  0x00 04.--05.             "  IPFEN ,Instruction prefetch enable" "disabled,inst read,res.,any inst read"
  bitfld.long  0x00 01.--03.             "  PFLIM ,Prefetch limit" "disabled,1 line,-2 lines,-3 lines,-4 lines,-5 lines,unlimited,res."
  bitfld.long  0x00 00.                  "  BFEN ,PFBIU line read buffers enable" "0,1"
TEXTLINE ""
 
 
group.long (0xC3F8C000+0x020)++0x03
  line.long    0x00 "BIUAPR,Flash Bus Interface Unit Access Protection Register"
  bitfld.long  0x00 16.--17.             "M8AP ,Master 8 access protection" "none,read,write,both"
  TEXTLINE "                "
  bitfld.long  0x00 14.--15.             "  M7AP ,Master 7 access protection" "none,read,write,both"
  bitfld.long  0x00 12.--13.             "  M6AP ,Master 6 access protection" "none,read,write,both"
  bitfld.long  0x00 10.--11.             "  M5AP ,Master 5 access protection" "none,read,write,both"
  bitfld.long  0x00 08.--09.             "  M4AP ,Master 4 access protection" "none,read,write,both"
  TEXTLINE "                "
  bitfld.long  0x00 06.--07.             "  M3AP ,Master 3 access protection" "none,read,write,both"
  bitfld.long  0x00 04.--05.             "  M2AP ,Master 2 access protection" "none,read,write,both"
  bitfld.long  0x00 02.--03.             "  M1AP ,Master 1 access protection" "none,read,write,both"
  bitfld.long  0x00 00.--01.             "  M0AP ,Master 0 access protection" "none,read,write,both"
 


tree.end

 tree.end
endif

sif (cpu()=="MPC5632M")||(cpu()=="MPC5633M")||(cpu()=="MPC5634M")||(cpu()=="SPC563M60")||(cpu()=="SPC563M64")
 tree "Flash Memory"

tree "Flash Bank 0, Array 0"

if (data.long(DBG:0x80)&0x0FFFF000)==0x08200000
 ;revision 0 with C90FL FLASH

group.long (0xC3F88000+0x000)++0x03
  line.long    0x00 "MCR,Module Configuration Register"
  bitfld.long  0x00 24.--26.               "SIZE ,Array space size. Dependent upon the size of the Flash module" "128K,256K,512K,1M,1.5M,2M,res.,res."
  bitfld.long  0x00 20.--22.             "  LAS  ,Low address space" "1x256K,2x128K,4x16K+4x48K,res.,8x16K+2x64K,res.,2x16K+2x48K+2x64K,res."
  bitfld.long  0x00 16.                  "  MAS  ,Mid address space size" "2x128K,1x256K"

TEXTLINE "                "
  eventfld.long  0x00 15.                "  EER  ,ECC event error" "0,1"
  eventfld.long  0x00 14.                "  RWE  ,Read while write event error" "0,1"
  eventfld.long  0x00 13.                "  SBC  ,Single Bit Correction" "0,1"
  bitfld.long  0x00 11.                  "  PEAS ,Program/erase access space" "0,1"
  bitfld.long  0x00 10.                  "  DONE ,State machine status" "0,1"
  bitfld.long  0x00 09.                  "  PEG  ,Program/erase good" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 04.                  "  PGM  ,Program" "0,1"
  bitfld.long  0x00 03.                  "  PSUS ,Program suspend" "0,1"
  bitfld.long  0x00 02.                  "  ERS  ,Erase" "0,1"
  bitfld.long  0x00 01.                  "  ESUS ,Erase suspend" "0,1"
  bitfld.long  0x00 00.                  "  EHV  ,Enable high voltage" "0,1"

else
;revisions newer than 0 with C90LC FLASH

group.long (0xC3F88000+0x000)++0x03
  line.long    0x00 "MCR,Module Configuration Register"
  eventfld.long  0x00 31.                "EDC  ,ECC Data Correction" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 24.--26.             "  SIZE ,Array space size. Dependent upon the size of the Flash module" "128K,256K,512K,1M,1.5M,2M,res.,res."
  bitfld.long  0x00 20.--22.             "  LAS  ,Low address space" "none,res.,res.,res.,res.,res.,res.,2*16K + 2*32K + 2*16K + 2*64K"
  bitfld.long  0x00 16.                  "  MAS  ,Mid address space size" "2x128K,none"
TEXTLINE "                "
  eventfld.long  0x00 15.                "  EER  ,ECC event error" "0,1"
  eventfld.long  0x00 14.                "  RWE  ,Read while write event error" "0,1"
  bitfld.long  0x00 11.                  "  PEAS ,Program/erase access space" "0,1"
  bitfld.long  0x00 10.                  "  DONE ,State machine status" "0,1"
  bitfld.long  0x00 09.                  "  PEG  ,Program/erase good" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 04.                  "  PGM  ,Program" "0,1"
  bitfld.long  0x00 03.                  "  PSUS ,Program suspend" "0,1"
  bitfld.long  0x00 02.                  "  ERS  ,Erase" "0,1"
  bitfld.long  0x00 01.                  "  ESUS ,Erase suspend" "0,1"
  bitfld.long  0x00 00.                  "  EHV  ,Enable high voltage" "0,1"
TEXTLINE ""

endif
  
group.long (0xC3F88000+0x004)++0x03
  line.long    0x00 "LMLR,Low/Mid Address Space Block Locking Register"
  bitfld.long  0x00 31.                  "LME  ,Low and mid address lock enable" "0,1"
  bitfld.long  0x00 20.                  " SLOCK ,Shadow lock" "0,1"

  bitfld.long  0x00 19.                  "    MLOCK03-00 ,Mid address block 3 lock" "0,1"
  bitfld.long  0x00 18.                  ",Mid address block 2 lock" "0,1"
  bitfld.long  0x00 17.                  ",Mid address block 1 lock" "0,1"
  bitfld.long  0x00 16.                  ",Mid address block 0 lock" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.                  "  LLOCK15-12 ,Low address block 15 lock" "0,1"
  bitfld.long  0x00 14.                  ",Low address block 14 lock" "0,1"
  bitfld.long  0x00 13.                  ",Low address block 13 lock" "0,1"
  bitfld.long  0x00 12.                  ",Low address block 12 lock" "0,1"
  
  bitfld.long  0x00 11.                  "   LLOCK11-08  ,Low address block 11 lock" "0,1"
  bitfld.long  0x00 10.                  ",Low address block 10 lock" "0,1"
  bitfld.long  0x00 09.                  ",Low address block 9 lock" "0,1"
  bitfld.long  0x00 08.                  ",Low address block 8 lock" "0,1"
  
  bitfld.long  0x00 07.                  "  LLOCK07-04  ,Low address block 7 lock" "0,1"
  bitfld.long  0x00 06.                  ",Low address block 6 lock" "0,1"
  bitfld.long  0x00 05.                  ",Low address block 5 lock" "0,1"
  bitfld.long  0x00 04.                  ",Low address block 4 lock" "0,1"
  
  bitfld.long  0x00 03.                  "  LLOCK03-00  ,Low address block 3 lock" "0,1"
  bitfld.long  0x00 02.                  ",Low address block 2 lock" "0,1"
  bitfld.long  0x00 01.                  ",Low address block 1 lock" "0,1"
  bitfld.long  0x00 00.                  ",Low address block 0 lock" "0,1"
TEXTLINE ""
  
group.long (0xC3F88000+0x008)++0x03
  line.long    0x00 "HLR,High Address Space Block Locking Register"
  bitfld.long  0x00 31.                  "HBE ,High address lock enable" "0,1"

  bitfld.long  0x00 27.                  "             HBLOCK27-24 ,High address space block 27 lock" "0,1"
  bitfld.long  0x00 26.                  ",High address space block 26 lock" "0,1"
  bitfld.long  0x00 25.                  ",High address space block 25 lock" "0,1"
  bitfld.long  0x00 24.                  ",High address space block 24 lock" "0,1"
  
  bitfld.long  0x00 23.                  "  HBLOCK23-20 ,High address space block 23 lock" "0,1"
  bitfld.long  0x00 22.                  ",High address space block 22 lock" "0,1"
  bitfld.long  0x00 21.                  ",High address space block 21 lock" "0,1"
  bitfld.long  0x00 20.                  ",High address space block 20 lock" "0,1"
  
  bitfld.long  0x00 19.                  "  HBLOCK19-16 ,High address space block 19 lock" "0,1"
  bitfld.long  0x00 18.                  ",High address space block 18 lock" "0,1"
  bitfld.long  0x00 17.                  ",High address space block 17 lock" "0,1"
  bitfld.long  0x00 16.                  ",High address space block 16 lock" "0,1"
TEXTLINE "                "
  
  bitfld.long  0x00 15.                  "  HBLOCK15-12 ,High address space block 15 lock" "0,1"
  bitfld.long  0x00 14.                  ",High address space block 14 lock" "0,1"
  bitfld.long  0x00 13.                  ",High address space block 13 lock" "0,1"
  bitfld.long  0x00 12.                  ",High address space block 12 lock" "0,1"
  
  bitfld.long  0x00 11.                  "  HBLOCK11-08 ,High address space block 11 lock" "0,1"
  bitfld.long  0x00 10.                  ",High address space block 10 lock" "0,1"
  bitfld.long  0x00 09.                  ",High address space block 9 lock" "0,1"
  bitfld.long  0x00 08.                  ",High address space block 8 lock" "0,1"
  
  bitfld.long  0x00 07.                  "  HBLOCK07-04 ,High address space block 7 lock" "0,1"
  bitfld.long  0x00 06.                  ",High address space block 6 lock" "0,1"
  bitfld.long  0x00 05.                  ",High address space block 5 lock" "0,1"
  bitfld.long  0x00 04.                  ",High address space block 4 lock" "0,1"
  
  bitfld.long  0x00 03.                  "  HBLOCK03-00 ,High address space block 3 lock" "0,1"
  bitfld.long  0x00 02.                  ",High address space block 2 lock" "0,1"
  bitfld.long  0x00 01.                  ",High address space block 1 lock" "0,1"
  bitfld.long  0x00 00.                  ",High address space block 0 lock" "0,1"
TEXTLINE ""
  
  
group.long (0xC3F88000+0x00C)++0x03
  line.long    0x00 "SLMLR,Secondary Low/Mid Address Space Block Locking Register"
  bitfld.long  0x00 31.                  "SME ,Secondary low and mid address lock enable" "0,1"
  bitfld.long  0x00 20.                  "  SSLOCK ,Secondary shadow lock" "0,1"

  bitfld.long  0x00 19.                  "   SMLOCK03-00 ,Secondary Mid address block 3 lock" "0,1"
  bitfld.long  0x00 18.                  ",Secondary Mid address block 2 lock" "0,1"
  bitfld.long  0x00 17.                  ",Secondary Mid address block 1 lock" "0,1"
  bitfld.long  0x00 16.                  ",Secondary Mid address block 0 lock" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.                  "  SLLOCK15-12 ,Secondary Low address block 15 lock" "0,1"
  bitfld.long  0x00 14.                  ",Secondary Low address block 14 lock" "0,1"
  bitfld.long  0x00 13.                  ",Secondary Low address block 13 lock" "0,1"
  bitfld.long  0x00 12.                  ",Secondary Low address block 12 lock" "0,1"
  
  bitfld.long  0x00 11.                  "  SLLOCK11-08 ,Secondary Low address block 11 lock" "0,1"
  bitfld.long  0x00 10.                  ",Secondary Low address block 10 lock" "0,1"
  bitfld.long  0x00 09.                  ",Secondary Low address block 9 lock" "0,1"
  bitfld.long  0x00 08.                  ",Secondary Low address block 8 lock" "0,1"
  
  bitfld.long  0x00 07.                  "  SLLOCK07-04 ,Secondary Low address block 7 lock" "0,1"
  bitfld.long  0x00 06.                  ",Secondary Low address block 6 lock" "0,1"
  bitfld.long  0x00 05.                  ",Secondary Low address block 5 lock" "0,1"
  bitfld.long  0x00 04.                  ",Secondary Low address block 4 lock" "0,1"
  
  bitfld.long  0x00 03.                  "  SLLOCK03-00 ,Secondary Low address block 3 lock" "0,1"
  bitfld.long  0x00 02.                  ",Secondary Low address block 2 lock" "0,1"
  bitfld.long  0x00 01.                  ",Secondary Low address block 1 lock" "0,1"
  bitfld.long  0x00 00.                  ",Secondary Low address block 0 lock" "0,1"
TEXTLINE ""
  
group.long (0xC3F88000+0x010)++0x03
  line.long    0x00 "LMSR,Low/Mid Address Space Block Select Register"

  bitfld.long  0x00 19.                  "MSEL03-00   ,Mid address block 3 select" "0,1"
  bitfld.long  0x00 18.                  ",Mid address block 2 select" "0,1"
  bitfld.long  0x00 17.                  ",Mid address block 1 select" "0,1"
  bitfld.long  0x00 16.                  ",Mid address block 0 select" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.                  "  LSEL15-12   ,Low address block 15 select" "0,1"
  bitfld.long  0x00 14.                  ",Low address block 14 select" "0,1"
  bitfld.long  0x00 13.                  ",Low address block 13 select" "0,1"
  bitfld.long  0x00 12.                  ",Low address block 12 select" "0,1"
  
  bitfld.long  0x00 11.                  "  LSEL11-08   ,Low address block 11 select" "0,1"
  bitfld.long  0x00 10.                  ",Low address block 10 select" "0,1"
  bitfld.long  0x00 09.                  ",Low address block 9 select" "0,1"
  bitfld.long  0x00 08.                  ",Low address block 8 select" "0,1"
  
  bitfld.long  0x00 07.                  "  LSEL07-04   ,Low address block 7 select" "0,1"
  bitfld.long  0x00 06.                  ",Low address block 6 select" "0,1"
  bitfld.long  0x00 05.                  ",Low address block 5 select" "0,1"
  bitfld.long  0x00 04.                  ",Low address block 4 select" "0,1"
  
  bitfld.long  0x00 03.                  "  LSEL03-00   ,Low address block 3 select" "0,1"
  bitfld.long  0x00 02.                  ",Low address block 2 select" "0,1"
  bitfld.long  0x00 01.                  ",Low address block 1 select" "0,1"
  bitfld.long  0x00 00.                  ",Low address block 0 select" "0,1"
TEXTLINE ""
  

group.long (0xC3F88000+0x014)++0x03
  line.long    0x00 "HSR,High Address Space Block Select Register"

  bitfld.long  0x00 27.                  "HBSEL27-24  ,High address space block 27 select" "0,1"
  bitfld.long  0x00 26.                  ",High address space block 26 select" "0,1"
  bitfld.long  0x00 25.                  ",High address space block 25 select" "0,1"
  bitfld.long  0x00 24.                  ",High address space block 24 select" "0,1"
  
  bitfld.long  0x00 23.                  "  HBSEL23-20  ,High address space block 23 select" "0,1"
  bitfld.long  0x00 22.                  ",High address space block 22 select" "0,1"
  bitfld.long  0x00 21.                  ",High address space block 21 select" "0,1"
  bitfld.long  0x00 20.                  ",High address space block 20 select" "0,1"
  
  bitfld.long  0x00 19.                  "  HBSEL19-16  ,High address space block 19 select" "0,1"
  bitfld.long  0x00 18.                  ",High address space block 18 select" "0,1"
  bitfld.long  0x00 17.                  ",High address space block 17 select" "0,1"
  bitfld.long  0x00 16.                  ",High address space block 16 select" "0,1"
TEXTLINE "                "
  
  bitfld.long  0x00 15.                  "  HBSEL15-12  ,High address space block 15 select" "0,1"
  bitfld.long  0x00 14.                  ",High address space block 14 select" "0,1"
  bitfld.long  0x00 13.                  ",High address space block 13 select" "0,1"
  bitfld.long  0x00 12.                  ",High address space block 12 select" "0,1"
  
  bitfld.long  0x00 11.                  "  HBSEL11-08  ,High address space block 11 select" "0,1"
  bitfld.long  0x00 10.                  ",High address space block 10 select" "0,1"
  bitfld.long  0x00 09.                  ",High address space block 9 select" "0,1"
  bitfld.long  0x00 08.                  ",High address space block 8 select" "0,1"
  
  bitfld.long  0x00 07.                  "  HBSEL07-04  ,High address space block 7 select" "0,1"
  bitfld.long  0x00 06.                  ",High address space block 6 select" "0,1"
  bitfld.long  0x00 05.                  ",High address space block 5 select" "0,1"
  bitfld.long  0x00 04.                  ",High address space block 4 select" "0,1"
  
  bitfld.long  0x00 03.                  "  HBSEL03-00  ,High address space block 3 select" "0,1"
  bitfld.long  0x00 02.                  ",High address space block 2 select" "0,1"
  bitfld.long  0x00 01.                  ",High address space block 1 select" "0,1"
  bitfld.long  0x00 00.                  ",High address space block 0 select" "0,1"
TEXTLINE ""

group.long (0xC3F88000+0x018)++0x03
  line.long    0x00 "AR,Address Register"
TEXTLINE ""


group.long (0xC3F88000+0x01C)++0x03
  line.long    0x00 "BIUCR,Flash Bus Interface Unit Control Register"
  bitfld.long  0x00 19.                  "MPFE03--00 ,Master 03 prefetch enable" "0,1"
  bitfld.long  0x00 18.                  ",Master 02 prefetch enable" "0,1"
  bitfld.long  0x00 17.                  ",Master 01 prefetch enable" "0,1"
  bitfld.long  0x00 16.                  ",Master 00 prefetch enable" "0,1"

  bitfld.long  0x00 13.--15.             "  APC ,Address pipelining control" "back-to-back,1 hold cycle,2 hold cycles,3 hold cycles,4 hold cycles,5 hold cycles,6 hold cycles,no pipelining"
  bitfld.long  0x00 11.--12.             "  WWSC ,Write wait state control" "0,1,2,3"
  bitfld.long  0x00 08.--10.             "  RWSC ,Read wait state control" "0,1,res(2),res(3),res(4),res(5),res(6),7"
  TEXTLINE "                "
  bitfld.long  0x00 06.--07.             "  DPFEN ,Data prefetch enable" "disabled,data burst,res.,any data read"
  bitfld.long  0x00 04.--05.             "  IPFEN ,Instruction prefetch enable" "disabled,inst read,res.,any inst read"
  bitfld.long  0x00 01.--03.             "  PFLIM ,Prefetch limit" "disabled,1 line,-2 lines,-3 lines,-4 lines,-5 lines,unlimited,res."
  bitfld.long  0x00 00.                  "  BFEN ,PFBIU line read buffers enable" "0,1"
TEXTLINE ""
 
 
group.long (0xC3F88000+0x020)++0x03
  line.long    0x00 "BIUAPR,Flash Bus Interface Unit Access Protection Register"
  bitfld.long  0x00 06.--07.             "M3AP ,EBI Master access protection" "none,read,write,both"
  bitfld.long  0x00 04.--05.             "  M2AP ,eDMA Master access protection" "none,read,write,both"
  bitfld.long  0x00 02.--03.             "  M1AP ,Nexus Master access protection" "none,read,write,both"
  bitfld.long  0x00 00.--01.             "  M0AP ,Core Master access protection" "none,read,write,both"
 


tree.end


tree "Flash Bank 1, Array 1"

if (data.long(DBG:0x80)&0x0FFFF000)==0x08200000
 ;revision 0 with C90FL FLASH

group.long (0xC3FB0000+0x000)++0x03
  line.long    0x00 "MCR,Module Configuration Register"
  bitfld.long  0x00 24.--26.               "SIZE ,Array space size. Dependent upon the size of the Flash module" "128K,256K,512K,1M,1.5M,2M,res.,res."
  bitfld.long  0x00 20.--22.             "  LAS  ,Low address space" "1x256K,2x128K,4x16K+4x48K,res.,8x16K+2x64K,res.,2x16K+2x48K+2x64K,res."
  bitfld.long  0x00 16.                  "  MAS  ,Mid address space size" "2x128K,1x256K"

TEXTLINE "                "
  eventfld.long  0x00 15.                "  EER  ,ECC event error" "0,1"
  eventfld.long  0x00 14.                "  RWE  ,Read while write event error" "0,1"
  eventfld.long  0x00 13.                "  SBC  ,Single Bit Correction" "0,1"
  bitfld.long  0x00 11.                  "  PEAS ,Program/erase access space" "0,1"
  bitfld.long  0x00 10.                  "  DONE ,State machine status" "0,1"
  bitfld.long  0x00 09.                  "  PEG  ,Program/erase good" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 04.                  "  PGM  ,Program" "0,1"
  bitfld.long  0x00 03.                  "  PSUS ,Program suspend" "0,1"
  bitfld.long  0x00 02.                  "  ERS  ,Erase" "0,1"
  bitfld.long  0x00 01.                  "  ESUS ,Erase suspend" "0,1"
  bitfld.long  0x00 00.                  "  EHV  ,Enable high voltage" "0,1"

else
;revisions newer than 0 with C90LC FLASH

group.long (0xC3FB0000+0x000)++0x03
  line.long    0x00 "MCR,Module Configuration Register"
  eventfld.long  0x00 31.                "EDC  ,ECC Data Correction" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 24.--26.             "  SIZE ,Array space size. Dependent upon the size of the Flash module" "128K,256K,512K,1M,1.5M,2M,res.,res."
  bitfld.long  0x00 20.--22.             "  LAS  ,Low address space" "none,res.,res.,res.,res.,res.,res.,2*16K + 2*32K + 2*16K + 2*64K"
  bitfld.long  0x00 16.                  "  MAS  ,Mid address space size" "2x128K,none"
TEXTLINE "                "
  eventfld.long  0x00 15.                "  EER  ,ECC event error" "0,1"
  eventfld.long  0x00 14.                "  RWE  ,Read while write event error" "0,1"
  bitfld.long  0x00 11.                  "  PEAS ,Program/erase access space" "0,1"
  bitfld.long  0x00 10.                  "  DONE ,State machine status" "0,1"
  bitfld.long  0x00 09.                  "  PEG  ,Program/erase good" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 04.                  "  PGM  ,Program" "0,1"
  bitfld.long  0x00 03.                  "  PSUS ,Program suspend" "0,1"
  bitfld.long  0x00 02.                  "  ERS  ,Erase" "0,1"
  bitfld.long  0x00 01.                  "  ESUS ,Erase suspend" "0,1"
  bitfld.long  0x00 00.                  "  EHV  ,Enable high voltage" "0,1"
TEXTLINE ""

endif
  
group.long (0xC3FB0000+0x004)++0x03
  line.long    0x00 "LMLR,Low/Mid Address Space Block Locking Register"
  bitfld.long  0x00 31.                  "LME  ,Low and mid address lock enable" "0,1"
  bitfld.long  0x00 20.                  " SLOCK ,Shadow lock" "0,1"

  bitfld.long  0x00 19.                  "    MLOCK03-00 ,Mid address block 3 lock" "0,1"
  bitfld.long  0x00 18.                  ",Mid address block 2 lock" "0,1"
  bitfld.long  0x00 17.                  ",Mid address block 1 lock" "0,1"
  bitfld.long  0x00 16.                  ",Mid address block 0 lock" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.                  "  LLOCK15-12 ,Low address block 15 lock" "0,1"
  bitfld.long  0x00 14.                  ",Low address block 14 lock" "0,1"
  bitfld.long  0x00 13.                  ",Low address block 13 lock" "0,1"
  bitfld.long  0x00 12.                  ",Low address block 12 lock" "0,1"
  
  bitfld.long  0x00 11.                  "   LLOCK11-08  ,Low address block 11 lock" "0,1"
  bitfld.long  0x00 10.                  ",Low address block 10 lock" "0,1"
  bitfld.long  0x00 09.                  ",Low address block 9 lock" "0,1"
  bitfld.long  0x00 08.                  ",Low address block 8 lock" "0,1"
  
  bitfld.long  0x00 07.                  "  LLOCK07-04  ,Low address block 7 lock" "0,1"
  bitfld.long  0x00 06.                  ",Low address block 6 lock" "0,1"
  bitfld.long  0x00 05.                  ",Low address block 5 lock" "0,1"
  bitfld.long  0x00 04.                  ",Low address block 4 lock" "0,1"
  
  bitfld.long  0x00 03.                  "  LLOCK03-00  ,Low address block 3 lock" "0,1"
  bitfld.long  0x00 02.                  ",Low address block 2 lock" "0,1"
  bitfld.long  0x00 01.                  ",Low address block 1 lock" "0,1"
  bitfld.long  0x00 00.                  ",Low address block 0 lock" "0,1"
TEXTLINE ""
  
group.long (0xC3FB0000+0x008)++0x03
  line.long    0x00 "HLR,High Address Space Block Locking Register"
  bitfld.long  0x00 31.                  "HBE ,High address lock enable" "0,1"

  bitfld.long  0x00 27.                  "             HBLOCK27-24 ,High address space block 27 lock" "0,1"
  bitfld.long  0x00 26.                  ",High address space block 26 lock" "0,1"
  bitfld.long  0x00 25.                  ",High address space block 25 lock" "0,1"
  bitfld.long  0x00 24.                  ",High address space block 24 lock" "0,1"
  
  bitfld.long  0x00 23.                  "  HBLOCK23-20 ,High address space block 23 lock" "0,1"
  bitfld.long  0x00 22.                  ",High address space block 22 lock" "0,1"
  bitfld.long  0x00 21.                  ",High address space block 21 lock" "0,1"
  bitfld.long  0x00 20.                  ",High address space block 20 lock" "0,1"
  
  bitfld.long  0x00 19.                  "  HBLOCK19-16 ,High address space block 19 lock" "0,1"
  bitfld.long  0x00 18.                  ",High address space block 18 lock" "0,1"
  bitfld.long  0x00 17.                  ",High address space block 17 lock" "0,1"
  bitfld.long  0x00 16.                  ",High address space block 16 lock" "0,1"
TEXTLINE "                "
  
  bitfld.long  0x00 15.                  "  HBLOCK15-12 ,High address space block 15 lock" "0,1"
  bitfld.long  0x00 14.                  ",High address space block 14 lock" "0,1"
  bitfld.long  0x00 13.                  ",High address space block 13 lock" "0,1"
  bitfld.long  0x00 12.                  ",High address space block 12 lock" "0,1"
  
  bitfld.long  0x00 11.                  "  HBLOCK11-08 ,High address space block 11 lock" "0,1"
  bitfld.long  0x00 10.                  ",High address space block 10 lock" "0,1"
  bitfld.long  0x00 09.                  ",High address space block 9 lock" "0,1"
  bitfld.long  0x00 08.                  ",High address space block 8 lock" "0,1"
  
  bitfld.long  0x00 07.                  "  HBLOCK07-04 ,High address space block 7 lock" "0,1"
  bitfld.long  0x00 06.                  ",High address space block 6 lock" "0,1"
  bitfld.long  0x00 05.                  ",High address space block 5 lock" "0,1"
  bitfld.long  0x00 04.                  ",High address space block 4 lock" "0,1"
  
  bitfld.long  0x00 03.                  "  HBLOCK03-00 ,High address space block 3 lock" "0,1"
  bitfld.long  0x00 02.                  ",High address space block 2 lock" "0,1"
  bitfld.long  0x00 01.                  ",High address space block 1 lock" "0,1"
  bitfld.long  0x00 00.                  ",High address space block 0 lock" "0,1"
TEXTLINE ""
  
  
group.long (0xC3FB0000+0x00C)++0x03
  line.long    0x00 "SLMLR,Secondary Low/Mid Address Space Block Locking Register"
  bitfld.long  0x00 31.                  "SME ,Secondary low and mid address lock enable" "0,1"
  bitfld.long  0x00 20.                  "  SSLOCK ,Secondary shadow lock" "0,1"

  bitfld.long  0x00 19.                  "   SMLOCK03-00 ,Secondary Mid address block 3 lock" "0,1"
  bitfld.long  0x00 18.                  ",Secondary Mid address block 2 lock" "0,1"
  bitfld.long  0x00 17.                  ",Secondary Mid address block 1 lock" "0,1"
  bitfld.long  0x00 16.                  ",Secondary Mid address block 0 lock" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.                  "  SLLOCK15-12 ,Secondary Low address block 15 lock" "0,1"
  bitfld.long  0x00 14.                  ",Secondary Low address block 14 lock" "0,1"
  bitfld.long  0x00 13.                  ",Secondary Low address block 13 lock" "0,1"
  bitfld.long  0x00 12.                  ",Secondary Low address block 12 lock" "0,1"
  
  bitfld.long  0x00 11.                  "  SLLOCK11-08 ,Secondary Low address block 11 lock" "0,1"
  bitfld.long  0x00 10.                  ",Secondary Low address block 10 lock" "0,1"
  bitfld.long  0x00 09.                  ",Secondary Low address block 9 lock" "0,1"
  bitfld.long  0x00 08.                  ",Secondary Low address block 8 lock" "0,1"
  
  bitfld.long  0x00 07.                  "  SLLOCK07-04 ,Secondary Low address block 7 lock" "0,1"
  bitfld.long  0x00 06.                  ",Secondary Low address block 6 lock" "0,1"
  bitfld.long  0x00 05.                  ",Secondary Low address block 5 lock" "0,1"
  bitfld.long  0x00 04.                  ",Secondary Low address block 4 lock" "0,1"
  
  bitfld.long  0x00 03.                  "  SLLOCK03-00 ,Secondary Low address block 3 lock" "0,1"
  bitfld.long  0x00 02.                  ",Secondary Low address block 2 lock" "0,1"
  bitfld.long  0x00 01.                  ",Secondary Low address block 1 lock" "0,1"
  bitfld.long  0x00 00.                  ",Secondary Low address block 0 lock" "0,1"
TEXTLINE ""
  
group.long (0xC3FB0000+0x010)++0x03
  line.long    0x00 "LMSR,Low/Mid Address Space Block Select Register"

  bitfld.long  0x00 19.                  "MSEL03-00   ,Mid address block 3 select" "0,1"
  bitfld.long  0x00 18.                  ",Mid address block 2 select" "0,1"
  bitfld.long  0x00 17.                  ",Mid address block 1 select" "0,1"
  bitfld.long  0x00 16.                  ",Mid address block 0 select" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.                  "  LSEL15-12   ,Low address block 15 select" "0,1"
  bitfld.long  0x00 14.                  ",Low address block 14 select" "0,1"
  bitfld.long  0x00 13.                  ",Low address block 13 select" "0,1"
  bitfld.long  0x00 12.                  ",Low address block 12 select" "0,1"
  
  bitfld.long  0x00 11.                  "  LSEL11-08   ,Low address block 11 select" "0,1"
  bitfld.long  0x00 10.                  ",Low address block 10 select" "0,1"
  bitfld.long  0x00 09.                  ",Low address block 9 select" "0,1"
  bitfld.long  0x00 08.                  ",Low address block 8 select" "0,1"
  
  bitfld.long  0x00 07.                  "  LSEL07-04   ,Low address block 7 select" "0,1"
  bitfld.long  0x00 06.                  ",Low address block 6 select" "0,1"
  bitfld.long  0x00 05.                  ",Low address block 5 select" "0,1"
  bitfld.long  0x00 04.                  ",Low address block 4 select" "0,1"
  
  bitfld.long  0x00 03.                  "  LSEL03-00   ,Low address block 3 select" "0,1"
  bitfld.long  0x00 02.                  ",Low address block 2 select" "0,1"
  bitfld.long  0x00 01.                  ",Low address block 1 select" "0,1"
  bitfld.long  0x00 00.                  ",Low address block 0 select" "0,1"
TEXTLINE ""
  

group.long (0xC3FB0000+0x014)++0x03
  line.long    0x00 "HSR,High Address Space Block Select Register"

  bitfld.long  0x00 27.                  "HBSEL27-24  ,High address space block 27 select" "0,1"
  bitfld.long  0x00 26.                  ",High address space block 26 select" "0,1"
  bitfld.long  0x00 25.                  ",High address space block 25 select" "0,1"
  bitfld.long  0x00 24.                  ",High address space block 24 select" "0,1"
  
  bitfld.long  0x00 23.                  "  HBSEL23-20  ,High address space block 23 select" "0,1"
  bitfld.long  0x00 22.                  ",High address space block 22 select" "0,1"
  bitfld.long  0x00 21.                  ",High address space block 21 select" "0,1"
  bitfld.long  0x00 20.                  ",High address space block 20 select" "0,1"
  
  bitfld.long  0x00 19.                  "  HBSEL19-16  ,High address space block 19 select" "0,1"
  bitfld.long  0x00 18.                  ",High address space block 18 select" "0,1"
  bitfld.long  0x00 17.                  ",High address space block 17 select" "0,1"
  bitfld.long  0x00 16.                  ",High address space block 16 select" "0,1"
TEXTLINE "                "
  
  bitfld.long  0x00 15.                  "  HBSEL15-12  ,High address space block 15 select" "0,1"
  bitfld.long  0x00 14.                  ",High address space block 14 select" "0,1"
  bitfld.long  0x00 13.                  ",High address space block 13 select" "0,1"
  bitfld.long  0x00 12.                  ",High address space block 12 select" "0,1"
  
  bitfld.long  0x00 11.                  "  HBSEL11-08  ,High address space block 11 select" "0,1"
  bitfld.long  0x00 10.                  ",High address space block 10 select" "0,1"
  bitfld.long  0x00 09.                  ",High address space block 9 select" "0,1"
  bitfld.long  0x00 08.                  ",High address space block 8 select" "0,1"
  
  bitfld.long  0x00 07.                  "  HBSEL07-04  ,High address space block 7 select" "0,1"
  bitfld.long  0x00 06.                  ",High address space block 6 select" "0,1"
  bitfld.long  0x00 05.                  ",High address space block 5 select" "0,1"
  bitfld.long  0x00 04.                  ",High address space block 4 select" "0,1"
  
  bitfld.long  0x00 03.                  "  HBSEL03-00  ,High address space block 3 select" "0,1"
  bitfld.long  0x00 02.                  ",High address space block 2 select" "0,1"
  bitfld.long  0x00 01.                  ",High address space block 1 select" "0,1"
  bitfld.long  0x00 00.                  ",High address space block 0 select" "0,1"
TEXTLINE ""

group.long (0xC3FB0000+0x018)++0x03
  line.long    0x00 "AR,Address Register"
TEXTLINE ""


group.long (0xC3FB0000+0x01C)++0x03
  line.long    0x00 "BIUCR,Flash Bus Interface Unit Control Register"
  bitfld.long  0x00 19.                  "MPFE03--00 ,Master 03 prefetch enable" "0,1"
  bitfld.long  0x00 18.                  ",Master 02 prefetch enable" "0,1"
  bitfld.long  0x00 17.                  ",Master 01 prefetch enable" "0,1"
  bitfld.long  0x00 16.                  ",Master 00 prefetch enable" "0,1"

  bitfld.long  0x00 13.--15.             "  APC ,Address pipelining control" "back-to-back,1 hold cycle,2 hold cycles,3 hold cycles,4 hold cycles,5 hold cycles,6 hold cycles,no pipelining"
  bitfld.long  0x00 11.--12.             "  WWSC ,Write wait state control" "0,1,2,3"
  bitfld.long  0x00 08.--10.             "  RWSC ,Read wait state control" "0,1,res(2),res(3),res(4),res(5),res(6),7"
  TEXTLINE "                "
  bitfld.long  0x00 06.--07.             "  DPFEN ,Data prefetch enable" "disabled,data burst,res.,any data read"
  bitfld.long  0x00 04.--05.             "  IPFEN ,Instruction prefetch enable" "disabled,inst read,res.,any inst read"
  bitfld.long  0x00 01.--03.             "  PFLIM ,Prefetch limit" "disabled,1 line,-2 lines,-3 lines,-4 lines,-5 lines,unlimited,res."
  bitfld.long  0x00 00.                  "  BFEN ,PFBIU line read buffers enable" "0,1"
TEXTLINE ""
 
 
group.long (0xC3FB0000+0x020)++0x03
  line.long    0x00 "BIUAPR,Flash Bus Interface Unit Access Protection Register"
  bitfld.long  0x00 06.--07.             "M3AP ,EBI Master access protection" "none,read,write,both"
  bitfld.long  0x00 04.--05.             "  M2AP ,eDMA Master access protection" "none,read,write,both"
  bitfld.long  0x00 02.--03.             "  M1AP ,Nexus Master access protection" "none,read,write,both"
  bitfld.long  0x00 00.--01.             "  M0AP ,Core Master access protection" "none,read,write,both"
 


tree.end


tree "Flash Bank 1, Array 2"

if (data.long(DBG:0x80)&0x0FFFF000)==0x08200000
 ;revision 0 with C90FL FLASH

group.long (0xC3FB4000+0x000)++0x03
  line.long    0x00 "MCR,Module Configuration Register"
  bitfld.long  0x00 24.--26.               "SIZE ,Array space size. Dependent upon the size of the Flash module" "128K,256K,512K,1M,1.5M,2M,res.,res."
  bitfld.long  0x00 20.--22.             "  LAS  ,Low address space" "1x256K,2x128K,4x16K+4x48K,res.,8x16K+2x64K,res.,2x16K+2x48K+2x64K,res."
  bitfld.long  0x00 16.                  "  MAS  ,Mid address space size" "2x128K,1x256K"

TEXTLINE "                "
  eventfld.long  0x00 15.                "  EER  ,ECC event error" "0,1"
  eventfld.long  0x00 14.                "  RWE  ,Read while write event error" "0,1"
  eventfld.long  0x00 13.                "  SBC  ,Single Bit Correction" "0,1"
  bitfld.long  0x00 11.                  "  PEAS ,Program/erase access space" "0,1"
  bitfld.long  0x00 10.                  "  DONE ,State machine status" "0,1"
  bitfld.long  0x00 09.                  "  PEG  ,Program/erase good" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 04.                  "  PGM  ,Program" "0,1"
  bitfld.long  0x00 03.                  "  PSUS ,Program suspend" "0,1"
  bitfld.long  0x00 02.                  "  ERS  ,Erase" "0,1"
  bitfld.long  0x00 01.                  "  ESUS ,Erase suspend" "0,1"
  bitfld.long  0x00 00.                  "  EHV  ,Enable high voltage" "0,1"

else
;revisions newer than 0 with C90LC FLASH

group.long (0xC3FB4000+0x000)++0x03
  line.long    0x00 "MCR,Module Configuration Register"
  eventfld.long  0x00 31.                "EDC  ,ECC Data Correction" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 24.--26.             "  SIZE ,Array space size. Dependent upon the size of the Flash module" "128K,256K,512K,1M,1.5M,2M,res.,res."
  bitfld.long  0x00 20.--22.             "  LAS  ,Low address space" "none,res.,res.,res.,res.,res.,res.,2*16K + 2*32K + 2*16K + 2*64K"
  bitfld.long  0x00 16.                  "  MAS  ,Mid address space size" "2x128K,none"
TEXTLINE "                "
  eventfld.long  0x00 15.                "  EER  ,ECC event error" "0,1"
  eventfld.long  0x00 14.                "  RWE  ,Read while write event error" "0,1"
  bitfld.long  0x00 11.                  "  PEAS ,Program/erase access space" "0,1"
  bitfld.long  0x00 10.                  "  DONE ,State machine status" "0,1"
  bitfld.long  0x00 09.                  "  PEG  ,Program/erase good" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 04.                  "  PGM  ,Program" "0,1"
  bitfld.long  0x00 03.                  "  PSUS ,Program suspend" "0,1"
  bitfld.long  0x00 02.                  "  ERS  ,Erase" "0,1"
  bitfld.long  0x00 01.                  "  ESUS ,Erase suspend" "0,1"
  bitfld.long  0x00 00.                  "  EHV  ,Enable high voltage" "0,1"
TEXTLINE ""

endif
  
group.long (0xC3FB4000+0x004)++0x03
  line.long    0x00 "LMLR,Low/Mid Address Space Block Locking Register"
  bitfld.long  0x00 31.                  "LME  ,Low and mid address lock enable" "0,1"
  bitfld.long  0x00 20.                  " SLOCK ,Shadow lock" "0,1"

  bitfld.long  0x00 19.                  "    MLOCK03-00 ,Mid address block 3 lock" "0,1"
  bitfld.long  0x00 18.                  ",Mid address block 2 lock" "0,1"
  bitfld.long  0x00 17.                  ",Mid address block 1 lock" "0,1"
  bitfld.long  0x00 16.                  ",Mid address block 0 lock" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.                  "  LLOCK15-12 ,Low address block 15 lock" "0,1"
  bitfld.long  0x00 14.                  ",Low address block 14 lock" "0,1"
  bitfld.long  0x00 13.                  ",Low address block 13 lock" "0,1"
  bitfld.long  0x00 12.                  ",Low address block 12 lock" "0,1"
  
  bitfld.long  0x00 11.                  "   LLOCK11-08  ,Low address block 11 lock" "0,1"
  bitfld.long  0x00 10.                  ",Low address block 10 lock" "0,1"
  bitfld.long  0x00 09.                  ",Low address block 9 lock" "0,1"
  bitfld.long  0x00 08.                  ",Low address block 8 lock" "0,1"
  
  bitfld.long  0x00 07.                  "  LLOCK07-04  ,Low address block 7 lock" "0,1"
  bitfld.long  0x00 06.                  ",Low address block 6 lock" "0,1"
  bitfld.long  0x00 05.                  ",Low address block 5 lock" "0,1"
  bitfld.long  0x00 04.                  ",Low address block 4 lock" "0,1"
  
  bitfld.long  0x00 03.                  "  LLOCK03-00  ,Low address block 3 lock" "0,1"
  bitfld.long  0x00 02.                  ",Low address block 2 lock" "0,1"
  bitfld.long  0x00 01.                  ",Low address block 1 lock" "0,1"
  bitfld.long  0x00 00.                  ",Low address block 0 lock" "0,1"
TEXTLINE ""
  
group.long (0xC3FB4000+0x008)++0x03
  line.long    0x00 "HLR,High Address Space Block Locking Register"
  bitfld.long  0x00 31.                  "HBE ,High address lock enable" "0,1"

  bitfld.long  0x00 27.                  "             HBLOCK27-24 ,High address space block 27 lock" "0,1"
  bitfld.long  0x00 26.                  ",High address space block 26 lock" "0,1"
  bitfld.long  0x00 25.                  ",High address space block 25 lock" "0,1"
  bitfld.long  0x00 24.                  ",High address space block 24 lock" "0,1"
  
  bitfld.long  0x00 23.                  "  HBLOCK23-20 ,High address space block 23 lock" "0,1"
  bitfld.long  0x00 22.                  ",High address space block 22 lock" "0,1"
  bitfld.long  0x00 21.                  ",High address space block 21 lock" "0,1"
  bitfld.long  0x00 20.                  ",High address space block 20 lock" "0,1"
  
  bitfld.long  0x00 19.                  "  HBLOCK19-16 ,High address space block 19 lock" "0,1"
  bitfld.long  0x00 18.                  ",High address space block 18 lock" "0,1"
  bitfld.long  0x00 17.                  ",High address space block 17 lock" "0,1"
  bitfld.long  0x00 16.                  ",High address space block 16 lock" "0,1"
TEXTLINE "                "
  
  bitfld.long  0x00 15.                  "  HBLOCK15-12 ,High address space block 15 lock" "0,1"
  bitfld.long  0x00 14.                  ",High address space block 14 lock" "0,1"
  bitfld.long  0x00 13.                  ",High address space block 13 lock" "0,1"
  bitfld.long  0x00 12.                  ",High address space block 12 lock" "0,1"
  
  bitfld.long  0x00 11.                  "  HBLOCK11-08 ,High address space block 11 lock" "0,1"
  bitfld.long  0x00 10.                  ",High address space block 10 lock" "0,1"
  bitfld.long  0x00 09.                  ",High address space block 9 lock" "0,1"
  bitfld.long  0x00 08.                  ",High address space block 8 lock" "0,1"
  
  bitfld.long  0x00 07.                  "  HBLOCK07-04 ,High address space block 7 lock" "0,1"
  bitfld.long  0x00 06.                  ",High address space block 6 lock" "0,1"
  bitfld.long  0x00 05.                  ",High address space block 5 lock" "0,1"
  bitfld.long  0x00 04.                  ",High address space block 4 lock" "0,1"
  
  bitfld.long  0x00 03.                  "  HBLOCK03-00 ,High address space block 3 lock" "0,1"
  bitfld.long  0x00 02.                  ",High address space block 2 lock" "0,1"
  bitfld.long  0x00 01.                  ",High address space block 1 lock" "0,1"
  bitfld.long  0x00 00.                  ",High address space block 0 lock" "0,1"
TEXTLINE ""
  
  
group.long (0xC3FB4000+0x00C)++0x03
  line.long    0x00 "SLMLR,Secondary Low/Mid Address Space Block Locking Register"
  bitfld.long  0x00 31.                  "SME ,Secondary low and mid address lock enable" "0,1"
  bitfld.long  0x00 20.                  "  SSLOCK ,Secondary shadow lock" "0,1"

  bitfld.long  0x00 19.                  "   SMLOCK03-00 ,Secondary Mid address block 3 lock" "0,1"
  bitfld.long  0x00 18.                  ",Secondary Mid address block 2 lock" "0,1"
  bitfld.long  0x00 17.                  ",Secondary Mid address block 1 lock" "0,1"
  bitfld.long  0x00 16.                  ",Secondary Mid address block 0 lock" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.                  "  SLLOCK15-12 ,Secondary Low address block 15 lock" "0,1"
  bitfld.long  0x00 14.                  ",Secondary Low address block 14 lock" "0,1"
  bitfld.long  0x00 13.                  ",Secondary Low address block 13 lock" "0,1"
  bitfld.long  0x00 12.                  ",Secondary Low address block 12 lock" "0,1"
  
  bitfld.long  0x00 11.                  "  SLLOCK11-08 ,Secondary Low address block 11 lock" "0,1"
  bitfld.long  0x00 10.                  ",Secondary Low address block 10 lock" "0,1"
  bitfld.long  0x00 09.                  ",Secondary Low address block 9 lock" "0,1"
  bitfld.long  0x00 08.                  ",Secondary Low address block 8 lock" "0,1"
  
  bitfld.long  0x00 07.                  "  SLLOCK07-04 ,Secondary Low address block 7 lock" "0,1"
  bitfld.long  0x00 06.                  ",Secondary Low address block 6 lock" "0,1"
  bitfld.long  0x00 05.                  ",Secondary Low address block 5 lock" "0,1"
  bitfld.long  0x00 04.                  ",Secondary Low address block 4 lock" "0,1"
  
  bitfld.long  0x00 03.                  "  SLLOCK03-00 ,Secondary Low address block 3 lock" "0,1"
  bitfld.long  0x00 02.                  ",Secondary Low address block 2 lock" "0,1"
  bitfld.long  0x00 01.                  ",Secondary Low address block 1 lock" "0,1"
  bitfld.long  0x00 00.                  ",Secondary Low address block 0 lock" "0,1"
TEXTLINE ""
  
group.long (0xC3FB4000+0x010)++0x03
  line.long    0x00 "LMSR,Low/Mid Address Space Block Select Register"

  bitfld.long  0x00 19.                  "MSEL03-00   ,Mid address block 3 select" "0,1"
  bitfld.long  0x00 18.                  ",Mid address block 2 select" "0,1"
  bitfld.long  0x00 17.                  ",Mid address block 1 select" "0,1"
  bitfld.long  0x00 16.                  ",Mid address block 0 select" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.                  "  LSEL15-12   ,Low address block 15 select" "0,1"
  bitfld.long  0x00 14.                  ",Low address block 14 select" "0,1"
  bitfld.long  0x00 13.                  ",Low address block 13 select" "0,1"
  bitfld.long  0x00 12.                  ",Low address block 12 select" "0,1"
  
  bitfld.long  0x00 11.                  "  LSEL11-08   ,Low address block 11 select" "0,1"
  bitfld.long  0x00 10.                  ",Low address block 10 select" "0,1"
  bitfld.long  0x00 09.                  ",Low address block 9 select" "0,1"
  bitfld.long  0x00 08.                  ",Low address block 8 select" "0,1"
  
  bitfld.long  0x00 07.                  "  LSEL07-04   ,Low address block 7 select" "0,1"
  bitfld.long  0x00 06.                  ",Low address block 6 select" "0,1"
  bitfld.long  0x00 05.                  ",Low address block 5 select" "0,1"
  bitfld.long  0x00 04.                  ",Low address block 4 select" "0,1"
  
  bitfld.long  0x00 03.                  "  LSEL03-00   ,Low address block 3 select" "0,1"
  bitfld.long  0x00 02.                  ",Low address block 2 select" "0,1"
  bitfld.long  0x00 01.                  ",Low address block 1 select" "0,1"
  bitfld.long  0x00 00.                  ",Low address block 0 select" "0,1"
TEXTLINE ""
  

group.long (0xC3FB4000+0x014)++0x03
  line.long    0x00 "HSR,High Address Space Block Select Register"

  bitfld.long  0x00 27.                  "HBSEL27-24  ,High address space block 27 select" "0,1"
  bitfld.long  0x00 26.                  ",High address space block 26 select" "0,1"
  bitfld.long  0x00 25.                  ",High address space block 25 select" "0,1"
  bitfld.long  0x00 24.                  ",High address space block 24 select" "0,1"
  
  bitfld.long  0x00 23.                  "  HBSEL23-20  ,High address space block 23 select" "0,1"
  bitfld.long  0x00 22.                  ",High address space block 22 select" "0,1"
  bitfld.long  0x00 21.                  ",High address space block 21 select" "0,1"
  bitfld.long  0x00 20.                  ",High address space block 20 select" "0,1"
  
  bitfld.long  0x00 19.                  "  HBSEL19-16  ,High address space block 19 select" "0,1"
  bitfld.long  0x00 18.                  ",High address space block 18 select" "0,1"
  bitfld.long  0x00 17.                  ",High address space block 17 select" "0,1"
  bitfld.long  0x00 16.                  ",High address space block 16 select" "0,1"
TEXTLINE "                "
  
  bitfld.long  0x00 15.                  "  HBSEL15-12  ,High address space block 15 select" "0,1"
  bitfld.long  0x00 14.                  ",High address space block 14 select" "0,1"
  bitfld.long  0x00 13.                  ",High address space block 13 select" "0,1"
  bitfld.long  0x00 12.                  ",High address space block 12 select" "0,1"
  
  bitfld.long  0x00 11.                  "  HBSEL11-08  ,High address space block 11 select" "0,1"
  bitfld.long  0x00 10.                  ",High address space block 10 select" "0,1"
  bitfld.long  0x00 09.                  ",High address space block 9 select" "0,1"
  bitfld.long  0x00 08.                  ",High address space block 8 select" "0,1"
  
  bitfld.long  0x00 07.                  "  HBSEL07-04  ,High address space block 7 select" "0,1"
  bitfld.long  0x00 06.                  ",High address space block 6 select" "0,1"
  bitfld.long  0x00 05.                  ",High address space block 5 select" "0,1"
  bitfld.long  0x00 04.                  ",High address space block 4 select" "0,1"
  
  bitfld.long  0x00 03.                  "  HBSEL03-00  ,High address space block 3 select" "0,1"
  bitfld.long  0x00 02.                  ",High address space block 2 select" "0,1"
  bitfld.long  0x00 01.                  ",High address space block 1 select" "0,1"
  bitfld.long  0x00 00.                  ",High address space block 0 select" "0,1"
TEXTLINE ""

group.long (0xC3FB4000+0x018)++0x03
  line.long    0x00 "AR,Address Register"
TEXTLINE ""


group.long (0xC3FB4000+0x01C)++0x03
  line.long    0x00 "BIUCR,Flash Bus Interface Unit Control Register"
  bitfld.long  0x00 19.                  "MPFE03--00 ,Master 03 prefetch enable" "0,1"
  bitfld.long  0x00 18.                  ",Master 02 prefetch enable" "0,1"
  bitfld.long  0x00 17.                  ",Master 01 prefetch enable" "0,1"
  bitfld.long  0x00 16.                  ",Master 00 prefetch enable" "0,1"

  bitfld.long  0x00 13.--15.             "  APC ,Address pipelining control" "back-to-back,1 hold cycle,2 hold cycles,3 hold cycles,4 hold cycles,5 hold cycles,6 hold cycles,no pipelining"
  bitfld.long  0x00 11.--12.             "  WWSC ,Write wait state control" "0,1,2,3"
  bitfld.long  0x00 08.--10.             "  RWSC ,Read wait state control" "0,1,res(2),res(3),res(4),res(5),res(6),7"
  TEXTLINE "                "
  bitfld.long  0x00 06.--07.             "  DPFEN ,Data prefetch enable" "disabled,data burst,res.,any data read"
  bitfld.long  0x00 04.--05.             "  IPFEN ,Instruction prefetch enable" "disabled,inst read,res.,any inst read"
  bitfld.long  0x00 01.--03.             "  PFLIM ,Prefetch limit" "disabled,1 line,-2 lines,-3 lines,-4 lines,-5 lines,unlimited,res."
  bitfld.long  0x00 00.                  "  BFEN ,PFBIU line read buffers enable" "0,1"
TEXTLINE ""
 
 
group.long (0xC3FB4000+0x020)++0x03
  line.long    0x00 "BIUAPR,Flash Bus Interface Unit Access Protection Register"
  bitfld.long  0x00 06.--07.             "M3AP ,EBI Master access protection" "none,read,write,both"
  bitfld.long  0x00 04.--05.             "  M2AP ,eDMA Master access protection" "none,read,write,both"
  bitfld.long  0x00 02.--03.             "  M1AP ,Nexus Master access protection" "none,read,write,both"
  bitfld.long  0x00 00.--01.             "  M0AP ,Core Master access protection" "none,read,write,both"
 


tree.end

 tree.end
endif

sif (cpu()=="MPC5534")||(cpu()=="MPC5553")||(cpu()=="MPC5554")||(cpu()=="MPC5561")||(cpu()=="MPC5565")||(cpu()=="MPC5566")||(cpu()=="MPC5567")||(cpu()=="MPC5633M")||(cpu()=="MPC5634M")||(cpu()=="SPC563M60")||(cpu()=="SPC563M64")

tree "Enhanced Modular Input/Output Subsystem (eMIOS)"

group.long (0xC3FA0000+0x0000)++0x03
  line.long    0x00 "MCR,Module Configuration Register"
  bitfld.long  0x00 30.                  "MDIS ,Module disable" "0,1"
  bitfld.long  0x00 29.                  "  FRZ ,Freeze" "0,1"
  bitfld.long  0x00 28.                  "  GTBE ,Global time base enable" "0,1"
  bitfld.long  0x00 27.                  "  ETB ,External time base" "0,1"
  bitfld.long  0x00 26.                  "  GPREN ,Global prescaler enable" "0,1"
  bitfld.long  0x00 16.--19.             "  SRV ,Server time slot" "eTPU A-TCR1,eTPU B-TCR1,eTPU A-TCR2,eTPU B-TCR2,res(4),res(5),res(6),res(7),res(8),res(9),res(10),res(11),res(12),res(13),res(14),res(15)"
  hexmask.long.byte 0x00 08.--15. 1.     "  GPRE ,Global Prescaler"
  
TEXTLINE ""

group.long (0xC3FA0000+0x0004)++0x03
  line.long    0x00 "GFR,eMIOS Global Flag Register"
  bitfld.long  0x00 23.                  "F23-20  ,F23" "0,1"
  bitfld.long  0x00 22.                  ",F22" "0,1"
  bitfld.long  0x00 21.                  ",F21" "0,1"
  bitfld.long  0x00 20.                  ",F20" "0,1"

  bitfld.long  0x00 19.                  "  F19-16  ,F19" "0,1"
  bitfld.long  0x00 18.                  ",F18" "0,1"
  bitfld.long  0x00 17.                  ",F17" "0,1"
  bitfld.long  0x00 16.                  ",F16" "0,1"

  TEXTLINE "                "

  bitfld.long  0x00 15.                  "  F15-12  ,F15" "0,1"
  bitfld.long  0x00 14.                  ",F14" "0,1"
  bitfld.long  0x00 13.                  ",F13" "0,1"
  bitfld.long  0x00 12.                  ",F12" "0,1"

  bitfld.long  0x00 11.                  "  F11-08  ,F11" "0,1"
  bitfld.long  0x00 10.                  ",F10" "0,1"
  bitfld.long  0x00 09.                  ",F09" "0,1"
  bitfld.long  0x00 08.                  ",F08" "0,1"
 
  bitfld.long  0x00 07.                  "  F07-04  ,F07" "0,1"
  bitfld.long  0x00 06.                  ",F06" "0,1"
  bitfld.long  0x00 05.                  ",F05" "0,1"
  bitfld.long  0x00 04.                  ",F04" "0,1"

  bitfld.long  0x00 03.                  "  F03-00  ,F03" "0,1"
  bitfld.long  0x00 02.                  ",F02" "0,1"
  bitfld.long  0x00 01.                  ",F01" "0,1"
  bitfld.long  0x00 00.                  ",F00" "0,1"
TEXTLINE ""


group.long (0xC3FA0000+0x0008)++0x03
  line.long    0x00 "OUDR,eMIOS Output Update Disable Register"
  bitfld.long  0x00 23.                  "OU23-20 ,OU23" "0,1"
  bitfld.long  0x00 22.                  ",OU22" "0,1"
  bitfld.long  0x00 21.                  ",OU21" "0,1"
  bitfld.long  0x00 20.                  ",OU20" "0,1"

  bitfld.long  0x00 19.                  "  OU19-16 ,OU19" "0,1"
  bitfld.long  0x00 18.                  ",OU18" "0,1"
  bitfld.long  0x00 17.                  ",OU17" "0,1"
  bitfld.long  0x00 16.                  ",OU16" "0,1"

  TEXTLINE "                "

  bitfld.long  0x00 15.                  "  OU15-12 ,OU15" "0,1"
  bitfld.long  0x00 14.                  ",OU14" "0,1"
  bitfld.long  0x00 13.                  ",OU13" "0,1"
  bitfld.long  0x00 12.                  ",OU12" "0,1"

  bitfld.long  0x00 11.                  "  OU11-08 ,OU11" "0,1"
  bitfld.long  0x00 10.                  ",OU10" "0,1"
  bitfld.long  0x00 09.                  ",OU09" "0,1"
  bitfld.long  0x00 08.                  ",OU08" "0,1"
 
  bitfld.long  0x00 07.                  "  OU07-04 ,OU07" "0,1"
  bitfld.long  0x00 06.                  ",OU06" "0,1"
  bitfld.long  0x00 05.                  ",OU05" "0,1"
  bitfld.long  0x00 04.                  ",OU04" "0,1"

  bitfld.long  0x00 03.                  "  OU03-00 ,OU03" "0,1"
  bitfld.long  0x00 02.                  ",OU02" "0,1"
  bitfld.long  0x00 01.                  ",OU01" "0,1"
  bitfld.long  0x00 00.                  ",OU00" "0,1"
TEXTLINE ""


tree "Unified Channel Registers"

sif ((cpu()=="MPC5633M")||(cpu()=="MPC5634M")||(cpu()=="SPC563M60")||(cpu()=="SPC563M64"))

wgroup.long (0xC3FA0000+0x0020+0x20*0.)++0x03
  hide.long    0x00 "CADR0,eMIOS Channel A Data Register (not displayed by debugger)"
  in

wgroup.long (0xC3FA0000+0x0024+0x20*0.)++0x03
  hide.long    0x00 "CBDR0,eMIOS Channel B Data Register (not displayed by debugger)"
  in
  
group.long (0xC3FA0000+0x0028+0x20*0.)++0x03
  line.long    0x00 "CCNTR0,eMIOS Channel Counter Register"
  
group.long (0xC3FA0000+0x002C+0x20*0.)++0x03
  line.long    0x00 "CCR0,eMIOS Channel Control Register"
  bitfld.long  0x00 31.                  "FREN  ,Freeze enable" "0,1"
  bitfld.long  0x00 30.                  "      ODIS   ,Output disable" "0,1"
  bitfld.long  0x00 28.--29.             "     ODISSL ,Output disable select" "0,1,2,3"
  bitfld.long  0x00 26.--27.             "  UCPRE  ,Prescaler" "1,2,3,4"
  bitfld.long  0x00 25.                  "  UCPREN ,Prescaler enable" "0,1"
  bitfld.long  0x00 24.                  "  DMA ,Direct memory access" "int,dma"
  TEXTLINE "                "
  bitfld.long  0x00 19.--22.             "  IF    ,Input filter" "byp.,02,04,res.,08,res.,res.,res.,16,res.,res.,res.,res.,res.,res.,res."
  bitfld.long  0x00 18.                  "   FCK    ,Filter clock select" "presc,main"
  bitfld.long  0x00 17.                  " FEN    ,FLAG enable" "0,1"
  bitfld.long  0x00 13.                  "  FORCMA ,Force match A" "0,1"
  bitfld.long  0x00 12.                  "  FORCMB ,Force match B" "0,1"
  bitfld.long  0x00 09.--10.             "  BSL ,Bus select" "all A,mix,res.,int"
  TEXTLINE "                "
  bitfld.long  0x00 08.                  "  EDSEL ,Edge selection bit" "single,both"
  bitfld.long  0x00 07.                  " EDPOL  ,Edge polarity" "fal.,ris."
  hexmask.byte 0x03 00.--06. 1.          "  MODE  ,Mode selection"
  
  
group.long (0xC3FA0000+0x0030+0x20*0.)++0x03
  line.long    0x00 "CSR0,eMIOS Channel Status Register"
  bitfld.long  0x00 31.                  "OVR   ,Overrun (w1c)" "0,1"
  bitfld.long  0x00 15.                  "      OVFL   ,Overflow (w1c)" "0,1"
  bitfld.long  0x00 02.                  "     UCIN   ,Unified channel input pin" "0,1"
  bitfld.long  0x00 01.                  "   UCOUT ,Unified channel output pin" "0,1"
  bitfld.long  0x00 00.                  "  FLAG   ,FLAG" "0,1"
  
TEXTLINE ""



wgroup.long (0xC3FA0000+0x0020+0x20*1.)++0x03
  hide.long    0x00 "CADR1,eMIOS Channel A Data Register (not displayed by debugger)"
  in

wgroup.long (0xC3FA0000+0x0024+0x20*1.)++0x03
  hide.long    0x00 "CBDR1,eMIOS Channel B Data Register (not displayed by debugger)"
  in
  
group.long (0xC3FA0000+0x0028+0x20*1.)++0x03
  line.long    0x00 "CCNTR1,eMIOS Channel Counter Register"
  
group.long (0xC3FA0000+0x002C+0x20*1.)++0x03
  line.long    0x00 "CCR1,eMIOS Channel Control Register"
  bitfld.long  0x00 31.                  "FREN  ,Freeze enable" "0,1"
  bitfld.long  0x00 30.                  "      ODIS   ,Output disable" "0,1"
  bitfld.long  0x00 28.--29.             "     ODISSL ,Output disable select" "0,1,2,3"
  bitfld.long  0x00 26.--27.             "  UCPRE  ,Prescaler" "1,2,3,4"
  bitfld.long  0x00 25.                  "  UCPREN ,Prescaler enable" "0,1"
  bitfld.long  0x00 24.                  "  DMA ,Direct memory access" "int,dma"
  TEXTLINE "                "
  bitfld.long  0x00 19.--22.             "  IF    ,Input filter" "byp.,02,04,res.,08,res.,res.,res.,16,res.,res.,res.,res.,res.,res.,res."
  bitfld.long  0x00 18.                  "   FCK    ,Filter clock select" "presc,main"
  bitfld.long  0x00 17.                  " FEN    ,FLAG enable" "0,1"
  bitfld.long  0x00 13.                  "  FORCMA ,Force match A" "0,1"
  bitfld.long  0x00 12.                  "  FORCMB ,Force match B" "0,1"
  bitfld.long  0x00 09.--10.             "  BSL ,Bus select" "all A,mix,res.,int"
  TEXTLINE "                "
  bitfld.long  0x00 08.                  "  EDSEL ,Edge selection bit" "single,both"
  bitfld.long  0x00 07.                  " EDPOL  ,Edge polarity" "fal.,ris."
  hexmask.byte 0x03 00.--06. 1.          "  MODE  ,Mode selection"
  
  
group.long (0xC3FA0000+0x0030+0x20*1.)++0x03
  line.long    0x00 "CSR1,eMIOS Channel Status Register"
  bitfld.long  0x00 31.                  "OVR   ,Overrun (w1c)" "0,1"
  bitfld.long  0x00 15.                  "      OVFL   ,Overflow (w1c)" "0,1"
  bitfld.long  0x00 02.                  "     UCIN   ,Unified channel input pin" "0,1"
  bitfld.long  0x00 01.                  "   UCOUT ,Unified channel output pin" "0,1"
  bitfld.long  0x00 00.                  "  FLAG   ,FLAG" "0,1"
  
TEXTLINE ""



wgroup.long (0xC3FA0000+0x0020+0x20*2.)++0x03
  hide.long    0x00 "CADR2,eMIOS Channel A Data Register (not displayed by debugger)"
  in

wgroup.long (0xC3FA0000+0x0024+0x20*2.)++0x03
  hide.long    0x00 "CBDR2,eMIOS Channel B Data Register (not displayed by debugger)"
  in
  
group.long (0xC3FA0000+0x0028+0x20*2.)++0x03
  line.long    0x00 "CCNTR2,eMIOS Channel Counter Register"
  
group.long (0xC3FA0000+0x002C+0x20*2.)++0x03
  line.long    0x00 "CCR2,eMIOS Channel Control Register"
  bitfld.long  0x00 31.                  "FREN  ,Freeze enable" "0,1"
  bitfld.long  0x00 30.                  "      ODIS   ,Output disable" "0,1"
  bitfld.long  0x00 28.--29.             "     ODISSL ,Output disable select" "0,1,2,3"
  bitfld.long  0x00 26.--27.             "  UCPRE  ,Prescaler" "1,2,3,4"
  bitfld.long  0x00 25.                  "  UCPREN ,Prescaler enable" "0,1"
  bitfld.long  0x00 24.                  "  DMA ,Direct memory access" "int,dma"
  TEXTLINE "                "
  bitfld.long  0x00 19.--22.             "  IF    ,Input filter" "byp.,02,04,res.,08,res.,res.,res.,16,res.,res.,res.,res.,res.,res.,res."
  bitfld.long  0x00 18.                  "   FCK    ,Filter clock select" "presc,main"
  bitfld.long  0x00 17.                  " FEN    ,FLAG enable" "0,1"
  bitfld.long  0x00 13.                  "  FORCMA ,Force match A" "0,1"
  bitfld.long  0x00 12.                  "  FORCMB ,Force match B" "0,1"
  bitfld.long  0x00 09.--10.             "  BSL ,Bus select" "all A,mix,res.,int"
  TEXTLINE "                "
  bitfld.long  0x00 08.                  "  EDSEL ,Edge selection bit" "single,both"
  bitfld.long  0x00 07.                  " EDPOL  ,Edge polarity" "fal.,ris."
  hexmask.byte 0x03 00.--06. 1.          "  MODE  ,Mode selection"
  
  
group.long (0xC3FA0000+0x0030+0x20*2.)++0x03
  line.long    0x00 "CSR2,eMIOS Channel Status Register"
  bitfld.long  0x00 31.                  "OVR   ,Overrun (w1c)" "0,1"
  bitfld.long  0x00 15.                  "      OVFL   ,Overflow (w1c)" "0,1"
  bitfld.long  0x00 02.                  "     UCIN   ,Unified channel input pin" "0,1"
  bitfld.long  0x00 01.                  "   UCOUT ,Unified channel output pin" "0,1"
  bitfld.long  0x00 00.                  "  FLAG   ,FLAG" "0,1"
  
TEXTLINE ""



wgroup.long (0xC3FA0000+0x0020+0x20*3.)++0x03
  hide.long    0x00 "CADR3,eMIOS Channel A Data Register (not displayed by debugger)"
  in

wgroup.long (0xC3FA0000+0x0024+0x20*3.)++0x03
  hide.long    0x00 "CBDR3,eMIOS Channel B Data Register (not displayed by debugger)"
  in
  
group.long (0xC3FA0000+0x0028+0x20*3.)++0x03
  line.long    0x00 "CCNTR3,eMIOS Channel Counter Register"
  
group.long (0xC3FA0000+0x002C+0x20*3.)++0x03
  line.long    0x00 "CCR3,eMIOS Channel Control Register"
  bitfld.long  0x00 31.                  "FREN  ,Freeze enable" "0,1"
  bitfld.long  0x00 30.                  "      ODIS   ,Output disable" "0,1"
  bitfld.long  0x00 28.--29.             "     ODISSL ,Output disable select" "0,1,2,3"
  bitfld.long  0x00 26.--27.             "  UCPRE  ,Prescaler" "1,2,3,4"
  bitfld.long  0x00 25.                  "  UCPREN ,Prescaler enable" "0,1"
  bitfld.long  0x00 24.                  "  DMA ,Direct memory access" "int,dma"
  TEXTLINE "                "
  bitfld.long  0x00 19.--22.             "  IF    ,Input filter" "byp.,02,04,res.,08,res.,res.,res.,16,res.,res.,res.,res.,res.,res.,res."
  bitfld.long  0x00 18.                  "   FCK    ,Filter clock select" "presc,main"
  bitfld.long  0x00 17.                  " FEN    ,FLAG enable" "0,1"
  bitfld.long  0x00 13.                  "  FORCMA ,Force match A" "0,1"
  bitfld.long  0x00 12.                  "  FORCMB ,Force match B" "0,1"
  bitfld.long  0x00 09.--10.             "  BSL ,Bus select" "all A,mix,res.,int"
  TEXTLINE "                "
  bitfld.long  0x00 08.                  "  EDSEL ,Edge selection bit" "single,both"
  bitfld.long  0x00 07.                  " EDPOL  ,Edge polarity" "fal.,ris."
  hexmask.byte 0x03 00.--06. 1.          "  MODE  ,Mode selection"
  
  
group.long (0xC3FA0000+0x0030+0x20*3.)++0x03
  line.long    0x00 "CSR3,eMIOS Channel Status Register"
  bitfld.long  0x00 31.                  "OVR   ,Overrun (w1c)" "0,1"
  bitfld.long  0x00 15.                  "      OVFL   ,Overflow (w1c)" "0,1"
  bitfld.long  0x00 02.                  "     UCIN   ,Unified channel input pin" "0,1"
  bitfld.long  0x00 01.                  "   UCOUT ,Unified channel output pin" "0,1"
  bitfld.long  0x00 00.                  "  FLAG   ,FLAG" "0,1"
  
TEXTLINE ""



wgroup.long (0xC3FA0000+0x0020+0x20*4.)++0x03
  hide.long    0x00 "CADR4,eMIOS Channel A Data Register (not displayed by debugger)"
  in

wgroup.long (0xC3FA0000+0x0024+0x20*4.)++0x03
  hide.long    0x00 "CBDR4,eMIOS Channel B Data Register (not displayed by debugger)"
  in
  
group.long (0xC3FA0000+0x0028+0x20*4.)++0x03
  line.long    0x00 "CCNTR4,eMIOS Channel Counter Register"
  
group.long (0xC3FA0000+0x002C+0x20*4.)++0x03
  line.long    0x00 "CCR4,eMIOS Channel Control Register"
  bitfld.long  0x00 31.                  "FREN  ,Freeze enable" "0,1"
  bitfld.long  0x00 30.                  "      ODIS   ,Output disable" "0,1"
  bitfld.long  0x00 28.--29.             "     ODISSL ,Output disable select" "0,1,2,3"
  bitfld.long  0x00 26.--27.             "  UCPRE  ,Prescaler" "1,2,3,4"
  bitfld.long  0x00 25.                  "  UCPREN ,Prescaler enable" "0,1"
  bitfld.long  0x00 24.                  "  DMA ,Direct memory access" "int,dma"
  TEXTLINE "                "
  bitfld.long  0x00 19.--22.             "  IF    ,Input filter" "byp.,02,04,res.,08,res.,res.,res.,16,res.,res.,res.,res.,res.,res.,res."
  bitfld.long  0x00 18.                  "   FCK    ,Filter clock select" "presc,main"
  bitfld.long  0x00 17.                  " FEN    ,FLAG enable" "0,1"
  bitfld.long  0x00 13.                  "  FORCMA ,Force match A" "0,1"
  bitfld.long  0x00 12.                  "  FORCMB ,Force match B" "0,1"
  bitfld.long  0x00 09.--10.             "  BSL ,Bus select" "all A,mix,res.,int"
  TEXTLINE "                "
  bitfld.long  0x00 08.                  "  EDSEL ,Edge selection bit" "single,both"
  bitfld.long  0x00 07.                  " EDPOL  ,Edge polarity" "fal.,ris."
  hexmask.byte 0x03 00.--06. 1.          "  MODE  ,Mode selection"
  
  
group.long (0xC3FA0000+0x0030+0x20*4.)++0x03
  line.long    0x00 "CSR4,eMIOS Channel Status Register"
  bitfld.long  0x00 31.                  "OVR   ,Overrun (w1c)" "0,1"
  bitfld.long  0x00 15.                  "      OVFL   ,Overflow (w1c)" "0,1"
  bitfld.long  0x00 02.                  "     UCIN   ,Unified channel input pin" "0,1"
  bitfld.long  0x00 01.                  "   UCOUT ,Unified channel output pin" "0,1"
  bitfld.long  0x00 00.                  "  FLAG   ,FLAG" "0,1"
  
TEXTLINE ""



wgroup.long (0xC3FA0000+0x0020+0x20*5.)++0x03
  hide.long    0x00 "CADR5,eMIOS Channel A Data Register (not displayed by debugger)"
  in

wgroup.long (0xC3FA0000+0x0024+0x20*5.)++0x03
  hide.long    0x00 "CBDR5,eMIOS Channel B Data Register (not displayed by debugger)"
  in
  
group.long (0xC3FA0000+0x0028+0x20*5.)++0x03
  line.long    0x00 "CCNTR5,eMIOS Channel Counter Register"
  
group.long (0xC3FA0000+0x002C+0x20*5.)++0x03
  line.long    0x00 "CCR5,eMIOS Channel Control Register"
  bitfld.long  0x00 31.                  "FREN  ,Freeze enable" "0,1"
  bitfld.long  0x00 30.                  "      ODIS   ,Output disable" "0,1"
  bitfld.long  0x00 28.--29.             "     ODISSL ,Output disable select" "0,1,2,3"
  bitfld.long  0x00 26.--27.             "  UCPRE  ,Prescaler" "1,2,3,4"
  bitfld.long  0x00 25.                  "  UCPREN ,Prescaler enable" "0,1"
  bitfld.long  0x00 24.                  "  DMA ,Direct memory access" "int,dma"
  TEXTLINE "                "
  bitfld.long  0x00 19.--22.             "  IF    ,Input filter" "byp.,02,04,res.,08,res.,res.,res.,16,res.,res.,res.,res.,res.,res.,res."
  bitfld.long  0x00 18.                  "   FCK    ,Filter clock select" "presc,main"
  bitfld.long  0x00 17.                  " FEN    ,FLAG enable" "0,1"
  bitfld.long  0x00 13.                  "  FORCMA ,Force match A" "0,1"
  bitfld.long  0x00 12.                  "  FORCMB ,Force match B" "0,1"
  bitfld.long  0x00 09.--10.             "  BSL ,Bus select" "all A,mix,res.,int"
  TEXTLINE "                "
  bitfld.long  0x00 08.                  "  EDSEL ,Edge selection bit" "single,both"
  bitfld.long  0x00 07.                  " EDPOL  ,Edge polarity" "fal.,ris."
  hexmask.byte 0x03 00.--06. 1.          "  MODE  ,Mode selection"
  
  
group.long (0xC3FA0000+0x0030+0x20*5.)++0x03
  line.long    0x00 "CSR5,eMIOS Channel Status Register"
  bitfld.long  0x00 31.                  "OVR   ,Overrun (w1c)" "0,1"
  bitfld.long  0x00 15.                  "      OVFL   ,Overflow (w1c)" "0,1"
  bitfld.long  0x00 02.                  "     UCIN   ,Unified channel input pin" "0,1"
  bitfld.long  0x00 01.                  "   UCOUT ,Unified channel output pin" "0,1"
  bitfld.long  0x00 00.                  "  FLAG   ,FLAG" "0,1"
  
TEXTLINE ""



wgroup.long (0xC3FA0000+0x0020+0x20*6.)++0x03
  hide.long    0x00 "CADR6,eMIOS Channel A Data Register (not displayed by debugger)"
  in

wgroup.long (0xC3FA0000+0x0024+0x20*6.)++0x03
  hide.long    0x00 "CBDR6,eMIOS Channel B Data Register (not displayed by debugger)"
  in
  
group.long (0xC3FA0000+0x0028+0x20*6.)++0x03
  line.long    0x00 "CCNTR6,eMIOS Channel Counter Register"
  
group.long (0xC3FA0000+0x002C+0x20*6.)++0x03
  line.long    0x00 "CCR6,eMIOS Channel Control Register"
  bitfld.long  0x00 31.                  "FREN  ,Freeze enable" "0,1"
  bitfld.long  0x00 30.                  "      ODIS   ,Output disable" "0,1"
  bitfld.long  0x00 28.--29.             "     ODISSL ,Output disable select" "0,1,2,3"
  bitfld.long  0x00 26.--27.             "  UCPRE  ,Prescaler" "1,2,3,4"
  bitfld.long  0x00 25.                  "  UCPREN ,Prescaler enable" "0,1"
  bitfld.long  0x00 24.                  "  DMA ,Direct memory access" "int,dma"
  TEXTLINE "                "
  bitfld.long  0x00 19.--22.             "  IF    ,Input filter" "byp.,02,04,res.,08,res.,res.,res.,16,res.,res.,res.,res.,res.,res.,res."
  bitfld.long  0x00 18.                  "   FCK    ,Filter clock select" "presc,main"
  bitfld.long  0x00 17.                  " FEN    ,FLAG enable" "0,1"
  bitfld.long  0x00 13.                  "  FORCMA ,Force match A" "0,1"
  bitfld.long  0x00 12.                  "  FORCMB ,Force match B" "0,1"
  bitfld.long  0x00 09.--10.             "  BSL ,Bus select" "all A,mix,res.,int"
  TEXTLINE "                "
  bitfld.long  0x00 08.                  "  EDSEL ,Edge selection bit" "single,both"
  bitfld.long  0x00 07.                  " EDPOL  ,Edge polarity" "fal.,ris."
  hexmask.byte 0x03 00.--06. 1.          "  MODE  ,Mode selection"
  
  
group.long (0xC3FA0000+0x0030+0x20*6.)++0x03
  line.long    0x00 "CSR6,eMIOS Channel Status Register"
  bitfld.long  0x00 31.                  "OVR   ,Overrun (w1c)" "0,1"
  bitfld.long  0x00 15.                  "      OVFL   ,Overflow (w1c)" "0,1"
  bitfld.long  0x00 02.                  "     UCIN   ,Unified channel input pin" "0,1"
  bitfld.long  0x00 01.                  "   UCOUT ,Unified channel output pin" "0,1"
  bitfld.long  0x00 00.                  "  FLAG   ,FLAG" "0,1"
  
TEXTLINE ""



wgroup.long (0xC3FA0000+0x0020+0x20*8.)++0x03
  hide.long    0x00 "CADR8,eMIOS Channel A Data Register (not displayed by debugger)"
  in

wgroup.long (0xC3FA0000+0x0024+0x20*8.)++0x03
  hide.long    0x00 "CBDR8,eMIOS Channel B Data Register (not displayed by debugger)"
  in
  
group.long (0xC3FA0000+0x0028+0x20*8.)++0x03
  line.long    0x00 "CCNTR8,eMIOS Channel Counter Register"
  
group.long (0xC3FA0000+0x002C+0x20*8.)++0x03
  line.long    0x00 "CCR8,eMIOS Channel Control Register"
  bitfld.long  0x00 31.                  "FREN  ,Freeze enable" "0,1"
  bitfld.long  0x00 30.                  "      ODIS   ,Output disable" "0,1"
  bitfld.long  0x00 28.--29.             "     ODISSL ,Output disable select" "0,1,2,3"
  bitfld.long  0x00 26.--27.             "  UCPRE  ,Prescaler" "1,2,3,4"
  bitfld.long  0x00 25.                  "  UCPREN ,Prescaler enable" "0,1"
  bitfld.long  0x00 24.                  "  DMA ,Direct memory access" "int,dma"
  TEXTLINE "                "
  bitfld.long  0x00 19.--22.             "  IF    ,Input filter" "byp.,02,04,res.,08,res.,res.,res.,16,res.,res.,res.,res.,res.,res.,res."
  bitfld.long  0x00 18.                  "   FCK    ,Filter clock select" "presc,main"
  bitfld.long  0x00 17.                  " FEN    ,FLAG enable" "0,1"
  bitfld.long  0x00 13.                  "  FORCMA ,Force match A" "0,1"
  bitfld.long  0x00 12.                  "  FORCMB ,Force match B" "0,1"
  bitfld.long  0x00 09.--10.             "  BSL ,Bus select" "all A,mix,res.,int"
  TEXTLINE "                "
  bitfld.long  0x00 08.                  "  EDSEL ,Edge selection bit" "single,both"
  bitfld.long  0x00 07.                  " EDPOL  ,Edge polarity" "fal.,ris."
  hexmask.byte 0x03 00.--06. 1.          "  MODE  ,Mode selection"
  
  
group.long (0xC3FA0000+0x0030+0x20*8.)++0x03
  line.long    0x00 "CSR8,eMIOS Channel Status Register"
  bitfld.long  0x00 31.                  "OVR   ,Overrun (w1c)" "0,1"
  bitfld.long  0x00 15.                  "      OVFL   ,Overflow (w1c)" "0,1"
  bitfld.long  0x00 02.                  "     UCIN   ,Unified channel input pin" "0,1"
  bitfld.long  0x00 01.                  "   UCOUT ,Unified channel output pin" "0,1"
  bitfld.long  0x00 00.                  "  FLAG   ,FLAG" "0,1"
  
TEXTLINE ""



wgroup.long (0xC3FA0000+0x0020+0x20*9.)++0x03
  hide.long    0x00 "CADR9,eMIOS Channel A Data Register (not displayed by debugger)"
  in

wgroup.long (0xC3FA0000+0x0024+0x20*9.)++0x03
  hide.long    0x00 "CBDR9,eMIOS Channel B Data Register (not displayed by debugger)"
  in
  
group.long (0xC3FA0000+0x0028+0x20*9.)++0x03
  line.long    0x00 "CCNTR9,eMIOS Channel Counter Register"
  
group.long (0xC3FA0000+0x002C+0x20*9.)++0x03
  line.long    0x00 "CCR9,eMIOS Channel Control Register"
  bitfld.long  0x00 31.                  "FREN  ,Freeze enable" "0,1"
  bitfld.long  0x00 30.                  "      ODIS   ,Output disable" "0,1"
  bitfld.long  0x00 28.--29.             "     ODISSL ,Output disable select" "0,1,2,3"
  bitfld.long  0x00 26.--27.             "  UCPRE  ,Prescaler" "1,2,3,4"
  bitfld.long  0x00 25.                  "  UCPREN ,Prescaler enable" "0,1"
  bitfld.long  0x00 24.                  "  DMA ,Direct memory access" "int,dma"
  TEXTLINE "                "
  bitfld.long  0x00 19.--22.             "  IF    ,Input filter" "byp.,02,04,res.,08,res.,res.,res.,16,res.,res.,res.,res.,res.,res.,res."
  bitfld.long  0x00 18.                  "   FCK    ,Filter clock select" "presc,main"
  bitfld.long  0x00 17.                  " FEN    ,FLAG enable" "0,1"
  bitfld.long  0x00 13.                  "  FORCMA ,Force match A" "0,1"
  bitfld.long  0x00 12.                  "  FORCMB ,Force match B" "0,1"
  bitfld.long  0x00 09.--10.             "  BSL ,Bus select" "all A,mix,res.,int"
  TEXTLINE "                "
  bitfld.long  0x00 08.                  "  EDSEL ,Edge selection bit" "single,both"
  bitfld.long  0x00 07.                  " EDPOL  ,Edge polarity" "fal.,ris."
  hexmask.byte 0x03 00.--06. 1.          "  MODE  ,Mode selection"
  
  
group.long (0xC3FA0000+0x0030+0x20*9.)++0x03
  line.long    0x00 "CSR9,eMIOS Channel Status Register"
  bitfld.long  0x00 31.                  "OVR   ,Overrun (w1c)" "0,1"
  bitfld.long  0x00 15.                  "      OVFL   ,Overflow (w1c)" "0,1"
  bitfld.long  0x00 02.                  "     UCIN   ,Unified channel input pin" "0,1"
  bitfld.long  0x00 01.                  "   UCOUT ,Unified channel output pin" "0,1"
  bitfld.long  0x00 00.                  "  FLAG   ,FLAG" "0,1"
  
TEXTLINE ""



wgroup.long (0xC3FA0000+0x0020+0x20*10.)++0x03
  hide.long    0x00 "CADR10,eMIOS Channel A Data Register (not displayed by debugger)"
  in

wgroup.long (0xC3FA0000+0x0024+0x20*10.)++0x03
  hide.long    0x00 "CBDR10,eMIOS Channel B Data Register (not displayed by debugger)"
  in
  
group.long (0xC3FA0000+0x0028+0x20*10.)++0x03
  line.long    0x00 "CCNTR10,eMIOS Channel Counter Register"
  
group.long (0xC3FA0000+0x002C+0x20*10.)++0x03
  line.long    0x00 "CCR10,eMIOS Channel Control Register"
  bitfld.long  0x00 31.                  "FREN  ,Freeze enable" "0,1"
  bitfld.long  0x00 30.                  "      ODIS   ,Output disable" "0,1"
  bitfld.long  0x00 28.--29.             "     ODISSL ,Output disable select" "0,1,2,3"
  bitfld.long  0x00 26.--27.             "  UCPRE  ,Prescaler" "1,2,3,4"
  bitfld.long  0x00 25.                  "  UCPREN ,Prescaler enable" "0,1"
  bitfld.long  0x00 24.                  "  DMA ,Direct memory access" "int,dma"
  TEXTLINE "                "
  bitfld.long  0x00 19.--22.             "  IF    ,Input filter" "byp.,02,04,res.,08,res.,res.,res.,16,res.,res.,res.,res.,res.,res.,res."
  bitfld.long  0x00 18.                  "   FCK    ,Filter clock select" "presc,main"
  bitfld.long  0x00 17.                  " FEN    ,FLAG enable" "0,1"
  bitfld.long  0x00 13.                  "  FORCMA ,Force match A" "0,1"
  bitfld.long  0x00 12.                  "  FORCMB ,Force match B" "0,1"
  bitfld.long  0x00 09.--10.             "  BSL ,Bus select" "all A,mix,res.,int"
  TEXTLINE "                "
  bitfld.long  0x00 08.                  "  EDSEL ,Edge selection bit" "single,both"
  bitfld.long  0x00 07.                  " EDPOL  ,Edge polarity" "fal.,ris."
  hexmask.byte 0x03 00.--06. 1.          "  MODE  ,Mode selection"
  
  
group.long (0xC3FA0000+0x0030+0x20*10.)++0x03
  line.long    0x00 "CSR10,eMIOS Channel Status Register"
  bitfld.long  0x00 31.                  "OVR   ,Overrun (w1c)" "0,1"
  bitfld.long  0x00 15.                  "      OVFL   ,Overflow (w1c)" "0,1"
  bitfld.long  0x00 02.                  "     UCIN   ,Unified channel input pin" "0,1"
  bitfld.long  0x00 01.                  "   UCOUT ,Unified channel output pin" "0,1"
  bitfld.long  0x00 00.                  "  FLAG   ,FLAG" "0,1"
  
TEXTLINE ""



wgroup.long (0xC3FA0000+0x0020+0x20*11.)++0x03
  hide.long    0x00 "CADR11,eMIOS Channel A Data Register (not displayed by debugger)"
  in

wgroup.long (0xC3FA0000+0x0024+0x20*11.)++0x03
  hide.long    0x00 "CBDR11,eMIOS Channel B Data Register (not displayed by debugger)"
  in
  
group.long (0xC3FA0000+0x0028+0x20*11.)++0x03
  line.long    0x00 "CCNTR11,eMIOS Channel Counter Register"
  
group.long (0xC3FA0000+0x002C+0x20*11.)++0x03
  line.long    0x00 "CCR11,eMIOS Channel Control Register"
  bitfld.long  0x00 31.                  "FREN  ,Freeze enable" "0,1"
  bitfld.long  0x00 30.                  "      ODIS   ,Output disable" "0,1"
  bitfld.long  0x00 28.--29.             "     ODISSL ,Output disable select" "0,1,2,3"
  bitfld.long  0x00 26.--27.             "  UCPRE  ,Prescaler" "1,2,3,4"
  bitfld.long  0x00 25.                  "  UCPREN ,Prescaler enable" "0,1"
  bitfld.long  0x00 24.                  "  DMA ,Direct memory access" "int,dma"
  TEXTLINE "                "
  bitfld.long  0x00 19.--22.             "  IF    ,Input filter" "byp.,02,04,res.,08,res.,res.,res.,16,res.,res.,res.,res.,res.,res.,res."
  bitfld.long  0x00 18.                  "   FCK    ,Filter clock select" "presc,main"
  bitfld.long  0x00 17.                  " FEN    ,FLAG enable" "0,1"
  bitfld.long  0x00 13.                  "  FORCMA ,Force match A" "0,1"
  bitfld.long  0x00 12.                  "  FORCMB ,Force match B" "0,1"
  bitfld.long  0x00 09.--10.             "  BSL ,Bus select" "all A,mix,res.,int"
  TEXTLINE "                "
  bitfld.long  0x00 08.                  "  EDSEL ,Edge selection bit" "single,both"
  bitfld.long  0x00 07.                  " EDPOL  ,Edge polarity" "fal.,ris."
  hexmask.byte 0x03 00.--06. 1.          "  MODE  ,Mode selection"
  
  
group.long (0xC3FA0000+0x0030+0x20*11.)++0x03
  line.long    0x00 "CSR11,eMIOS Channel Status Register"
  bitfld.long  0x00 31.                  "OVR   ,Overrun (w1c)" "0,1"
  bitfld.long  0x00 15.                  "      OVFL   ,Overflow (w1c)" "0,1"
  bitfld.long  0x00 02.                  "     UCIN   ,Unified channel input pin" "0,1"
  bitfld.long  0x00 01.                  "   UCOUT ,Unified channel output pin" "0,1"
  bitfld.long  0x00 00.                  "  FLAG   ,FLAG" "0,1"
  
TEXTLINE ""



wgroup.long (0xC3FA0000+0x0020+0x20*12.)++0x03
  hide.long    0x00 "CADR12,eMIOS Channel A Data Register (not displayed by debugger)"
  in

wgroup.long (0xC3FA0000+0x0024+0x20*12.)++0x03
  hide.long    0x00 "CBDR12,eMIOS Channel B Data Register (not displayed by debugger)"
  in
  
group.long (0xC3FA0000+0x0028+0x20*12.)++0x03
  line.long    0x00 "CCNTR12,eMIOS Channel Counter Register"
  
group.long (0xC3FA0000+0x002C+0x20*12.)++0x03
  line.long    0x00 "CCR12,eMIOS Channel Control Register"
  bitfld.long  0x00 31.                  "FREN  ,Freeze enable" "0,1"
  bitfld.long  0x00 30.                  "      ODIS   ,Output disable" "0,1"
  bitfld.long  0x00 28.--29.             "     ODISSL ,Output disable select" "0,1,2,3"
  bitfld.long  0x00 26.--27.             "  UCPRE  ,Prescaler" "1,2,3,4"
  bitfld.long  0x00 25.                  "  UCPREN ,Prescaler enable" "0,1"
  bitfld.long  0x00 24.                  "  DMA ,Direct memory access" "int,dma"
  TEXTLINE "                "
  bitfld.long  0x00 19.--22.             "  IF    ,Input filter" "byp.,02,04,res.,08,res.,res.,res.,16,res.,res.,res.,res.,res.,res.,res."
  bitfld.long  0x00 18.                  "   FCK    ,Filter clock select" "presc,main"
  bitfld.long  0x00 17.                  " FEN    ,FLAG enable" "0,1"
  bitfld.long  0x00 13.                  "  FORCMA ,Force match A" "0,1"
  bitfld.long  0x00 12.                  "  FORCMB ,Force match B" "0,1"
  bitfld.long  0x00 09.--10.             "  BSL ,Bus select" "all A,mix,res.,int"
  TEXTLINE "                "
  bitfld.long  0x00 08.                  "  EDSEL ,Edge selection bit" "single,both"
  bitfld.long  0x00 07.                  " EDPOL  ,Edge polarity" "fal.,ris."
  hexmask.byte 0x03 00.--06. 1.          "  MODE  ,Mode selection"
  
  
group.long (0xC3FA0000+0x0030+0x20*12.)++0x03
  line.long    0x00 "CSR12,eMIOS Channel Status Register"
  bitfld.long  0x00 31.                  "OVR   ,Overrun (w1c)" "0,1"
  bitfld.long  0x00 15.                  "      OVFL   ,Overflow (w1c)" "0,1"
  bitfld.long  0x00 02.                  "     UCIN   ,Unified channel input pin" "0,1"
  bitfld.long  0x00 01.                  "   UCOUT ,Unified channel output pin" "0,1"
  bitfld.long  0x00 00.                  "  FLAG   ,FLAG" "0,1"
  
TEXTLINE ""



wgroup.long (0xC3FA0000+0x0020+0x20*13.)++0x03
  hide.long    0x00 "CADR13,eMIOS Channel A Data Register (not displayed by debugger)"
  in

wgroup.long (0xC3FA0000+0x0024+0x20*13.)++0x03
  hide.long    0x00 "CBDR13,eMIOS Channel B Data Register (not displayed by debugger)"
  in
  
group.long (0xC3FA0000+0x0028+0x20*13.)++0x03
  line.long    0x00 "CCNTR13,eMIOS Channel Counter Register"
  
group.long (0xC3FA0000+0x002C+0x20*13.)++0x03
  line.long    0x00 "CCR13,eMIOS Channel Control Register"
  bitfld.long  0x00 31.                  "FREN  ,Freeze enable" "0,1"
  bitfld.long  0x00 30.                  "      ODIS   ,Output disable" "0,1"
  bitfld.long  0x00 28.--29.             "     ODISSL ,Output disable select" "0,1,2,3"
  bitfld.long  0x00 26.--27.             "  UCPRE  ,Prescaler" "1,2,3,4"
  bitfld.long  0x00 25.                  "  UCPREN ,Prescaler enable" "0,1"
  bitfld.long  0x00 24.                  "  DMA ,Direct memory access" "int,dma"
  TEXTLINE "                "
  bitfld.long  0x00 19.--22.             "  IF    ,Input filter" "byp.,02,04,res.,08,res.,res.,res.,16,res.,res.,res.,res.,res.,res.,res."
  bitfld.long  0x00 18.                  "   FCK    ,Filter clock select" "presc,main"
  bitfld.long  0x00 17.                  " FEN    ,FLAG enable" "0,1"
  bitfld.long  0x00 13.                  "  FORCMA ,Force match A" "0,1"
  bitfld.long  0x00 12.                  "  FORCMB ,Force match B" "0,1"
  bitfld.long  0x00 09.--10.             "  BSL ,Bus select" "all A,mix,res.,int"
  TEXTLINE "                "
  bitfld.long  0x00 08.                  "  EDSEL ,Edge selection bit" "single,both"
  bitfld.long  0x00 07.                  " EDPOL  ,Edge polarity" "fal.,ris."
  hexmask.byte 0x03 00.--06. 1.          "  MODE  ,Mode selection"
  
  
group.long (0xC3FA0000+0x0030+0x20*13.)++0x03
  line.long    0x00 "CSR13,eMIOS Channel Status Register"
  bitfld.long  0x00 31.                  "OVR   ,Overrun (w1c)" "0,1"
  bitfld.long  0x00 15.                  "      OVFL   ,Overflow (w1c)" "0,1"
  bitfld.long  0x00 02.                  "     UCIN   ,Unified channel input pin" "0,1"
  bitfld.long  0x00 01.                  "   UCOUT ,Unified channel output pin" "0,1"
  bitfld.long  0x00 00.                  "  FLAG   ,FLAG" "0,1"
  
TEXTLINE ""



wgroup.long (0xC3FA0000+0x0020+0x20*14.)++0x03
  hide.long    0x00 "CADR14,eMIOS Channel A Data Register (not displayed by debugger)"
  in

wgroup.long (0xC3FA0000+0x0024+0x20*14.)++0x03
  hide.long    0x00 "CBDR14,eMIOS Channel B Data Register (not displayed by debugger)"
  in
  
group.long (0xC3FA0000+0x0028+0x20*14.)++0x03
  line.long    0x00 "CCNTR14,eMIOS Channel Counter Register"
  
group.long (0xC3FA0000+0x002C+0x20*14.)++0x03
  line.long    0x00 "CCR14,eMIOS Channel Control Register"
  bitfld.long  0x00 31.                  "FREN  ,Freeze enable" "0,1"
  bitfld.long  0x00 30.                  "      ODIS   ,Output disable" "0,1"
  bitfld.long  0x00 28.--29.             "     ODISSL ,Output disable select" "0,1,2,3"
  bitfld.long  0x00 26.--27.             "  UCPRE  ,Prescaler" "1,2,3,4"
  bitfld.long  0x00 25.                  "  UCPREN ,Prescaler enable" "0,1"
  bitfld.long  0x00 24.                  "  DMA ,Direct memory access" "int,dma"
  TEXTLINE "                "
  bitfld.long  0x00 19.--22.             "  IF    ,Input filter" "byp.,02,04,res.,08,res.,res.,res.,16,res.,res.,res.,res.,res.,res.,res."
  bitfld.long  0x00 18.                  "   FCK    ,Filter clock select" "presc,main"
  bitfld.long  0x00 17.                  " FEN    ,FLAG enable" "0,1"
  bitfld.long  0x00 13.                  "  FORCMA ,Force match A" "0,1"
  bitfld.long  0x00 12.                  "  FORCMB ,Force match B" "0,1"
  bitfld.long  0x00 09.--10.             "  BSL ,Bus select" "all A,mix,res.,int"
  TEXTLINE "                "
  bitfld.long  0x00 08.                  "  EDSEL ,Edge selection bit" "single,both"
  bitfld.long  0x00 07.                  " EDPOL  ,Edge polarity" "fal.,ris."
  hexmask.byte 0x03 00.--06. 1.          "  MODE  ,Mode selection"
  
  
group.long (0xC3FA0000+0x0030+0x20*14.)++0x03
  line.long    0x00 "CSR14,eMIOS Channel Status Register"
  bitfld.long  0x00 31.                  "OVR   ,Overrun (w1c)" "0,1"
  bitfld.long  0x00 15.                  "      OVFL   ,Overflow (w1c)" "0,1"
  bitfld.long  0x00 02.                  "     UCIN   ,Unified channel input pin" "0,1"
  bitfld.long  0x00 01.                  "   UCOUT ,Unified channel output pin" "0,1"
  bitfld.long  0x00 00.                  "  FLAG   ,FLAG" "0,1"
  
TEXTLINE ""



wgroup.long (0xC3FA0000+0x0020+0x20*15.)++0x03
  hide.long    0x00 "CADR15,eMIOS Channel A Data Register (not displayed by debugger)"
  in

wgroup.long (0xC3FA0000+0x0024+0x20*15.)++0x03
  hide.long    0x00 "CBDR15,eMIOS Channel B Data Register (not displayed by debugger)"
  in
  
group.long (0xC3FA0000+0x0028+0x20*15.)++0x03
  line.long    0x00 "CCNTR15,eMIOS Channel Counter Register"
  
group.long (0xC3FA0000+0x002C+0x20*15.)++0x03
  line.long    0x00 "CCR15,eMIOS Channel Control Register"
  bitfld.long  0x00 31.                  "FREN  ,Freeze enable" "0,1"
  bitfld.long  0x00 30.                  "      ODIS   ,Output disable" "0,1"
  bitfld.long  0x00 28.--29.             "     ODISSL ,Output disable select" "0,1,2,3"
  bitfld.long  0x00 26.--27.             "  UCPRE  ,Prescaler" "1,2,3,4"
  bitfld.long  0x00 25.                  "  UCPREN ,Prescaler enable" "0,1"
  bitfld.long  0x00 24.                  "  DMA ,Direct memory access" "int,dma"
  TEXTLINE "                "
  bitfld.long  0x00 19.--22.             "  IF    ,Input filter" "byp.,02,04,res.,08,res.,res.,res.,16,res.,res.,res.,res.,res.,res.,res."
  bitfld.long  0x00 18.                  "   FCK    ,Filter clock select" "presc,main"
  bitfld.long  0x00 17.                  " FEN    ,FLAG enable" "0,1"
  bitfld.long  0x00 13.                  "  FORCMA ,Force match A" "0,1"
  bitfld.long  0x00 12.                  "  FORCMB ,Force match B" "0,1"
  bitfld.long  0x00 09.--10.             "  BSL ,Bus select" "all A,mix,res.,int"
  TEXTLINE "                "
  bitfld.long  0x00 08.                  "  EDSEL ,Edge selection bit" "single,both"
  bitfld.long  0x00 07.                  " EDPOL  ,Edge polarity" "fal.,ris."
  hexmask.byte 0x03 00.--06. 1.          "  MODE  ,Mode selection"
  
  
group.long (0xC3FA0000+0x0030+0x20*15.)++0x03
  line.long    0x00 "CSR15,eMIOS Channel Status Register"
  bitfld.long  0x00 31.                  "OVR   ,Overrun (w1c)" "0,1"
  bitfld.long  0x00 15.                  "      OVFL   ,Overflow (w1c)" "0,1"
  bitfld.long  0x00 02.                  "     UCIN   ,Unified channel input pin" "0,1"
  bitfld.long  0x00 01.                  "   UCOUT ,Unified channel output pin" "0,1"
  bitfld.long  0x00 00.                  "  FLAG   ,FLAG" "0,1"
  
TEXTLINE ""



wgroup.long (0xC3FA0000+0x0020+0x20*23.)++0x03
  hide.long    0x00 "CADR23,eMIOS Channel A Data Register (not displayed by debugger)"
  in

wgroup.long (0xC3FA0000+0x0024+0x20*23.)++0x03
  hide.long    0x00 "CBDR23,eMIOS Channel B Data Register (not displayed by debugger)"
  in
  
group.long (0xC3FA0000+0x0028+0x20*23.)++0x03
  line.long    0x00 "CCNTR23,eMIOS Channel Counter Register"
  
group.long (0xC3FA0000+0x002C+0x20*23.)++0x03
  line.long    0x00 "CCR23,eMIOS Channel Control Register"
  bitfld.long  0x00 31.                  "FREN  ,Freeze enable" "0,1"
  bitfld.long  0x00 30.                  "      ODIS   ,Output disable" "0,1"
  bitfld.long  0x00 28.--29.             "     ODISSL ,Output disable select" "0,1,2,3"
  bitfld.long  0x00 26.--27.             "  UCPRE  ,Prescaler" "1,2,3,4"
  bitfld.long  0x00 25.                  "  UCPREN ,Prescaler enable" "0,1"
  bitfld.long  0x00 24.                  "  DMA ,Direct memory access" "int,dma"
  TEXTLINE "                "
  bitfld.long  0x00 19.--22.             "  IF    ,Input filter" "byp.,02,04,res.,08,res.,res.,res.,16,res.,res.,res.,res.,res.,res.,res."
  bitfld.long  0x00 18.                  "   FCK    ,Filter clock select" "presc,main"
  bitfld.long  0x00 17.                  " FEN    ,FLAG enable" "0,1"
  bitfld.long  0x00 13.                  "  FORCMA ,Force match A" "0,1"
  bitfld.long  0x00 12.                  "  FORCMB ,Force match B" "0,1"
  bitfld.long  0x00 09.--10.             "  BSL ,Bus select" "all A,mix,res.,int"
  TEXTLINE "                "
  bitfld.long  0x00 08.                  "  EDSEL ,Edge selection bit" "single,both"
  bitfld.long  0x00 07.                  " EDPOL  ,Edge polarity" "fal.,ris."
  hexmask.byte 0x03 00.--06. 1.          "  MODE  ,Mode selection"
  
  
group.long (0xC3FA0000+0x0030+0x20*23.)++0x03
  line.long    0x00 "CSR23,eMIOS Channel Status Register"
  bitfld.long  0x00 31.                  "OVR   ,Overrun (w1c)" "0,1"
  bitfld.long  0x00 15.                  "      OVFL   ,Overflow (w1c)" "0,1"
  bitfld.long  0x00 02.                  "     UCIN   ,Unified channel input pin" "0,1"
  bitfld.long  0x00 01.                  "   UCOUT ,Unified channel output pin" "0,1"
  bitfld.long  0x00 00.                  "  FLAG   ,FLAG" "0,1"
  
TEXTLINE ""


else

wgroup.long (0xC3FA0000+0x0020+0x20*0.)++0x03
  hide.long    0x00 "CADR0,eMIOS Channel A Data Register (not displayed by debugger)"
  in

wgroup.long (0xC3FA0000+0x0024+0x20*0.)++0x03
  hide.long    0x00 "CBDR0,eMIOS Channel B Data Register (not displayed by debugger)"
  in
  
group.long (0xC3FA0000+0x0028+0x20*0.)++0x03
  line.long    0x00 "CCNTR0,eMIOS Channel Counter Register"
  
group.long (0xC3FA0000+0x002C+0x20*0.)++0x03
  line.long    0x00 "CCR0,eMIOS Channel Control Register"
  bitfld.long  0x00 31.                  "FREN  ,Freeze enable" "0,1"
  bitfld.long  0x00 30.                  "      ODIS   ,Output disable" "0,1"
  bitfld.long  0x00 28.--29.             "     ODISSL ,Output disable select" "0,1,2,3"
  bitfld.long  0x00 26.--27.             "  UCPRE  ,Prescaler" "1,2,3,4"
  bitfld.long  0x00 25.                  "  UCPREN ,Prescaler enable" "0,1"
  bitfld.long  0x00 24.                  "  DMA ,Direct memory access" "int,dma"
  TEXTLINE "                "
  bitfld.long  0x00 19.--22.             "  IF    ,Input filter" "byp.,02,04,res.,08,res.,res.,res.,16,res.,res.,res.,res.,res.,res.,res."
  bitfld.long  0x00 18.                  "   FCK    ,Filter clock select" "presc,main"
  bitfld.long  0x00 17.                  " FEN    ,FLAG enable" "0,1"
  bitfld.long  0x00 13.                  "  FORCMA ,Force match A" "0,1"
  bitfld.long  0x00 12.                  "  FORCMB ,Force match B" "0,1"
  bitfld.long  0x00 09.--10.             "  BSL ,Bus select" "all A,mix,res.,int"
  TEXTLINE "                "
  bitfld.long  0x00 08.                  "  EDSEL ,Edge selection bit" "single,both"
  bitfld.long  0x00 07.                  " EDPOL  ,Edge polarity" "fal.,ris."
  hexmask.byte 0x03 00.--06. 1.          "  MODE  ,Mode selection"
  
  
group.long (0xC3FA0000+0x0030+0x20*0.)++0x03
  line.long    0x00 "CSR0,eMIOS Channel Status Register"
  bitfld.long  0x00 31.                  "OVR   ,Overrun (w1c)" "0,1"
  bitfld.long  0x00 15.                  "      OVFL   ,Overflow (w1c)" "0,1"
  bitfld.long  0x00 02.                  "     UCIN   ,Unified channel input pin" "0,1"
  bitfld.long  0x00 01.                  "   UCOUT ,Unified channel output pin" "0,1"
  bitfld.long  0x00 00.                  "  FLAG   ,FLAG" "0,1"
  
TEXTLINE ""



wgroup.long (0xC3FA0000+0x0020+0x20*1.)++0x03
  hide.long    0x00 "CADR1,eMIOS Channel A Data Register (not displayed by debugger)"
  in

wgroup.long (0xC3FA0000+0x0024+0x20*1.)++0x03
  hide.long    0x00 "CBDR1,eMIOS Channel B Data Register (not displayed by debugger)"
  in
  
group.long (0xC3FA0000+0x0028+0x20*1.)++0x03
  line.long    0x00 "CCNTR1,eMIOS Channel Counter Register"
  
group.long (0xC3FA0000+0x002C+0x20*1.)++0x03
  line.long    0x00 "CCR1,eMIOS Channel Control Register"
  bitfld.long  0x00 31.                  "FREN  ,Freeze enable" "0,1"
  bitfld.long  0x00 30.                  "      ODIS   ,Output disable" "0,1"
  bitfld.long  0x00 28.--29.             "     ODISSL ,Output disable select" "0,1,2,3"
  bitfld.long  0x00 26.--27.             "  UCPRE  ,Prescaler" "1,2,3,4"
  bitfld.long  0x00 25.                  "  UCPREN ,Prescaler enable" "0,1"
  bitfld.long  0x00 24.                  "  DMA ,Direct memory access" "int,dma"
  TEXTLINE "                "
  bitfld.long  0x00 19.--22.             "  IF    ,Input filter" "byp.,02,04,res.,08,res.,res.,res.,16,res.,res.,res.,res.,res.,res.,res."
  bitfld.long  0x00 18.                  "   FCK    ,Filter clock select" "presc,main"
  bitfld.long  0x00 17.                  " FEN    ,FLAG enable" "0,1"
  bitfld.long  0x00 13.                  "  FORCMA ,Force match A" "0,1"
  bitfld.long  0x00 12.                  "  FORCMB ,Force match B" "0,1"
  bitfld.long  0x00 09.--10.             "  BSL ,Bus select" "all A,mix,res.,int"
  TEXTLINE "                "
  bitfld.long  0x00 08.                  "  EDSEL ,Edge selection bit" "single,both"
  bitfld.long  0x00 07.                  " EDPOL  ,Edge polarity" "fal.,ris."
  hexmask.byte 0x03 00.--06. 1.          "  MODE  ,Mode selection"
  
  
group.long (0xC3FA0000+0x0030+0x20*1.)++0x03
  line.long    0x00 "CSR1,eMIOS Channel Status Register"
  bitfld.long  0x00 31.                  "OVR   ,Overrun (w1c)" "0,1"
  bitfld.long  0x00 15.                  "      OVFL   ,Overflow (w1c)" "0,1"
  bitfld.long  0x00 02.                  "     UCIN   ,Unified channel input pin" "0,1"
  bitfld.long  0x00 01.                  "   UCOUT ,Unified channel output pin" "0,1"
  bitfld.long  0x00 00.                  "  FLAG   ,FLAG" "0,1"
  
TEXTLINE ""



wgroup.long (0xC3FA0000+0x0020+0x20*2.)++0x03
  hide.long    0x00 "CADR2,eMIOS Channel A Data Register (not displayed by debugger)"
  in

wgroup.long (0xC3FA0000+0x0024+0x20*2.)++0x03
  hide.long    0x00 "CBDR2,eMIOS Channel B Data Register (not displayed by debugger)"
  in
  
group.long (0xC3FA0000+0x0028+0x20*2.)++0x03
  line.long    0x00 "CCNTR2,eMIOS Channel Counter Register"
  
group.long (0xC3FA0000+0x002C+0x20*2.)++0x03
  line.long    0x00 "CCR2,eMIOS Channel Control Register"
  bitfld.long  0x00 31.                  "FREN  ,Freeze enable" "0,1"
  bitfld.long  0x00 30.                  "      ODIS   ,Output disable" "0,1"
  bitfld.long  0x00 28.--29.             "     ODISSL ,Output disable select" "0,1,2,3"
  bitfld.long  0x00 26.--27.             "  UCPRE  ,Prescaler" "1,2,3,4"
  bitfld.long  0x00 25.                  "  UCPREN ,Prescaler enable" "0,1"
  bitfld.long  0x00 24.                  "  DMA ,Direct memory access" "int,dma"
  TEXTLINE "                "
  bitfld.long  0x00 19.--22.             "  IF    ,Input filter" "byp.,02,04,res.,08,res.,res.,res.,16,res.,res.,res.,res.,res.,res.,res."
  bitfld.long  0x00 18.                  "   FCK    ,Filter clock select" "presc,main"
  bitfld.long  0x00 17.                  " FEN    ,FLAG enable" "0,1"
  bitfld.long  0x00 13.                  "  FORCMA ,Force match A" "0,1"
  bitfld.long  0x00 12.                  "  FORCMB ,Force match B" "0,1"
  bitfld.long  0x00 09.--10.             "  BSL ,Bus select" "all A,mix,res.,int"
  TEXTLINE "                "
  bitfld.long  0x00 08.                  "  EDSEL ,Edge selection bit" "single,both"
  bitfld.long  0x00 07.                  " EDPOL  ,Edge polarity" "fal.,ris."
  hexmask.byte 0x03 00.--06. 1.          "  MODE  ,Mode selection"
  
  
group.long (0xC3FA0000+0x0030+0x20*2.)++0x03
  line.long    0x00 "CSR2,eMIOS Channel Status Register"
  bitfld.long  0x00 31.                  "OVR   ,Overrun (w1c)" "0,1"
  bitfld.long  0x00 15.                  "      OVFL   ,Overflow (w1c)" "0,1"
  bitfld.long  0x00 02.                  "     UCIN   ,Unified channel input pin" "0,1"
  bitfld.long  0x00 01.                  "   UCOUT ,Unified channel output pin" "0,1"
  bitfld.long  0x00 00.                  "  FLAG   ,FLAG" "0,1"
  
TEXTLINE ""



wgroup.long (0xC3FA0000+0x0020+0x20*3.)++0x03
  hide.long    0x00 "CADR3,eMIOS Channel A Data Register (not displayed by debugger)"
  in

wgroup.long (0xC3FA0000+0x0024+0x20*3.)++0x03
  hide.long    0x00 "CBDR3,eMIOS Channel B Data Register (not displayed by debugger)"
  in
  
group.long (0xC3FA0000+0x0028+0x20*3.)++0x03
  line.long    0x00 "CCNTR3,eMIOS Channel Counter Register"
  
group.long (0xC3FA0000+0x002C+0x20*3.)++0x03
  line.long    0x00 "CCR3,eMIOS Channel Control Register"
  bitfld.long  0x00 31.                  "FREN  ,Freeze enable" "0,1"
  bitfld.long  0x00 30.                  "      ODIS   ,Output disable" "0,1"
  bitfld.long  0x00 28.--29.             "     ODISSL ,Output disable select" "0,1,2,3"
  bitfld.long  0x00 26.--27.             "  UCPRE  ,Prescaler" "1,2,3,4"
  bitfld.long  0x00 25.                  "  UCPREN ,Prescaler enable" "0,1"
  bitfld.long  0x00 24.                  "  DMA ,Direct memory access" "int,dma"
  TEXTLINE "                "
  bitfld.long  0x00 19.--22.             "  IF    ,Input filter" "byp.,02,04,res.,08,res.,res.,res.,16,res.,res.,res.,res.,res.,res.,res."
  bitfld.long  0x00 18.                  "   FCK    ,Filter clock select" "presc,main"
  bitfld.long  0x00 17.                  " FEN    ,FLAG enable" "0,1"
  bitfld.long  0x00 13.                  "  FORCMA ,Force match A" "0,1"
  bitfld.long  0x00 12.                  "  FORCMB ,Force match B" "0,1"
  bitfld.long  0x00 09.--10.             "  BSL ,Bus select" "all A,mix,res.,int"
  TEXTLINE "                "
  bitfld.long  0x00 08.                  "  EDSEL ,Edge selection bit" "single,both"
  bitfld.long  0x00 07.                  " EDPOL  ,Edge polarity" "fal.,ris."
  hexmask.byte 0x03 00.--06. 1.          "  MODE  ,Mode selection"
  
  
group.long (0xC3FA0000+0x0030+0x20*3.)++0x03
  line.long    0x00 "CSR3,eMIOS Channel Status Register"
  bitfld.long  0x00 31.                  "OVR   ,Overrun (w1c)" "0,1"
  bitfld.long  0x00 15.                  "      OVFL   ,Overflow (w1c)" "0,1"
  bitfld.long  0x00 02.                  "     UCIN   ,Unified channel input pin" "0,1"
  bitfld.long  0x00 01.                  "   UCOUT ,Unified channel output pin" "0,1"
  bitfld.long  0x00 00.                  "  FLAG   ,FLAG" "0,1"
  
TEXTLINE ""



wgroup.long (0xC3FA0000+0x0020+0x20*4.)++0x03
  hide.long    0x00 "CADR4,eMIOS Channel A Data Register (not displayed by debugger)"
  in

wgroup.long (0xC3FA0000+0x0024+0x20*4.)++0x03
  hide.long    0x00 "CBDR4,eMIOS Channel B Data Register (not displayed by debugger)"
  in
  
group.long (0xC3FA0000+0x0028+0x20*4.)++0x03
  line.long    0x00 "CCNTR4,eMIOS Channel Counter Register"
  
group.long (0xC3FA0000+0x002C+0x20*4.)++0x03
  line.long    0x00 "CCR4,eMIOS Channel Control Register"
  bitfld.long  0x00 31.                  "FREN  ,Freeze enable" "0,1"
  bitfld.long  0x00 30.                  "      ODIS   ,Output disable" "0,1"
  bitfld.long  0x00 28.--29.             "     ODISSL ,Output disable select" "0,1,2,3"
  bitfld.long  0x00 26.--27.             "  UCPRE  ,Prescaler" "1,2,3,4"
  bitfld.long  0x00 25.                  "  UCPREN ,Prescaler enable" "0,1"
  bitfld.long  0x00 24.                  "  DMA ,Direct memory access" "int,dma"
  TEXTLINE "                "
  bitfld.long  0x00 19.--22.             "  IF    ,Input filter" "byp.,02,04,res.,08,res.,res.,res.,16,res.,res.,res.,res.,res.,res.,res."
  bitfld.long  0x00 18.                  "   FCK    ,Filter clock select" "presc,main"
  bitfld.long  0x00 17.                  " FEN    ,FLAG enable" "0,1"
  bitfld.long  0x00 13.                  "  FORCMA ,Force match A" "0,1"
  bitfld.long  0x00 12.                  "  FORCMB ,Force match B" "0,1"
  bitfld.long  0x00 09.--10.             "  BSL ,Bus select" "all A,mix,res.,int"
  TEXTLINE "                "
  bitfld.long  0x00 08.                  "  EDSEL ,Edge selection bit" "single,both"
  bitfld.long  0x00 07.                  " EDPOL  ,Edge polarity" "fal.,ris."
  hexmask.byte 0x03 00.--06. 1.          "  MODE  ,Mode selection"
  
  
group.long (0xC3FA0000+0x0030+0x20*4.)++0x03
  line.long    0x00 "CSR4,eMIOS Channel Status Register"
  bitfld.long  0x00 31.                  "OVR   ,Overrun (w1c)" "0,1"
  bitfld.long  0x00 15.                  "      OVFL   ,Overflow (w1c)" "0,1"
  bitfld.long  0x00 02.                  "     UCIN   ,Unified channel input pin" "0,1"
  bitfld.long  0x00 01.                  "   UCOUT ,Unified channel output pin" "0,1"
  bitfld.long  0x00 00.                  "  FLAG   ,FLAG" "0,1"
  
TEXTLINE ""



wgroup.long (0xC3FA0000+0x0020+0x20*5.)++0x03
  hide.long    0x00 "CADR5,eMIOS Channel A Data Register (not displayed by debugger)"
  in

wgroup.long (0xC3FA0000+0x0024+0x20*5.)++0x03
  hide.long    0x00 "CBDR5,eMIOS Channel B Data Register (not displayed by debugger)"
  in
  
group.long (0xC3FA0000+0x0028+0x20*5.)++0x03
  line.long    0x00 "CCNTR5,eMIOS Channel Counter Register"
  
group.long (0xC3FA0000+0x002C+0x20*5.)++0x03
  line.long    0x00 "CCR5,eMIOS Channel Control Register"
  bitfld.long  0x00 31.                  "FREN  ,Freeze enable" "0,1"
  bitfld.long  0x00 30.                  "      ODIS   ,Output disable" "0,1"
  bitfld.long  0x00 28.--29.             "     ODISSL ,Output disable select" "0,1,2,3"
  bitfld.long  0x00 26.--27.             "  UCPRE  ,Prescaler" "1,2,3,4"
  bitfld.long  0x00 25.                  "  UCPREN ,Prescaler enable" "0,1"
  bitfld.long  0x00 24.                  "  DMA ,Direct memory access" "int,dma"
  TEXTLINE "                "
  bitfld.long  0x00 19.--22.             "  IF    ,Input filter" "byp.,02,04,res.,08,res.,res.,res.,16,res.,res.,res.,res.,res.,res.,res."
  bitfld.long  0x00 18.                  "   FCK    ,Filter clock select" "presc,main"
  bitfld.long  0x00 17.                  " FEN    ,FLAG enable" "0,1"
  bitfld.long  0x00 13.                  "  FORCMA ,Force match A" "0,1"
  bitfld.long  0x00 12.                  "  FORCMB ,Force match B" "0,1"
  bitfld.long  0x00 09.--10.             "  BSL ,Bus select" "all A,mix,res.,int"
  TEXTLINE "                "
  bitfld.long  0x00 08.                  "  EDSEL ,Edge selection bit" "single,both"
  bitfld.long  0x00 07.                  " EDPOL  ,Edge polarity" "fal.,ris."
  hexmask.byte 0x03 00.--06. 1.          "  MODE  ,Mode selection"
  
  
group.long (0xC3FA0000+0x0030+0x20*5.)++0x03
  line.long    0x00 "CSR5,eMIOS Channel Status Register"
  bitfld.long  0x00 31.                  "OVR   ,Overrun (w1c)" "0,1"
  bitfld.long  0x00 15.                  "      OVFL   ,Overflow (w1c)" "0,1"
  bitfld.long  0x00 02.                  "     UCIN   ,Unified channel input pin" "0,1"
  bitfld.long  0x00 01.                  "   UCOUT ,Unified channel output pin" "0,1"
  bitfld.long  0x00 00.                  "  FLAG   ,FLAG" "0,1"
  
TEXTLINE ""



wgroup.long (0xC3FA0000+0x0020+0x20*6.)++0x03
  hide.long    0x00 "CADR6,eMIOS Channel A Data Register (not displayed by debugger)"
  in

wgroup.long (0xC3FA0000+0x0024+0x20*6.)++0x03
  hide.long    0x00 "CBDR6,eMIOS Channel B Data Register (not displayed by debugger)"
  in
  
group.long (0xC3FA0000+0x0028+0x20*6.)++0x03
  line.long    0x00 "CCNTR6,eMIOS Channel Counter Register"
  
group.long (0xC3FA0000+0x002C+0x20*6.)++0x03
  line.long    0x00 "CCR6,eMIOS Channel Control Register"
  bitfld.long  0x00 31.                  "FREN  ,Freeze enable" "0,1"
  bitfld.long  0x00 30.                  "      ODIS   ,Output disable" "0,1"
  bitfld.long  0x00 28.--29.             "     ODISSL ,Output disable select" "0,1,2,3"
  bitfld.long  0x00 26.--27.             "  UCPRE  ,Prescaler" "1,2,3,4"
  bitfld.long  0x00 25.                  "  UCPREN ,Prescaler enable" "0,1"
  bitfld.long  0x00 24.                  "  DMA ,Direct memory access" "int,dma"
  TEXTLINE "                "
  bitfld.long  0x00 19.--22.             "  IF    ,Input filter" "byp.,02,04,res.,08,res.,res.,res.,16,res.,res.,res.,res.,res.,res.,res."
  bitfld.long  0x00 18.                  "   FCK    ,Filter clock select" "presc,main"
  bitfld.long  0x00 17.                  " FEN    ,FLAG enable" "0,1"
  bitfld.long  0x00 13.                  "  FORCMA ,Force match A" "0,1"
  bitfld.long  0x00 12.                  "  FORCMB ,Force match B" "0,1"
  bitfld.long  0x00 09.--10.             "  BSL ,Bus select" "all A,mix,res.,int"
  TEXTLINE "                "
  bitfld.long  0x00 08.                  "  EDSEL ,Edge selection bit" "single,both"
  bitfld.long  0x00 07.                  " EDPOL  ,Edge polarity" "fal.,ris."
  hexmask.byte 0x03 00.--06. 1.          "  MODE  ,Mode selection"
  
  
group.long (0xC3FA0000+0x0030+0x20*6.)++0x03
  line.long    0x00 "CSR6,eMIOS Channel Status Register"
  bitfld.long  0x00 31.                  "OVR   ,Overrun (w1c)" "0,1"
  bitfld.long  0x00 15.                  "      OVFL   ,Overflow (w1c)" "0,1"
  bitfld.long  0x00 02.                  "     UCIN   ,Unified channel input pin" "0,1"
  bitfld.long  0x00 01.                  "   UCOUT ,Unified channel output pin" "0,1"
  bitfld.long  0x00 00.                  "  FLAG   ,FLAG" "0,1"
  
TEXTLINE ""



wgroup.long (0xC3FA0000+0x0020+0x20*7.)++0x03
  hide.long    0x00 "CADR7,eMIOS Channel A Data Register (not displayed by debugger)"
  in

wgroup.long (0xC3FA0000+0x0024+0x20*7.)++0x03
  hide.long    0x00 "CBDR7,eMIOS Channel B Data Register (not displayed by debugger)"
  in
  
group.long (0xC3FA0000+0x0028+0x20*7.)++0x03
  line.long    0x00 "CCNTR7,eMIOS Channel Counter Register"
  
group.long (0xC3FA0000+0x002C+0x20*7.)++0x03
  line.long    0x00 "CCR7,eMIOS Channel Control Register"
  bitfld.long  0x00 31.                  "FREN  ,Freeze enable" "0,1"
  bitfld.long  0x00 30.                  "      ODIS   ,Output disable" "0,1"
  bitfld.long  0x00 28.--29.             "     ODISSL ,Output disable select" "0,1,2,3"
  bitfld.long  0x00 26.--27.             "  UCPRE  ,Prescaler" "1,2,3,4"
  bitfld.long  0x00 25.                  "  UCPREN ,Prescaler enable" "0,1"
  bitfld.long  0x00 24.                  "  DMA ,Direct memory access" "int,dma"
  TEXTLINE "                "
  bitfld.long  0x00 19.--22.             "  IF    ,Input filter" "byp.,02,04,res.,08,res.,res.,res.,16,res.,res.,res.,res.,res.,res.,res."
  bitfld.long  0x00 18.                  "   FCK    ,Filter clock select" "presc,main"
  bitfld.long  0x00 17.                  " FEN    ,FLAG enable" "0,1"
  bitfld.long  0x00 13.                  "  FORCMA ,Force match A" "0,1"
  bitfld.long  0x00 12.                  "  FORCMB ,Force match B" "0,1"
  bitfld.long  0x00 09.--10.             "  BSL ,Bus select" "all A,mix,res.,int"
  TEXTLINE "                "
  bitfld.long  0x00 08.                  "  EDSEL ,Edge selection bit" "single,both"
  bitfld.long  0x00 07.                  " EDPOL  ,Edge polarity" "fal.,ris."
  hexmask.byte 0x03 00.--06. 1.          "  MODE  ,Mode selection"
  
  
group.long (0xC3FA0000+0x0030+0x20*7.)++0x03
  line.long    0x00 "CSR7,eMIOS Channel Status Register"
  bitfld.long  0x00 31.                  "OVR   ,Overrun (w1c)" "0,1"
  bitfld.long  0x00 15.                  "      OVFL   ,Overflow (w1c)" "0,1"
  bitfld.long  0x00 02.                  "     UCIN   ,Unified channel input pin" "0,1"
  bitfld.long  0x00 01.                  "   UCOUT ,Unified channel output pin" "0,1"
  bitfld.long  0x00 00.                  "  FLAG   ,FLAG" "0,1"
  
TEXTLINE ""



wgroup.long (0xC3FA0000+0x0020+0x20*8.)++0x03
  hide.long    0x00 "CADR8,eMIOS Channel A Data Register (not displayed by debugger)"
  in

wgroup.long (0xC3FA0000+0x0024+0x20*8.)++0x03
  hide.long    0x00 "CBDR8,eMIOS Channel B Data Register (not displayed by debugger)"
  in
  
group.long (0xC3FA0000+0x0028+0x20*8.)++0x03
  line.long    0x00 "CCNTR8,eMIOS Channel Counter Register"
  
group.long (0xC3FA0000+0x002C+0x20*8.)++0x03
  line.long    0x00 "CCR8,eMIOS Channel Control Register"
  bitfld.long  0x00 31.                  "FREN  ,Freeze enable" "0,1"
  bitfld.long  0x00 30.                  "      ODIS   ,Output disable" "0,1"
  bitfld.long  0x00 28.--29.             "     ODISSL ,Output disable select" "0,1,2,3"
  bitfld.long  0x00 26.--27.             "  UCPRE  ,Prescaler" "1,2,3,4"
  bitfld.long  0x00 25.                  "  UCPREN ,Prescaler enable" "0,1"
  bitfld.long  0x00 24.                  "  DMA ,Direct memory access" "int,dma"
  TEXTLINE "                "
  bitfld.long  0x00 19.--22.             "  IF    ,Input filter" "byp.,02,04,res.,08,res.,res.,res.,16,res.,res.,res.,res.,res.,res.,res."
  bitfld.long  0x00 18.                  "   FCK    ,Filter clock select" "presc,main"
  bitfld.long  0x00 17.                  " FEN    ,FLAG enable" "0,1"
  bitfld.long  0x00 13.                  "  FORCMA ,Force match A" "0,1"
  bitfld.long  0x00 12.                  "  FORCMB ,Force match B" "0,1"
  bitfld.long  0x00 09.--10.             "  BSL ,Bus select" "all A,mix,res.,int"
  TEXTLINE "                "
  bitfld.long  0x00 08.                  "  EDSEL ,Edge selection bit" "single,both"
  bitfld.long  0x00 07.                  " EDPOL  ,Edge polarity" "fal.,ris."
  hexmask.byte 0x03 00.--06. 1.          "  MODE  ,Mode selection"
  
  
group.long (0xC3FA0000+0x0030+0x20*8.)++0x03
  line.long    0x00 "CSR8,eMIOS Channel Status Register"
  bitfld.long  0x00 31.                  "OVR   ,Overrun (w1c)" "0,1"
  bitfld.long  0x00 15.                  "      OVFL   ,Overflow (w1c)" "0,1"
  bitfld.long  0x00 02.                  "     UCIN   ,Unified channel input pin" "0,1"
  bitfld.long  0x00 01.                  "   UCOUT ,Unified channel output pin" "0,1"
  bitfld.long  0x00 00.                  "  FLAG   ,FLAG" "0,1"
  
TEXTLINE ""



wgroup.long (0xC3FA0000+0x0020+0x20*9.)++0x03
  hide.long    0x00 "CADR9,eMIOS Channel A Data Register (not displayed by debugger)"
  in

wgroup.long (0xC3FA0000+0x0024+0x20*9.)++0x03
  hide.long    0x00 "CBDR9,eMIOS Channel B Data Register (not displayed by debugger)"
  in
  
group.long (0xC3FA0000+0x0028+0x20*9.)++0x03
  line.long    0x00 "CCNTR9,eMIOS Channel Counter Register"
  
group.long (0xC3FA0000+0x002C+0x20*9.)++0x03
  line.long    0x00 "CCR9,eMIOS Channel Control Register"
  bitfld.long  0x00 31.                  "FREN  ,Freeze enable" "0,1"
  bitfld.long  0x00 30.                  "      ODIS   ,Output disable" "0,1"
  bitfld.long  0x00 28.--29.             "     ODISSL ,Output disable select" "0,1,2,3"
  bitfld.long  0x00 26.--27.             "  UCPRE  ,Prescaler" "1,2,3,4"
  bitfld.long  0x00 25.                  "  UCPREN ,Prescaler enable" "0,1"
  bitfld.long  0x00 24.                  "  DMA ,Direct memory access" "int,dma"
  TEXTLINE "                "
  bitfld.long  0x00 19.--22.             "  IF    ,Input filter" "byp.,02,04,res.,08,res.,res.,res.,16,res.,res.,res.,res.,res.,res.,res."
  bitfld.long  0x00 18.                  "   FCK    ,Filter clock select" "presc,main"
  bitfld.long  0x00 17.                  " FEN    ,FLAG enable" "0,1"
  bitfld.long  0x00 13.                  "  FORCMA ,Force match A" "0,1"
  bitfld.long  0x00 12.                  "  FORCMB ,Force match B" "0,1"
  bitfld.long  0x00 09.--10.             "  BSL ,Bus select" "all A,mix,res.,int"
  TEXTLINE "                "
  bitfld.long  0x00 08.                  "  EDSEL ,Edge selection bit" "single,both"
  bitfld.long  0x00 07.                  " EDPOL  ,Edge polarity" "fal.,ris."
  hexmask.byte 0x03 00.--06. 1.          "  MODE  ,Mode selection"
  
  
group.long (0xC3FA0000+0x0030+0x20*9.)++0x03
  line.long    0x00 "CSR9,eMIOS Channel Status Register"
  bitfld.long  0x00 31.                  "OVR   ,Overrun (w1c)" "0,1"
  bitfld.long  0x00 15.                  "      OVFL   ,Overflow (w1c)" "0,1"
  bitfld.long  0x00 02.                  "     UCIN   ,Unified channel input pin" "0,1"
  bitfld.long  0x00 01.                  "   UCOUT ,Unified channel output pin" "0,1"
  bitfld.long  0x00 00.                  "  FLAG   ,FLAG" "0,1"
  
TEXTLINE ""



wgroup.long (0xC3FA0000+0x0020+0x20*10.)++0x03
  hide.long    0x00 "CADR10,eMIOS Channel A Data Register (not displayed by debugger)"
  in

wgroup.long (0xC3FA0000+0x0024+0x20*10.)++0x03
  hide.long    0x00 "CBDR10,eMIOS Channel B Data Register (not displayed by debugger)"
  in
  
group.long (0xC3FA0000+0x0028+0x20*10.)++0x03
  line.long    0x00 "CCNTR10,eMIOS Channel Counter Register"
  
group.long (0xC3FA0000+0x002C+0x20*10.)++0x03
  line.long    0x00 "CCR10,eMIOS Channel Control Register"
  bitfld.long  0x00 31.                  "FREN  ,Freeze enable" "0,1"
  bitfld.long  0x00 30.                  "      ODIS   ,Output disable" "0,1"
  bitfld.long  0x00 28.--29.             "     ODISSL ,Output disable select" "0,1,2,3"
  bitfld.long  0x00 26.--27.             "  UCPRE  ,Prescaler" "1,2,3,4"
  bitfld.long  0x00 25.                  "  UCPREN ,Prescaler enable" "0,1"
  bitfld.long  0x00 24.                  "  DMA ,Direct memory access" "int,dma"
  TEXTLINE "                "
  bitfld.long  0x00 19.--22.             "  IF    ,Input filter" "byp.,02,04,res.,08,res.,res.,res.,16,res.,res.,res.,res.,res.,res.,res."
  bitfld.long  0x00 18.                  "   FCK    ,Filter clock select" "presc,main"
  bitfld.long  0x00 17.                  " FEN    ,FLAG enable" "0,1"
  bitfld.long  0x00 13.                  "  FORCMA ,Force match A" "0,1"
  bitfld.long  0x00 12.                  "  FORCMB ,Force match B" "0,1"
  bitfld.long  0x00 09.--10.             "  BSL ,Bus select" "all A,mix,res.,int"
  TEXTLINE "                "
  bitfld.long  0x00 08.                  "  EDSEL ,Edge selection bit" "single,both"
  bitfld.long  0x00 07.                  " EDPOL  ,Edge polarity" "fal.,ris."
  hexmask.byte 0x03 00.--06. 1.          "  MODE  ,Mode selection"
  
  
group.long (0xC3FA0000+0x0030+0x20*10.)++0x03
  line.long    0x00 "CSR10,eMIOS Channel Status Register"
  bitfld.long  0x00 31.                  "OVR   ,Overrun (w1c)" "0,1"
  bitfld.long  0x00 15.                  "      OVFL   ,Overflow (w1c)" "0,1"
  bitfld.long  0x00 02.                  "     UCIN   ,Unified channel input pin" "0,1"
  bitfld.long  0x00 01.                  "   UCOUT ,Unified channel output pin" "0,1"
  bitfld.long  0x00 00.                  "  FLAG   ,FLAG" "0,1"
  
TEXTLINE ""



wgroup.long (0xC3FA0000+0x0020+0x20*11.)++0x03
  hide.long    0x00 "CADR11,eMIOS Channel A Data Register (not displayed by debugger)"
  in

wgroup.long (0xC3FA0000+0x0024+0x20*11.)++0x03
  hide.long    0x00 "CBDR11,eMIOS Channel B Data Register (not displayed by debugger)"
  in
  
group.long (0xC3FA0000+0x0028+0x20*11.)++0x03
  line.long    0x00 "CCNTR11,eMIOS Channel Counter Register"
  
group.long (0xC3FA0000+0x002C+0x20*11.)++0x03
  line.long    0x00 "CCR11,eMIOS Channel Control Register"
  bitfld.long  0x00 31.                  "FREN  ,Freeze enable" "0,1"
  bitfld.long  0x00 30.                  "      ODIS   ,Output disable" "0,1"
  bitfld.long  0x00 28.--29.             "     ODISSL ,Output disable select" "0,1,2,3"
  bitfld.long  0x00 26.--27.             "  UCPRE  ,Prescaler" "1,2,3,4"
  bitfld.long  0x00 25.                  "  UCPREN ,Prescaler enable" "0,1"
  bitfld.long  0x00 24.                  "  DMA ,Direct memory access" "int,dma"
  TEXTLINE "                "
  bitfld.long  0x00 19.--22.             "  IF    ,Input filter" "byp.,02,04,res.,08,res.,res.,res.,16,res.,res.,res.,res.,res.,res.,res."
  bitfld.long  0x00 18.                  "   FCK    ,Filter clock select" "presc,main"
  bitfld.long  0x00 17.                  " FEN    ,FLAG enable" "0,1"
  bitfld.long  0x00 13.                  "  FORCMA ,Force match A" "0,1"
  bitfld.long  0x00 12.                  "  FORCMB ,Force match B" "0,1"
  bitfld.long  0x00 09.--10.             "  BSL ,Bus select" "all A,mix,res.,int"
  TEXTLINE "                "
  bitfld.long  0x00 08.                  "  EDSEL ,Edge selection bit" "single,both"
  bitfld.long  0x00 07.                  " EDPOL  ,Edge polarity" "fal.,ris."
  hexmask.byte 0x03 00.--06. 1.          "  MODE  ,Mode selection"
  
  
group.long (0xC3FA0000+0x0030+0x20*11.)++0x03
  line.long    0x00 "CSR11,eMIOS Channel Status Register"
  bitfld.long  0x00 31.                  "OVR   ,Overrun (w1c)" "0,1"
  bitfld.long  0x00 15.                  "      OVFL   ,Overflow (w1c)" "0,1"
  bitfld.long  0x00 02.                  "     UCIN   ,Unified channel input pin" "0,1"
  bitfld.long  0x00 01.                  "   UCOUT ,Unified channel output pin" "0,1"
  bitfld.long  0x00 00.                  "  FLAG   ,FLAG" "0,1"
  
TEXTLINE ""



wgroup.long (0xC3FA0000+0x0020+0x20*12.)++0x03
  hide.long    0x00 "CADR12,eMIOS Channel A Data Register (not displayed by debugger)"
  in

wgroup.long (0xC3FA0000+0x0024+0x20*12.)++0x03
  hide.long    0x00 "CBDR12,eMIOS Channel B Data Register (not displayed by debugger)"
  in
  
group.long (0xC3FA0000+0x0028+0x20*12.)++0x03
  line.long    0x00 "CCNTR12,eMIOS Channel Counter Register"
  
group.long (0xC3FA0000+0x002C+0x20*12.)++0x03
  line.long    0x00 "CCR12,eMIOS Channel Control Register"
  bitfld.long  0x00 31.                  "FREN  ,Freeze enable" "0,1"
  bitfld.long  0x00 30.                  "      ODIS   ,Output disable" "0,1"
  bitfld.long  0x00 28.--29.             "     ODISSL ,Output disable select" "0,1,2,3"
  bitfld.long  0x00 26.--27.             "  UCPRE  ,Prescaler" "1,2,3,4"
  bitfld.long  0x00 25.                  "  UCPREN ,Prescaler enable" "0,1"
  bitfld.long  0x00 24.                  "  DMA ,Direct memory access" "int,dma"
  TEXTLINE "                "
  bitfld.long  0x00 19.--22.             "  IF    ,Input filter" "byp.,02,04,res.,08,res.,res.,res.,16,res.,res.,res.,res.,res.,res.,res."
  bitfld.long  0x00 18.                  "   FCK    ,Filter clock select" "presc,main"
  bitfld.long  0x00 17.                  " FEN    ,FLAG enable" "0,1"
  bitfld.long  0x00 13.                  "  FORCMA ,Force match A" "0,1"
  bitfld.long  0x00 12.                  "  FORCMB ,Force match B" "0,1"
  bitfld.long  0x00 09.--10.             "  BSL ,Bus select" "all A,mix,res.,int"
  TEXTLINE "                "
  bitfld.long  0x00 08.                  "  EDSEL ,Edge selection bit" "single,both"
  bitfld.long  0x00 07.                  " EDPOL  ,Edge polarity" "fal.,ris."
  hexmask.byte 0x03 00.--06. 1.          "  MODE  ,Mode selection"
  
  
group.long (0xC3FA0000+0x0030+0x20*12.)++0x03
  line.long    0x00 "CSR12,eMIOS Channel Status Register"
  bitfld.long  0x00 31.                  "OVR   ,Overrun (w1c)" "0,1"
  bitfld.long  0x00 15.                  "      OVFL   ,Overflow (w1c)" "0,1"
  bitfld.long  0x00 02.                  "     UCIN   ,Unified channel input pin" "0,1"
  bitfld.long  0x00 01.                  "   UCOUT ,Unified channel output pin" "0,1"
  bitfld.long  0x00 00.                  "  FLAG   ,FLAG" "0,1"
  
TEXTLINE ""



wgroup.long (0xC3FA0000+0x0020+0x20*13.)++0x03
  hide.long    0x00 "CADR13,eMIOS Channel A Data Register (not displayed by debugger)"
  in

wgroup.long (0xC3FA0000+0x0024+0x20*13.)++0x03
  hide.long    0x00 "CBDR13,eMIOS Channel B Data Register (not displayed by debugger)"
  in
  
group.long (0xC3FA0000+0x0028+0x20*13.)++0x03
  line.long    0x00 "CCNTR13,eMIOS Channel Counter Register"
  
group.long (0xC3FA0000+0x002C+0x20*13.)++0x03
  line.long    0x00 "CCR13,eMIOS Channel Control Register"
  bitfld.long  0x00 31.                  "FREN  ,Freeze enable" "0,1"
  bitfld.long  0x00 30.                  "      ODIS   ,Output disable" "0,1"
  bitfld.long  0x00 28.--29.             "     ODISSL ,Output disable select" "0,1,2,3"
  bitfld.long  0x00 26.--27.             "  UCPRE  ,Prescaler" "1,2,3,4"
  bitfld.long  0x00 25.                  "  UCPREN ,Prescaler enable" "0,1"
  bitfld.long  0x00 24.                  "  DMA ,Direct memory access" "int,dma"
  TEXTLINE "                "
  bitfld.long  0x00 19.--22.             "  IF    ,Input filter" "byp.,02,04,res.,08,res.,res.,res.,16,res.,res.,res.,res.,res.,res.,res."
  bitfld.long  0x00 18.                  "   FCK    ,Filter clock select" "presc,main"
  bitfld.long  0x00 17.                  " FEN    ,FLAG enable" "0,1"
  bitfld.long  0x00 13.                  "  FORCMA ,Force match A" "0,1"
  bitfld.long  0x00 12.                  "  FORCMB ,Force match B" "0,1"
  bitfld.long  0x00 09.--10.             "  BSL ,Bus select" "all A,mix,res.,int"
  TEXTLINE "                "
  bitfld.long  0x00 08.                  "  EDSEL ,Edge selection bit" "single,both"
  bitfld.long  0x00 07.                  " EDPOL  ,Edge polarity" "fal.,ris."
  hexmask.byte 0x03 00.--06. 1.          "  MODE  ,Mode selection"
  
  
group.long (0xC3FA0000+0x0030+0x20*13.)++0x03
  line.long    0x00 "CSR13,eMIOS Channel Status Register"
  bitfld.long  0x00 31.                  "OVR   ,Overrun (w1c)" "0,1"
  bitfld.long  0x00 15.                  "      OVFL   ,Overflow (w1c)" "0,1"
  bitfld.long  0x00 02.                  "     UCIN   ,Unified channel input pin" "0,1"
  bitfld.long  0x00 01.                  "   UCOUT ,Unified channel output pin" "0,1"
  bitfld.long  0x00 00.                  "  FLAG   ,FLAG" "0,1"
  
TEXTLINE ""



wgroup.long (0xC3FA0000+0x0020+0x20*14.)++0x03
  hide.long    0x00 "CADR14,eMIOS Channel A Data Register (not displayed by debugger)"
  in

wgroup.long (0xC3FA0000+0x0024+0x20*14.)++0x03
  hide.long    0x00 "CBDR14,eMIOS Channel B Data Register (not displayed by debugger)"
  in
  
group.long (0xC3FA0000+0x0028+0x20*14.)++0x03
  line.long    0x00 "CCNTR14,eMIOS Channel Counter Register"
  
group.long (0xC3FA0000+0x002C+0x20*14.)++0x03
  line.long    0x00 "CCR14,eMIOS Channel Control Register"
  bitfld.long  0x00 31.                  "FREN  ,Freeze enable" "0,1"
  bitfld.long  0x00 30.                  "      ODIS   ,Output disable" "0,1"
  bitfld.long  0x00 28.--29.             "     ODISSL ,Output disable select" "0,1,2,3"
  bitfld.long  0x00 26.--27.             "  UCPRE  ,Prescaler" "1,2,3,4"
  bitfld.long  0x00 25.                  "  UCPREN ,Prescaler enable" "0,1"
  bitfld.long  0x00 24.                  "  DMA ,Direct memory access" "int,dma"
  TEXTLINE "                "
  bitfld.long  0x00 19.--22.             "  IF    ,Input filter" "byp.,02,04,res.,08,res.,res.,res.,16,res.,res.,res.,res.,res.,res.,res."
  bitfld.long  0x00 18.                  "   FCK    ,Filter clock select" "presc,main"
  bitfld.long  0x00 17.                  " FEN    ,FLAG enable" "0,1"
  bitfld.long  0x00 13.                  "  FORCMA ,Force match A" "0,1"
  bitfld.long  0x00 12.                  "  FORCMB ,Force match B" "0,1"
  bitfld.long  0x00 09.--10.             "  BSL ,Bus select" "all A,mix,res.,int"
  TEXTLINE "                "
  bitfld.long  0x00 08.                  "  EDSEL ,Edge selection bit" "single,both"
  bitfld.long  0x00 07.                  " EDPOL  ,Edge polarity" "fal.,ris."
  hexmask.byte 0x03 00.--06. 1.          "  MODE  ,Mode selection"
  
  
group.long (0xC3FA0000+0x0030+0x20*14.)++0x03
  line.long    0x00 "CSR14,eMIOS Channel Status Register"
  bitfld.long  0x00 31.                  "OVR   ,Overrun (w1c)" "0,1"
  bitfld.long  0x00 15.                  "      OVFL   ,Overflow (w1c)" "0,1"
  bitfld.long  0x00 02.                  "     UCIN   ,Unified channel input pin" "0,1"
  bitfld.long  0x00 01.                  "   UCOUT ,Unified channel output pin" "0,1"
  bitfld.long  0x00 00.                  "  FLAG   ,FLAG" "0,1"
  
TEXTLINE ""



wgroup.long (0xC3FA0000+0x0020+0x20*15.)++0x03
  hide.long    0x00 "CADR15,eMIOS Channel A Data Register (not displayed by debugger)"
  in

wgroup.long (0xC3FA0000+0x0024+0x20*15.)++0x03
  hide.long    0x00 "CBDR15,eMIOS Channel B Data Register (not displayed by debugger)"
  in
  
group.long (0xC3FA0000+0x0028+0x20*15.)++0x03
  line.long    0x00 "CCNTR15,eMIOS Channel Counter Register"
  
group.long (0xC3FA0000+0x002C+0x20*15.)++0x03
  line.long    0x00 "CCR15,eMIOS Channel Control Register"
  bitfld.long  0x00 31.                  "FREN  ,Freeze enable" "0,1"
  bitfld.long  0x00 30.                  "      ODIS   ,Output disable" "0,1"
  bitfld.long  0x00 28.--29.             "     ODISSL ,Output disable select" "0,1,2,3"
  bitfld.long  0x00 26.--27.             "  UCPRE  ,Prescaler" "1,2,3,4"
  bitfld.long  0x00 25.                  "  UCPREN ,Prescaler enable" "0,1"
  bitfld.long  0x00 24.                  "  DMA ,Direct memory access" "int,dma"
  TEXTLINE "                "
  bitfld.long  0x00 19.--22.             "  IF    ,Input filter" "byp.,02,04,res.,08,res.,res.,res.,16,res.,res.,res.,res.,res.,res.,res."
  bitfld.long  0x00 18.                  "   FCK    ,Filter clock select" "presc,main"
  bitfld.long  0x00 17.                  " FEN    ,FLAG enable" "0,1"
  bitfld.long  0x00 13.                  "  FORCMA ,Force match A" "0,1"
  bitfld.long  0x00 12.                  "  FORCMB ,Force match B" "0,1"
  bitfld.long  0x00 09.--10.             "  BSL ,Bus select" "all A,mix,res.,int"
  TEXTLINE "                "
  bitfld.long  0x00 08.                  "  EDSEL ,Edge selection bit" "single,both"
  bitfld.long  0x00 07.                  " EDPOL  ,Edge polarity" "fal.,ris."
  hexmask.byte 0x03 00.--06. 1.          "  MODE  ,Mode selection"
  
  
group.long (0xC3FA0000+0x0030+0x20*15.)++0x03
  line.long    0x00 "CSR15,eMIOS Channel Status Register"
  bitfld.long  0x00 31.                  "OVR   ,Overrun (w1c)" "0,1"
  bitfld.long  0x00 15.                  "      OVFL   ,Overflow (w1c)" "0,1"
  bitfld.long  0x00 02.                  "     UCIN   ,Unified channel input pin" "0,1"
  bitfld.long  0x00 01.                  "   UCOUT ,Unified channel output pin" "0,1"
  bitfld.long  0x00 00.                  "  FLAG   ,FLAG" "0,1"
  
TEXTLINE ""



wgroup.long (0xC3FA0000+0x0020+0x20*16.)++0x03
  hide.long    0x00 "CADR16,eMIOS Channel A Data Register (not displayed by debugger)"
  in

wgroup.long (0xC3FA0000+0x0024+0x20*16.)++0x03
  hide.long    0x00 "CBDR16,eMIOS Channel B Data Register (not displayed by debugger)"
  in
  
group.long (0xC3FA0000+0x0028+0x20*16.)++0x03
  line.long    0x00 "CCNTR16,eMIOS Channel Counter Register"
  
group.long (0xC3FA0000+0x002C+0x20*16.)++0x03
  line.long    0x00 "CCR16,eMIOS Channel Control Register"
  bitfld.long  0x00 31.                  "FREN  ,Freeze enable" "0,1"
  bitfld.long  0x00 30.                  "      ODIS   ,Output disable" "0,1"
  bitfld.long  0x00 28.--29.             "     ODISSL ,Output disable select" "0,1,2,3"
  bitfld.long  0x00 26.--27.             "  UCPRE  ,Prescaler" "1,2,3,4"
  bitfld.long  0x00 25.                  "  UCPREN ,Prescaler enable" "0,1"
  bitfld.long  0x00 24.                  "  DMA ,Direct memory access" "int,dma"
  TEXTLINE "                "
  bitfld.long  0x00 19.--22.             "  IF    ,Input filter" "byp.,02,04,res.,08,res.,res.,res.,16,res.,res.,res.,res.,res.,res.,res."
  bitfld.long  0x00 18.                  "   FCK    ,Filter clock select" "presc,main"
  bitfld.long  0x00 17.                  " FEN    ,FLAG enable" "0,1"
  bitfld.long  0x00 13.                  "  FORCMA ,Force match A" "0,1"
  bitfld.long  0x00 12.                  "  FORCMB ,Force match B" "0,1"
  bitfld.long  0x00 09.--10.             "  BSL ,Bus select" "all A,mix,res.,int"
  TEXTLINE "                "
  bitfld.long  0x00 08.                  "  EDSEL ,Edge selection bit" "single,both"
  bitfld.long  0x00 07.                  " EDPOL  ,Edge polarity" "fal.,ris."
  hexmask.byte 0x03 00.--06. 1.          "  MODE  ,Mode selection"
  
  
group.long (0xC3FA0000+0x0030+0x20*16.)++0x03
  line.long    0x00 "CSR16,eMIOS Channel Status Register"
  bitfld.long  0x00 31.                  "OVR   ,Overrun (w1c)" "0,1"
  bitfld.long  0x00 15.                  "      OVFL   ,Overflow (w1c)" "0,1"
  bitfld.long  0x00 02.                  "     UCIN   ,Unified channel input pin" "0,1"
  bitfld.long  0x00 01.                  "   UCOUT ,Unified channel output pin" "0,1"
  bitfld.long  0x00 00.                  "  FLAG   ,FLAG" "0,1"
  
TEXTLINE ""



wgroup.long (0xC3FA0000+0x0020+0x20*17.)++0x03
  hide.long    0x00 "CADR17,eMIOS Channel A Data Register (not displayed by debugger)"
  in

wgroup.long (0xC3FA0000+0x0024+0x20*17.)++0x03
  hide.long    0x00 "CBDR17,eMIOS Channel B Data Register (not displayed by debugger)"
  in
  
group.long (0xC3FA0000+0x0028+0x20*17.)++0x03
  line.long    0x00 "CCNTR17,eMIOS Channel Counter Register"
  
group.long (0xC3FA0000+0x002C+0x20*17.)++0x03
  line.long    0x00 "CCR17,eMIOS Channel Control Register"
  bitfld.long  0x00 31.                  "FREN  ,Freeze enable" "0,1"
  bitfld.long  0x00 30.                  "      ODIS   ,Output disable" "0,1"
  bitfld.long  0x00 28.--29.             "     ODISSL ,Output disable select" "0,1,2,3"
  bitfld.long  0x00 26.--27.             "  UCPRE  ,Prescaler" "1,2,3,4"
  bitfld.long  0x00 25.                  "  UCPREN ,Prescaler enable" "0,1"
  bitfld.long  0x00 24.                  "  DMA ,Direct memory access" "int,dma"
  TEXTLINE "                "
  bitfld.long  0x00 19.--22.             "  IF    ,Input filter" "byp.,02,04,res.,08,res.,res.,res.,16,res.,res.,res.,res.,res.,res.,res."
  bitfld.long  0x00 18.                  "   FCK    ,Filter clock select" "presc,main"
  bitfld.long  0x00 17.                  " FEN    ,FLAG enable" "0,1"
  bitfld.long  0x00 13.                  "  FORCMA ,Force match A" "0,1"
  bitfld.long  0x00 12.                  "  FORCMB ,Force match B" "0,1"
  bitfld.long  0x00 09.--10.             "  BSL ,Bus select" "all A,mix,res.,int"
  TEXTLINE "                "
  bitfld.long  0x00 08.                  "  EDSEL ,Edge selection bit" "single,both"
  bitfld.long  0x00 07.                  " EDPOL  ,Edge polarity" "fal.,ris."
  hexmask.byte 0x03 00.--06. 1.          "  MODE  ,Mode selection"
  
  
group.long (0xC3FA0000+0x0030+0x20*17.)++0x03
  line.long    0x00 "CSR17,eMIOS Channel Status Register"
  bitfld.long  0x00 31.                  "OVR   ,Overrun (w1c)" "0,1"
  bitfld.long  0x00 15.                  "      OVFL   ,Overflow (w1c)" "0,1"
  bitfld.long  0x00 02.                  "     UCIN   ,Unified channel input pin" "0,1"
  bitfld.long  0x00 01.                  "   UCOUT ,Unified channel output pin" "0,1"
  bitfld.long  0x00 00.                  "  FLAG   ,FLAG" "0,1"
  
TEXTLINE ""



wgroup.long (0xC3FA0000+0x0020+0x20*18.)++0x03
  hide.long    0x00 "CADR18,eMIOS Channel A Data Register (not displayed by debugger)"
  in

wgroup.long (0xC3FA0000+0x0024+0x20*18.)++0x03
  hide.long    0x00 "CBDR18,eMIOS Channel B Data Register (not displayed by debugger)"
  in
  
group.long (0xC3FA0000+0x0028+0x20*18.)++0x03
  line.long    0x00 "CCNTR18,eMIOS Channel Counter Register"
  
group.long (0xC3FA0000+0x002C+0x20*18.)++0x03
  line.long    0x00 "CCR18,eMIOS Channel Control Register"
  bitfld.long  0x00 31.                  "FREN  ,Freeze enable" "0,1"
  bitfld.long  0x00 30.                  "      ODIS   ,Output disable" "0,1"
  bitfld.long  0x00 28.--29.             "     ODISSL ,Output disable select" "0,1,2,3"
  bitfld.long  0x00 26.--27.             "  UCPRE  ,Prescaler" "1,2,3,4"
  bitfld.long  0x00 25.                  "  UCPREN ,Prescaler enable" "0,1"
  bitfld.long  0x00 24.                  "  DMA ,Direct memory access" "int,dma"
  TEXTLINE "                "
  bitfld.long  0x00 19.--22.             "  IF    ,Input filter" "byp.,02,04,res.,08,res.,res.,res.,16,res.,res.,res.,res.,res.,res.,res."
  bitfld.long  0x00 18.                  "   FCK    ,Filter clock select" "presc,main"
  bitfld.long  0x00 17.                  " FEN    ,FLAG enable" "0,1"
  bitfld.long  0x00 13.                  "  FORCMA ,Force match A" "0,1"
  bitfld.long  0x00 12.                  "  FORCMB ,Force match B" "0,1"
  bitfld.long  0x00 09.--10.             "  BSL ,Bus select" "all A,mix,res.,int"
  TEXTLINE "                "
  bitfld.long  0x00 08.                  "  EDSEL ,Edge selection bit" "single,both"
  bitfld.long  0x00 07.                  " EDPOL  ,Edge polarity" "fal.,ris."
  hexmask.byte 0x03 00.--06. 1.          "  MODE  ,Mode selection"
  
  
group.long (0xC3FA0000+0x0030+0x20*18.)++0x03
  line.long    0x00 "CSR18,eMIOS Channel Status Register"
  bitfld.long  0x00 31.                  "OVR   ,Overrun (w1c)" "0,1"
  bitfld.long  0x00 15.                  "      OVFL   ,Overflow (w1c)" "0,1"
  bitfld.long  0x00 02.                  "     UCIN   ,Unified channel input pin" "0,1"
  bitfld.long  0x00 01.                  "   UCOUT ,Unified channel output pin" "0,1"
  bitfld.long  0x00 00.                  "  FLAG   ,FLAG" "0,1"
  
TEXTLINE ""



wgroup.long (0xC3FA0000+0x0020+0x20*19.)++0x03
  hide.long    0x00 "CADR19,eMIOS Channel A Data Register (not displayed by debugger)"
  in

wgroup.long (0xC3FA0000+0x0024+0x20*19.)++0x03
  hide.long    0x00 "CBDR19,eMIOS Channel B Data Register (not displayed by debugger)"
  in
  
group.long (0xC3FA0000+0x0028+0x20*19.)++0x03
  line.long    0x00 "CCNTR19,eMIOS Channel Counter Register"
  
group.long (0xC3FA0000+0x002C+0x20*19.)++0x03
  line.long    0x00 "CCR19,eMIOS Channel Control Register"
  bitfld.long  0x00 31.                  "FREN  ,Freeze enable" "0,1"
  bitfld.long  0x00 30.                  "      ODIS   ,Output disable" "0,1"
  bitfld.long  0x00 28.--29.             "     ODISSL ,Output disable select" "0,1,2,3"
  bitfld.long  0x00 26.--27.             "  UCPRE  ,Prescaler" "1,2,3,4"
  bitfld.long  0x00 25.                  "  UCPREN ,Prescaler enable" "0,1"
  bitfld.long  0x00 24.                  "  DMA ,Direct memory access" "int,dma"
  TEXTLINE "                "
  bitfld.long  0x00 19.--22.             "  IF    ,Input filter" "byp.,02,04,res.,08,res.,res.,res.,16,res.,res.,res.,res.,res.,res.,res."
  bitfld.long  0x00 18.                  "   FCK    ,Filter clock select" "presc,main"
  bitfld.long  0x00 17.                  " FEN    ,FLAG enable" "0,1"
  bitfld.long  0x00 13.                  "  FORCMA ,Force match A" "0,1"
  bitfld.long  0x00 12.                  "  FORCMB ,Force match B" "0,1"
  bitfld.long  0x00 09.--10.             "  BSL ,Bus select" "all A,mix,res.,int"
  TEXTLINE "                "
  bitfld.long  0x00 08.                  "  EDSEL ,Edge selection bit" "single,both"
  bitfld.long  0x00 07.                  " EDPOL  ,Edge polarity" "fal.,ris."
  hexmask.byte 0x03 00.--06. 1.          "  MODE  ,Mode selection"
  
  
group.long (0xC3FA0000+0x0030+0x20*19.)++0x03
  line.long    0x00 "CSR19,eMIOS Channel Status Register"
  bitfld.long  0x00 31.                  "OVR   ,Overrun (w1c)" "0,1"
  bitfld.long  0x00 15.                  "      OVFL   ,Overflow (w1c)" "0,1"
  bitfld.long  0x00 02.                  "     UCIN   ,Unified channel input pin" "0,1"
  bitfld.long  0x00 01.                  "   UCOUT ,Unified channel output pin" "0,1"
  bitfld.long  0x00 00.                  "  FLAG   ,FLAG" "0,1"
  
TEXTLINE ""



wgroup.long (0xC3FA0000+0x0020+0x20*20.)++0x03
  hide.long    0x00 "CADR20,eMIOS Channel A Data Register (not displayed by debugger)"
  in

wgroup.long (0xC3FA0000+0x0024+0x20*20.)++0x03
  hide.long    0x00 "CBDR20,eMIOS Channel B Data Register (not displayed by debugger)"
  in
  
group.long (0xC3FA0000+0x0028+0x20*20.)++0x03
  line.long    0x00 "CCNTR20,eMIOS Channel Counter Register"
  
group.long (0xC3FA0000+0x002C+0x20*20.)++0x03
  line.long    0x00 "CCR20,eMIOS Channel Control Register"
  bitfld.long  0x00 31.                  "FREN  ,Freeze enable" "0,1"
  bitfld.long  0x00 30.                  "      ODIS   ,Output disable" "0,1"
  bitfld.long  0x00 28.--29.             "     ODISSL ,Output disable select" "0,1,2,3"
  bitfld.long  0x00 26.--27.             "  UCPRE  ,Prescaler" "1,2,3,4"
  bitfld.long  0x00 25.                  "  UCPREN ,Prescaler enable" "0,1"
  bitfld.long  0x00 24.                  "  DMA ,Direct memory access" "int,dma"
  TEXTLINE "                "
  bitfld.long  0x00 19.--22.             "  IF    ,Input filter" "byp.,02,04,res.,08,res.,res.,res.,16,res.,res.,res.,res.,res.,res.,res."
  bitfld.long  0x00 18.                  "   FCK    ,Filter clock select" "presc,main"
  bitfld.long  0x00 17.                  " FEN    ,FLAG enable" "0,1"
  bitfld.long  0x00 13.                  "  FORCMA ,Force match A" "0,1"
  bitfld.long  0x00 12.                  "  FORCMB ,Force match B" "0,1"
  bitfld.long  0x00 09.--10.             "  BSL ,Bus select" "all A,mix,res.,int"
  TEXTLINE "                "
  bitfld.long  0x00 08.                  "  EDSEL ,Edge selection bit" "single,both"
  bitfld.long  0x00 07.                  " EDPOL  ,Edge polarity" "fal.,ris."
  hexmask.byte 0x03 00.--06. 1.          "  MODE  ,Mode selection"
  
  
group.long (0xC3FA0000+0x0030+0x20*20.)++0x03
  line.long    0x00 "CSR20,eMIOS Channel Status Register"
  bitfld.long  0x00 31.                  "OVR   ,Overrun (w1c)" "0,1"
  bitfld.long  0x00 15.                  "      OVFL   ,Overflow (w1c)" "0,1"
  bitfld.long  0x00 02.                  "     UCIN   ,Unified channel input pin" "0,1"
  bitfld.long  0x00 01.                  "   UCOUT ,Unified channel output pin" "0,1"
  bitfld.long  0x00 00.                  "  FLAG   ,FLAG" "0,1"
  
TEXTLINE ""



wgroup.long (0xC3FA0000+0x0020+0x20*21.)++0x03
  hide.long    0x00 "CADR21,eMIOS Channel A Data Register (not displayed by debugger)"
  in

wgroup.long (0xC3FA0000+0x0024+0x20*21.)++0x03
  hide.long    0x00 "CBDR21,eMIOS Channel B Data Register (not displayed by debugger)"
  in
  
group.long (0xC3FA0000+0x0028+0x20*21.)++0x03
  line.long    0x00 "CCNTR21,eMIOS Channel Counter Register"
  
group.long (0xC3FA0000+0x002C+0x20*21.)++0x03
  line.long    0x00 "CCR21,eMIOS Channel Control Register"
  bitfld.long  0x00 31.                  "FREN  ,Freeze enable" "0,1"
  bitfld.long  0x00 30.                  "      ODIS   ,Output disable" "0,1"
  bitfld.long  0x00 28.--29.             "     ODISSL ,Output disable select" "0,1,2,3"
  bitfld.long  0x00 26.--27.             "  UCPRE  ,Prescaler" "1,2,3,4"
  bitfld.long  0x00 25.                  "  UCPREN ,Prescaler enable" "0,1"
  bitfld.long  0x00 24.                  "  DMA ,Direct memory access" "int,dma"
  TEXTLINE "                "
  bitfld.long  0x00 19.--22.             "  IF    ,Input filter" "byp.,02,04,res.,08,res.,res.,res.,16,res.,res.,res.,res.,res.,res.,res."
  bitfld.long  0x00 18.                  "   FCK    ,Filter clock select" "presc,main"
  bitfld.long  0x00 17.                  " FEN    ,FLAG enable" "0,1"
  bitfld.long  0x00 13.                  "  FORCMA ,Force match A" "0,1"
  bitfld.long  0x00 12.                  "  FORCMB ,Force match B" "0,1"
  bitfld.long  0x00 09.--10.             "  BSL ,Bus select" "all A,mix,res.,int"
  TEXTLINE "                "
  bitfld.long  0x00 08.                  "  EDSEL ,Edge selection bit" "single,both"
  bitfld.long  0x00 07.                  " EDPOL  ,Edge polarity" "fal.,ris."
  hexmask.byte 0x03 00.--06. 1.          "  MODE  ,Mode selection"
  
  
group.long (0xC3FA0000+0x0030+0x20*21.)++0x03
  line.long    0x00 "CSR21,eMIOS Channel Status Register"
  bitfld.long  0x00 31.                  "OVR   ,Overrun (w1c)" "0,1"
  bitfld.long  0x00 15.                  "      OVFL   ,Overflow (w1c)" "0,1"
  bitfld.long  0x00 02.                  "     UCIN   ,Unified channel input pin" "0,1"
  bitfld.long  0x00 01.                  "   UCOUT ,Unified channel output pin" "0,1"
  bitfld.long  0x00 00.                  "  FLAG   ,FLAG" "0,1"
  
TEXTLINE ""



wgroup.long (0xC3FA0000+0x0020+0x20*22.)++0x03
  hide.long    0x00 "CADR22,eMIOS Channel A Data Register (not displayed by debugger)"
  in

wgroup.long (0xC3FA0000+0x0024+0x20*22.)++0x03
  hide.long    0x00 "CBDR22,eMIOS Channel B Data Register (not displayed by debugger)"
  in
  
group.long (0xC3FA0000+0x0028+0x20*22.)++0x03
  line.long    0x00 "CCNTR22,eMIOS Channel Counter Register"
  
group.long (0xC3FA0000+0x002C+0x20*22.)++0x03
  line.long    0x00 "CCR22,eMIOS Channel Control Register"
  bitfld.long  0x00 31.                  "FREN  ,Freeze enable" "0,1"
  bitfld.long  0x00 30.                  "      ODIS   ,Output disable" "0,1"
  bitfld.long  0x00 28.--29.             "     ODISSL ,Output disable select" "0,1,2,3"
  bitfld.long  0x00 26.--27.             "  UCPRE  ,Prescaler" "1,2,3,4"
  bitfld.long  0x00 25.                  "  UCPREN ,Prescaler enable" "0,1"
  bitfld.long  0x00 24.                  "  DMA ,Direct memory access" "int,dma"
  TEXTLINE "                "
  bitfld.long  0x00 19.--22.             "  IF    ,Input filter" "byp.,02,04,res.,08,res.,res.,res.,16,res.,res.,res.,res.,res.,res.,res."
  bitfld.long  0x00 18.                  "   FCK    ,Filter clock select" "presc,main"
  bitfld.long  0x00 17.                  " FEN    ,FLAG enable" "0,1"
  bitfld.long  0x00 13.                  "  FORCMA ,Force match A" "0,1"
  bitfld.long  0x00 12.                  "  FORCMB ,Force match B" "0,1"
  bitfld.long  0x00 09.--10.             "  BSL ,Bus select" "all A,mix,res.,int"
  TEXTLINE "                "
  bitfld.long  0x00 08.                  "  EDSEL ,Edge selection bit" "single,both"
  bitfld.long  0x00 07.                  " EDPOL  ,Edge polarity" "fal.,ris."
  hexmask.byte 0x03 00.--06. 1.          "  MODE  ,Mode selection"
  
  
group.long (0xC3FA0000+0x0030+0x20*22.)++0x03
  line.long    0x00 "CSR22,eMIOS Channel Status Register"
  bitfld.long  0x00 31.                  "OVR   ,Overrun (w1c)" "0,1"
  bitfld.long  0x00 15.                  "      OVFL   ,Overflow (w1c)" "0,1"
  bitfld.long  0x00 02.                  "     UCIN   ,Unified channel input pin" "0,1"
  bitfld.long  0x00 01.                  "   UCOUT ,Unified channel output pin" "0,1"
  bitfld.long  0x00 00.                  "  FLAG   ,FLAG" "0,1"
  
TEXTLINE ""



wgroup.long (0xC3FA0000+0x0020+0x20*23.)++0x03
  hide.long    0x00 "CADR23,eMIOS Channel A Data Register (not displayed by debugger)"
  in

wgroup.long (0xC3FA0000+0x0024+0x20*23.)++0x03
  hide.long    0x00 "CBDR23,eMIOS Channel B Data Register (not displayed by debugger)"
  in
  
group.long (0xC3FA0000+0x0028+0x20*23.)++0x03
  line.long    0x00 "CCNTR23,eMIOS Channel Counter Register"
  
group.long (0xC3FA0000+0x002C+0x20*23.)++0x03
  line.long    0x00 "CCR23,eMIOS Channel Control Register"
  bitfld.long  0x00 31.                  "FREN  ,Freeze enable" "0,1"
  bitfld.long  0x00 30.                  "      ODIS   ,Output disable" "0,1"
  bitfld.long  0x00 28.--29.             "     ODISSL ,Output disable select" "0,1,2,3"
  bitfld.long  0x00 26.--27.             "  UCPRE  ,Prescaler" "1,2,3,4"
  bitfld.long  0x00 25.                  "  UCPREN ,Prescaler enable" "0,1"
  bitfld.long  0x00 24.                  "  DMA ,Direct memory access" "int,dma"
  TEXTLINE "                "
  bitfld.long  0x00 19.--22.             "  IF    ,Input filter" "byp.,02,04,res.,08,res.,res.,res.,16,res.,res.,res.,res.,res.,res.,res."
  bitfld.long  0x00 18.                  "   FCK    ,Filter clock select" "presc,main"
  bitfld.long  0x00 17.                  " FEN    ,FLAG enable" "0,1"
  bitfld.long  0x00 13.                  "  FORCMA ,Force match A" "0,1"
  bitfld.long  0x00 12.                  "  FORCMB ,Force match B" "0,1"
  bitfld.long  0x00 09.--10.             "  BSL ,Bus select" "all A,mix,res.,int"
  TEXTLINE "                "
  bitfld.long  0x00 08.                  "  EDSEL ,Edge selection bit" "single,both"
  bitfld.long  0x00 07.                  " EDPOL  ,Edge polarity" "fal.,ris."
  hexmask.byte 0x03 00.--06. 1.          "  MODE  ,Mode selection"
  
  
group.long (0xC3FA0000+0x0030+0x20*23.)++0x03
  line.long    0x00 "CSR23,eMIOS Channel Status Register"
  bitfld.long  0x00 31.                  "OVR   ,Overrun (w1c)" "0,1"
  bitfld.long  0x00 15.                  "      OVFL   ,Overflow (w1c)" "0,1"
  bitfld.long  0x00 02.                  "     UCIN   ,Unified channel input pin" "0,1"
  bitfld.long  0x00 01.                  "   UCOUT ,Unified channel output pin" "0,1"
  bitfld.long  0x00 00.                  "  FLAG   ,FLAG" "0,1"
  
TEXTLINE ""


endif

tree.end


tree.end

endif

sif CPUIS("MPC5674*")

tree "Enhanced Modular Input/Output Subsystem (eMIOS)"

group.long (0xC3FA0000+0x0000)++0x03
  line.long    0x00 "MCR,Module Configuration Register"
  bitfld.long  0x00 30.                  "MDIS ,Module disable" "0,1"
  bitfld.long  0x00 29.                  "  FRZ ,Freeze" "0,1"
  bitfld.long  0x00 28.                  "  GTBE ,Global time base enable" "0,1"
  bitfld.long  0x00 27.                  "  ETB ,External time base" "0,1"
  bitfld.long  0x00 26.                  "  GPREN ,Global prescaler enable" "0,1"
  bitfld.long  0x00 16.--19.             "  SRV ,Server time slot" "eTPU A-TCR1,eTPU B-TCR1,eTPU A-TCR2,eTPU B-TCR2,res(4),res(5),res(6),res(7),res(8),res(9),res(10),res(11),res(12),res(13),res(14),res(15)"
  hexmask.long.byte 0x00 08.--15. 1.     "  GPRE ,Global Prescaler"
  
TEXTLINE ""

group.long (0xC3FA0000+0x0004)++0x03
  line.long    0x00 "GFR,eMIOS Global Flag Register"
  bitfld.long  0x00 31.                    "F31-28  ,F31" "0,1"
  bitfld.long  0x00 30.                  ",F30" "0,1"
  bitfld.long  0x00 29.                  ",F29" "0,1"
  bitfld.long  0x00 28.                  ",F28" "0,1"

  bitfld.long  0x00 27.                  "  F27-24  ,F27" "0,1"
  bitfld.long  0x00 26.                  ",F26" "0,1"
  bitfld.long  0x00 25.                  ",F25" "0,1"
  bitfld.long  0x00 24.                  ",F24" "0,1"

  bitfld.long  0x00 23.                  "  F23-20  ,F23" "0,1"
  bitfld.long  0x00 22.                  ",F22" "0,1"
  bitfld.long  0x00 21.                  ",F21" "0,1"
  bitfld.long  0x00 20.                  ",F20" "0,1"

  bitfld.long  0x00 19.                  "  F19-16  ,F19" "0,1"
  bitfld.long  0x00 18.                  ",F18" "0,1"
  bitfld.long  0x00 17.                  ",F17" "0,1"
  bitfld.long  0x00 16.                  ",F16" "0,1"

  TEXTLINE "                "

  bitfld.long  0x00 15.                  "  F15-12  ,F15" "0,1"
  bitfld.long  0x00 14.                  ",F14" "0,1"
  bitfld.long  0x00 13.                  ",F13" "0,1"
  bitfld.long  0x00 12.                  ",F12" "0,1"

  bitfld.long  0x00 11.                  "  F11-08  ,F11" "0,1"
  bitfld.long  0x00 10.                  ",F10" "0,1"
  bitfld.long  0x00 09.                  ",F09" "0,1"
  bitfld.long  0x00 08.                  ",F08" "0,1"
 
  bitfld.long  0x00 07.                  "  F07-04  ,F07" "0,1"
  bitfld.long  0x00 06.                  ",F06" "0,1"
  bitfld.long  0x00 05.                  ",F05" "0,1"
  bitfld.long  0x00 04.                  ",F04" "0,1"

  bitfld.long  0x00 03.                  "  F03-00  ,F03" "0,1"
  bitfld.long  0x00 02.                  ",F02" "0,1"
  bitfld.long  0x00 01.                  ",F01" "0,1"
  bitfld.long  0x00 00.                  ",F00" "0,1"
TEXTLINE ""


group.long (0xC3FA0000+0x0008)++0x03
  line.long    0x00 "OUDR,eMIOS Output Update Disable Register"
  bitfld.long  0x00 31.                    "OU31-28 ,OU31" "0,1"
  bitfld.long  0x00 30.                  ",OU30" "0,1"
  bitfld.long  0x00 29.                  ",OU29" "0,1"
  bitfld.long  0x00 28.                  ",OU28" "0,1"

  bitfld.long  0x00 27.                  "  OU27-24 ,OU27" "0,1"
  bitfld.long  0x00 26.                  ",OU26" "0,1"
  bitfld.long  0x00 25.                  ",OU25" "0,1"
  bitfld.long  0x00 24.                  ",OU24" "0,1"

  bitfld.long  0x00 23.                  "  OU23-20 ,OU23" "0,1"
  bitfld.long  0x00 22.                  ",OU22" "0,1"
  bitfld.long  0x00 21.                  ",OU21" "0,1"
  bitfld.long  0x00 20.                  ",OU20" "0,1"

  bitfld.long  0x00 19.                  "  OU19-16 ,OU19" "0,1"
  bitfld.long  0x00 18.                  ",OU18" "0,1"
  bitfld.long  0x00 17.                  ",OU17" "0,1"
  bitfld.long  0x00 16.                  ",OU16" "0,1"

  TEXTLINE "                "

  bitfld.long  0x00 15.                  "  OU15-12 ,OU15" "0,1"
  bitfld.long  0x00 14.                  ",OU14" "0,1"
  bitfld.long  0x00 13.                  ",OU13" "0,1"
  bitfld.long  0x00 12.                  ",OU12" "0,1"

  bitfld.long  0x00 11.                  "  OU11-08 ,OU11" "0,1"
  bitfld.long  0x00 10.                  ",OU10" "0,1"
  bitfld.long  0x00 09.                  ",OU09" "0,1"
  bitfld.long  0x00 08.                  ",OU08" "0,1"
 
  bitfld.long  0x00 07.                  "  OU07-04 ,OU07" "0,1"
  bitfld.long  0x00 06.                  ",OU06" "0,1"
  bitfld.long  0x00 05.                  ",OU05" "0,1"
  bitfld.long  0x00 04.                  ",OU04" "0,1"

  bitfld.long  0x00 03.                  "  OU03-00 ,OU03" "0,1"
  bitfld.long  0x00 02.                  ",OU02" "0,1"
  bitfld.long  0x00 01.                  ",OU01" "0,1"
  bitfld.long  0x00 00.                  ",OU00" "0,1"
TEXTLINE ""


tree "Unified Channel Registers"

wgroup.long (0xC3FA0000+0x0020+0x20*0.)++0x03
  hide.long    0x00 "CADR0,eMIOS Channel A Data Register"
  in

wgroup.long (0xC3FA0000+0x0024+0x20*0.)++0x03
  hide.long    0x00 "CBDR0,eMIOS Channel B Data Register"
  in
  
group.long (0xC3FA0000+0x0028+0x20*0.)++0x03
  line.long    0x00 "CCNTR0,eMIOS Channel Counter Register"
  
group.long (0xC3FA0000+0x002C+0x20*0.)++0x03
  line.long    0x00 "CCR0,eMIOS Channel Control Register"
  bitfld.long  0x00 31.                  "FREN  ,Freeze enable" "0,1"
  bitfld.long  0x00 30.                  "      ODIS   ,Output disable" "0,1"
  bitfld.long  0x00 28.--29.             "     ODISSL ,Output disable select" "0,1,2,3"
  bitfld.long  0x00 26.--27.             "  UCPRE  ,Prescaler" "1,2,3,4"
  bitfld.long  0x00 25.                  "  UCPREN ,Prescaler enable" "0,1"
  bitfld.long  0x00 24.                  "  DMA ,Direct memory access" "int,dma"
  TEXTLINE "                "
  bitfld.long  0x00 19.--22.             "  IF    ,Input filter" "byp.,02,04,res.,08,res.,res.,res.,16,res.,res.,res.,res.,res.,res.,res."
  bitfld.long  0x00 18.                  "   FCK    ,Filter clock select" "presc,main"
  bitfld.long  0x00 17.                  " FEN    ,FLAG enable" "0,1"
  bitfld.long  0x00 13.                  "  FORCMA ,Force match A" "0,1"
  bitfld.long  0x00 12.                  "  FORCMB ,Force match B" "0,1"
  bitfld.long  0x00 09.--10.             "  BSL ,Bus select" "all A,mix,res.,int"
  TEXTLINE "                "
  bitfld.long  0x00 08.                  "  EDSEL ,Edge selection bit" "single,both"
  bitfld.long  0x00 07.                  " EDPOL  ,Edge polarity" "fal.,ris."
  hexmask.byte 0x03 00.--06. 1.          "  MODE  ,Mode selection"
  
  
group.long (0xC3FA0000+0x0030+0x20*0.)++0x03
  line.long    0x00 "CSR0,eMIOS Channel Status Register"
  eventfld.long  0x00 31.                  "OVR   ,Overrun (w1c)" "0,1"
  eventfld.long  0x00 15.                  "      OVFL   ,Overflow (w1c)" "0,1"
  bitfld.long  0x00 02.                  "     UCIN   ,Unified channel input pin" "0,1"
  bitfld.long  0x00 01.                  "   UCOUT ,Unified channel output pin" "0,1"
  eventfld.long  0x00 00.                  "  FLAG   ,FLAG" "0,1"
  
TEXTLINE ""



wgroup.long (0xC3FA0000+0x0020+0x20*1.)++0x03
  hide.long    0x00 "CADR1,eMIOS Channel A Data Register"
  in

wgroup.long (0xC3FA0000+0x0024+0x20*1.)++0x03
  hide.long    0x00 "CBDR1,eMIOS Channel B Data Register"
  in
  
group.long (0xC3FA0000+0x0028+0x20*1.)++0x03
  line.long    0x00 "CCNTR1,eMIOS Channel Counter Register"
  
group.long (0xC3FA0000+0x002C+0x20*1.)++0x03
  line.long    0x00 "CCR1,eMIOS Channel Control Register"
  bitfld.long  0x00 31.                  "FREN  ,Freeze enable" "0,1"
  bitfld.long  0x00 30.                  "      ODIS   ,Output disable" "0,1"
  bitfld.long  0x00 28.--29.             "     ODISSL ,Output disable select" "0,1,2,3"
  bitfld.long  0x00 26.--27.             "  UCPRE  ,Prescaler" "1,2,3,4"
  bitfld.long  0x00 25.                  "  UCPREN ,Prescaler enable" "0,1"
  bitfld.long  0x00 24.                  "  DMA ,Direct memory access" "int,dma"
  TEXTLINE "                "
  bitfld.long  0x00 19.--22.             "  IF    ,Input filter" "byp.,02,04,res.,08,res.,res.,res.,16,res.,res.,res.,res.,res.,res.,res."
  bitfld.long  0x00 18.                  "   FCK    ,Filter clock select" "presc,main"
  bitfld.long  0x00 17.                  " FEN    ,FLAG enable" "0,1"
  bitfld.long  0x00 13.                  "  FORCMA ,Force match A" "0,1"
  bitfld.long  0x00 12.                  "  FORCMB ,Force match B" "0,1"
  bitfld.long  0x00 09.--10.             "  BSL ,Bus select" "all A,mix,res.,int"
  TEXTLINE "                "
  bitfld.long  0x00 08.                  "  EDSEL ,Edge selection bit" "single,both"
  bitfld.long  0x00 07.                  " EDPOL  ,Edge polarity" "fal.,ris."
  hexmask.byte 0x03 00.--06. 1.          "  MODE  ,Mode selection"
  
  
group.long (0xC3FA0000+0x0030+0x20*1.)++0x03
  line.long    0x00 "CSR1,eMIOS Channel Status Register"
  eventfld.long  0x00 31.                  "OVR   ,Overrun (w1c)" "0,1"
  eventfld.long  0x00 15.                  "      OVFL   ,Overflow (w1c)" "0,1"
  bitfld.long  0x00 02.                  "     UCIN   ,Unified channel input pin" "0,1"
  bitfld.long  0x00 01.                  "   UCOUT ,Unified channel output pin" "0,1"
  eventfld.long  0x00 00.                  "  FLAG   ,FLAG" "0,1"
  
TEXTLINE ""



wgroup.long (0xC3FA0000+0x0020+0x20*2.)++0x03
  hide.long    0x00 "CADR2,eMIOS Channel A Data Register"
  in

wgroup.long (0xC3FA0000+0x0024+0x20*2.)++0x03
  hide.long    0x00 "CBDR2,eMIOS Channel B Data Register"
  in
  
group.long (0xC3FA0000+0x0028+0x20*2.)++0x03
  line.long    0x00 "CCNTR2,eMIOS Channel Counter Register"
  
group.long (0xC3FA0000+0x002C+0x20*2.)++0x03
  line.long    0x00 "CCR2,eMIOS Channel Control Register"
  bitfld.long  0x00 31.                  "FREN  ,Freeze enable" "0,1"
  bitfld.long  0x00 30.                  "      ODIS   ,Output disable" "0,1"
  bitfld.long  0x00 28.--29.             "     ODISSL ,Output disable select" "0,1,2,3"
  bitfld.long  0x00 26.--27.             "  UCPRE  ,Prescaler" "1,2,3,4"
  bitfld.long  0x00 25.                  "  UCPREN ,Prescaler enable" "0,1"
  bitfld.long  0x00 24.                  "  DMA ,Direct memory access" "int,dma"
  TEXTLINE "                "
  bitfld.long  0x00 19.--22.             "  IF    ,Input filter" "byp.,02,04,res.,08,res.,res.,res.,16,res.,res.,res.,res.,res.,res.,res."
  bitfld.long  0x00 18.                  "   FCK    ,Filter clock select" "presc,main"
  bitfld.long  0x00 17.                  " FEN    ,FLAG enable" "0,1"
  bitfld.long  0x00 13.                  "  FORCMA ,Force match A" "0,1"
  bitfld.long  0x00 12.                  "  FORCMB ,Force match B" "0,1"
  bitfld.long  0x00 09.--10.             "  BSL ,Bus select" "all A,mix,res.,int"
  TEXTLINE "                "
  bitfld.long  0x00 08.                  "  EDSEL ,Edge selection bit" "single,both"
  bitfld.long  0x00 07.                  " EDPOL  ,Edge polarity" "fal.,ris."
  hexmask.byte 0x03 00.--06. 1.          "  MODE  ,Mode selection"
  
  
group.long (0xC3FA0000+0x0030+0x20*2.)++0x03
  line.long    0x00 "CSR2,eMIOS Channel Status Register"
  eventfld.long  0x00 31.                  "OVR   ,Overrun (w1c)" "0,1"
  eventfld.long  0x00 15.                  "      OVFL   ,Overflow (w1c)" "0,1"
  bitfld.long  0x00 02.                  "     UCIN   ,Unified channel input pin" "0,1"
  bitfld.long  0x00 01.                  "   UCOUT ,Unified channel output pin" "0,1"
  eventfld.long  0x00 00.                  "  FLAG   ,FLAG" "0,1"
  
TEXTLINE ""



wgroup.long (0xC3FA0000+0x0020+0x20*3.)++0x03
  hide.long    0x00 "CADR3,eMIOS Channel A Data Register"
  in

wgroup.long (0xC3FA0000+0x0024+0x20*3.)++0x03
  hide.long    0x00 "CBDR3,eMIOS Channel B Data Register"
  in
  
group.long (0xC3FA0000+0x0028+0x20*3.)++0x03
  line.long    0x00 "CCNTR3,eMIOS Channel Counter Register"
  
group.long (0xC3FA0000+0x002C+0x20*3.)++0x03
  line.long    0x00 "CCR3,eMIOS Channel Control Register"
  bitfld.long  0x00 31.                  "FREN  ,Freeze enable" "0,1"
  bitfld.long  0x00 30.                  "      ODIS   ,Output disable" "0,1"
  bitfld.long  0x00 28.--29.             "     ODISSL ,Output disable select" "0,1,2,3"
  bitfld.long  0x00 26.--27.             "  UCPRE  ,Prescaler" "1,2,3,4"
  bitfld.long  0x00 25.                  "  UCPREN ,Prescaler enable" "0,1"
  bitfld.long  0x00 24.                  "  DMA ,Direct memory access" "int,dma"
  TEXTLINE "                "
  bitfld.long  0x00 19.--22.             "  IF    ,Input filter" "byp.,02,04,res.,08,res.,res.,res.,16,res.,res.,res.,res.,res.,res.,res."
  bitfld.long  0x00 18.                  "   FCK    ,Filter clock select" "presc,main"
  bitfld.long  0x00 17.                  " FEN    ,FLAG enable" "0,1"
  bitfld.long  0x00 13.                  "  FORCMA ,Force match A" "0,1"
  bitfld.long  0x00 12.                  "  FORCMB ,Force match B" "0,1"
  bitfld.long  0x00 09.--10.             "  BSL ,Bus select" "all A,mix,res.,int"
  TEXTLINE "                "
  bitfld.long  0x00 08.                  "  EDSEL ,Edge selection bit" "single,both"
  bitfld.long  0x00 07.                  " EDPOL  ,Edge polarity" "fal.,ris."
  hexmask.byte 0x03 00.--06. 1.          "  MODE  ,Mode selection"
  
  
group.long (0xC3FA0000+0x0030+0x20*3.)++0x03
  line.long    0x00 "CSR3,eMIOS Channel Status Register"
  eventfld.long  0x00 31.                  "OVR   ,Overrun (w1c)" "0,1"
  eventfld.long  0x00 15.                  "      OVFL   ,Overflow (w1c)" "0,1"
  bitfld.long  0x00 02.                  "     UCIN   ,Unified channel input pin" "0,1"
  bitfld.long  0x00 01.                  "   UCOUT ,Unified channel output pin" "0,1"
  eventfld.long  0x00 00.                  "  FLAG   ,FLAG" "0,1"
  
TEXTLINE ""



wgroup.long (0xC3FA0000+0x0020+0x20*4.)++0x03
  hide.long    0x00 "CADR4,eMIOS Channel A Data Register"
  in

wgroup.long (0xC3FA0000+0x0024+0x20*4.)++0x03
  hide.long    0x00 "CBDR4,eMIOS Channel B Data Register"
  in
  
group.long (0xC3FA0000+0x0028+0x20*4.)++0x03
  line.long    0x00 "CCNTR4,eMIOS Channel Counter Register"
  
group.long (0xC3FA0000+0x002C+0x20*4.)++0x03
  line.long    0x00 "CCR4,eMIOS Channel Control Register"
  bitfld.long  0x00 31.                  "FREN  ,Freeze enable" "0,1"
  bitfld.long  0x00 30.                  "      ODIS   ,Output disable" "0,1"
  bitfld.long  0x00 28.--29.             "     ODISSL ,Output disable select" "0,1,2,3"
  bitfld.long  0x00 26.--27.             "  UCPRE  ,Prescaler" "1,2,3,4"
  bitfld.long  0x00 25.                  "  UCPREN ,Prescaler enable" "0,1"
  bitfld.long  0x00 24.                  "  DMA ,Direct memory access" "int,dma"
  TEXTLINE "                "
  bitfld.long  0x00 19.--22.             "  IF    ,Input filter" "byp.,02,04,res.,08,res.,res.,res.,16,res.,res.,res.,res.,res.,res.,res."
  bitfld.long  0x00 18.                  "   FCK    ,Filter clock select" "presc,main"
  bitfld.long  0x00 17.                  " FEN    ,FLAG enable" "0,1"
  bitfld.long  0x00 13.                  "  FORCMA ,Force match A" "0,1"
  bitfld.long  0x00 12.                  "  FORCMB ,Force match B" "0,1"
  bitfld.long  0x00 09.--10.             "  BSL ,Bus select" "all A,mix,res.,int"
  TEXTLINE "                "
  bitfld.long  0x00 08.                  "  EDSEL ,Edge selection bit" "single,both"
  bitfld.long  0x00 07.                  " EDPOL  ,Edge polarity" "fal.,ris."
  hexmask.byte 0x03 00.--06. 1.          "  MODE  ,Mode selection"
  
  
group.long (0xC3FA0000+0x0030+0x20*4.)++0x03
  line.long    0x00 "CSR4,eMIOS Channel Status Register"
  eventfld.long  0x00 31.                  "OVR   ,Overrun (w1c)" "0,1"
  eventfld.long  0x00 15.                  "      OVFL   ,Overflow (w1c)" "0,1"
  bitfld.long  0x00 02.                  "     UCIN   ,Unified channel input pin" "0,1"
  bitfld.long  0x00 01.                  "   UCOUT ,Unified channel output pin" "0,1"
  eventfld.long  0x00 00.                  "  FLAG   ,FLAG" "0,1"
  
TEXTLINE ""



wgroup.long (0xC3FA0000+0x0020+0x20*5.)++0x03
  hide.long    0x00 "CADR5,eMIOS Channel A Data Register"
  in

wgroup.long (0xC3FA0000+0x0024+0x20*5.)++0x03
  hide.long    0x00 "CBDR5,eMIOS Channel B Data Register"
  in
  
group.long (0xC3FA0000+0x0028+0x20*5.)++0x03
  line.long    0x00 "CCNTR5,eMIOS Channel Counter Register"
  
group.long (0xC3FA0000+0x002C+0x20*5.)++0x03
  line.long    0x00 "CCR5,eMIOS Channel Control Register"
  bitfld.long  0x00 31.                  "FREN  ,Freeze enable" "0,1"
  bitfld.long  0x00 30.                  "      ODIS   ,Output disable" "0,1"
  bitfld.long  0x00 28.--29.             "     ODISSL ,Output disable select" "0,1,2,3"
  bitfld.long  0x00 26.--27.             "  UCPRE  ,Prescaler" "1,2,3,4"
  bitfld.long  0x00 25.                  "  UCPREN ,Prescaler enable" "0,1"
  bitfld.long  0x00 24.                  "  DMA ,Direct memory access" "int,dma"
  TEXTLINE "                "
  bitfld.long  0x00 19.--22.             "  IF    ,Input filter" "byp.,02,04,res.,08,res.,res.,res.,16,res.,res.,res.,res.,res.,res.,res."
  bitfld.long  0x00 18.                  "   FCK    ,Filter clock select" "presc,main"
  bitfld.long  0x00 17.                  " FEN    ,FLAG enable" "0,1"
  bitfld.long  0x00 13.                  "  FORCMA ,Force match A" "0,1"
  bitfld.long  0x00 12.                  "  FORCMB ,Force match B" "0,1"
  bitfld.long  0x00 09.--10.             "  BSL ,Bus select" "all A,mix,res.,int"
  TEXTLINE "                "
  bitfld.long  0x00 08.                  "  EDSEL ,Edge selection bit" "single,both"
  bitfld.long  0x00 07.                  " EDPOL  ,Edge polarity" "fal.,ris."
  hexmask.byte 0x03 00.--06. 1.          "  MODE  ,Mode selection"
  
  
group.long (0xC3FA0000+0x0030+0x20*5.)++0x03
  line.long    0x00 "CSR5,eMIOS Channel Status Register"
  eventfld.long  0x00 31.                  "OVR   ,Overrun (w1c)" "0,1"
  eventfld.long  0x00 15.                  "      OVFL   ,Overflow (w1c)" "0,1"
  bitfld.long  0x00 02.                  "     UCIN   ,Unified channel input pin" "0,1"
  bitfld.long  0x00 01.                  "   UCOUT ,Unified channel output pin" "0,1"
  eventfld.long  0x00 00.                  "  FLAG   ,FLAG" "0,1"
  
TEXTLINE ""



wgroup.long (0xC3FA0000+0x0020+0x20*6.)++0x03
  hide.long    0x00 "CADR6,eMIOS Channel A Data Register"
  in

wgroup.long (0xC3FA0000+0x0024+0x20*6.)++0x03
  hide.long    0x00 "CBDR6,eMIOS Channel B Data Register"
  in
  
group.long (0xC3FA0000+0x0028+0x20*6.)++0x03
  line.long    0x00 "CCNTR6,eMIOS Channel Counter Register"
  
group.long (0xC3FA0000+0x002C+0x20*6.)++0x03
  line.long    0x00 "CCR6,eMIOS Channel Control Register"
  bitfld.long  0x00 31.                  "FREN  ,Freeze enable" "0,1"
  bitfld.long  0x00 30.                  "      ODIS   ,Output disable" "0,1"
  bitfld.long  0x00 28.--29.             "     ODISSL ,Output disable select" "0,1,2,3"
  bitfld.long  0x00 26.--27.             "  UCPRE  ,Prescaler" "1,2,3,4"
  bitfld.long  0x00 25.                  "  UCPREN ,Prescaler enable" "0,1"
  bitfld.long  0x00 24.                  "  DMA ,Direct memory access" "int,dma"
  TEXTLINE "                "
  bitfld.long  0x00 19.--22.             "  IF    ,Input filter" "byp.,02,04,res.,08,res.,res.,res.,16,res.,res.,res.,res.,res.,res.,res."
  bitfld.long  0x00 18.                  "   FCK    ,Filter clock select" "presc,main"
  bitfld.long  0x00 17.                  " FEN    ,FLAG enable" "0,1"
  bitfld.long  0x00 13.                  "  FORCMA ,Force match A" "0,1"
  bitfld.long  0x00 12.                  "  FORCMB ,Force match B" "0,1"
  bitfld.long  0x00 09.--10.             "  BSL ,Bus select" "all A,mix,res.,int"
  TEXTLINE "                "
  bitfld.long  0x00 08.                  "  EDSEL ,Edge selection bit" "single,both"
  bitfld.long  0x00 07.                  " EDPOL  ,Edge polarity" "fal.,ris."
  hexmask.byte 0x03 00.--06. 1.          "  MODE  ,Mode selection"
  
  
group.long (0xC3FA0000+0x0030+0x20*6.)++0x03
  line.long    0x00 "CSR6,eMIOS Channel Status Register"
  eventfld.long  0x00 31.                  "OVR   ,Overrun (w1c)" "0,1"
  eventfld.long  0x00 15.                  "      OVFL   ,Overflow (w1c)" "0,1"
  bitfld.long  0x00 02.                  "     UCIN   ,Unified channel input pin" "0,1"
  bitfld.long  0x00 01.                  "   UCOUT ,Unified channel output pin" "0,1"
  eventfld.long  0x00 00.                  "  FLAG   ,FLAG" "0,1"
  
TEXTLINE ""



wgroup.long (0xC3FA0000+0x0020+0x20*7.)++0x03
  hide.long    0x00 "CADR7,eMIOS Channel A Data Register"
  in

wgroup.long (0xC3FA0000+0x0024+0x20*7.)++0x03
  hide.long    0x00 "CBDR7,eMIOS Channel B Data Register"
  in
  
group.long (0xC3FA0000+0x0028+0x20*7.)++0x03
  line.long    0x00 "CCNTR7,eMIOS Channel Counter Register"
  
group.long (0xC3FA0000+0x002C+0x20*7.)++0x03
  line.long    0x00 "CCR7,eMIOS Channel Control Register"
  bitfld.long  0x00 31.                  "FREN  ,Freeze enable" "0,1"
  bitfld.long  0x00 30.                  "      ODIS   ,Output disable" "0,1"
  bitfld.long  0x00 28.--29.             "     ODISSL ,Output disable select" "0,1,2,3"
  bitfld.long  0x00 26.--27.             "  UCPRE  ,Prescaler" "1,2,3,4"
  bitfld.long  0x00 25.                  "  UCPREN ,Prescaler enable" "0,1"
  bitfld.long  0x00 24.                  "  DMA ,Direct memory access" "int,dma"
  TEXTLINE "                "
  bitfld.long  0x00 19.--22.             "  IF    ,Input filter" "byp.,02,04,res.,08,res.,res.,res.,16,res.,res.,res.,res.,res.,res.,res."
  bitfld.long  0x00 18.                  "   FCK    ,Filter clock select" "presc,main"
  bitfld.long  0x00 17.                  " FEN    ,FLAG enable" "0,1"
  bitfld.long  0x00 13.                  "  FORCMA ,Force match A" "0,1"
  bitfld.long  0x00 12.                  "  FORCMB ,Force match B" "0,1"
  bitfld.long  0x00 09.--10.             "  BSL ,Bus select" "all A,mix,res.,int"
  TEXTLINE "                "
  bitfld.long  0x00 08.                  "  EDSEL ,Edge selection bit" "single,both"
  bitfld.long  0x00 07.                  " EDPOL  ,Edge polarity" "fal.,ris."
  hexmask.byte 0x03 00.--06. 1.          "  MODE  ,Mode selection"
  
  
group.long (0xC3FA0000+0x0030+0x20*7.)++0x03
  line.long    0x00 "CSR7,eMIOS Channel Status Register"
  eventfld.long  0x00 31.                  "OVR   ,Overrun (w1c)" "0,1"
  eventfld.long  0x00 15.                  "      OVFL   ,Overflow (w1c)" "0,1"
  bitfld.long  0x00 02.                  "     UCIN   ,Unified channel input pin" "0,1"
  bitfld.long  0x00 01.                  "   UCOUT ,Unified channel output pin" "0,1"
  eventfld.long  0x00 00.                  "  FLAG   ,FLAG" "0,1"
  
TEXTLINE ""



wgroup.long (0xC3FA0000+0x0020+0x20*8.)++0x03
  hide.long    0x00 "CADR8,eMIOS Channel A Data Register"
  in

wgroup.long (0xC3FA0000+0x0024+0x20*8.)++0x03
  hide.long    0x00 "CBDR8,eMIOS Channel B Data Register"
  in
  
group.long (0xC3FA0000+0x0028+0x20*8.)++0x03
  line.long    0x00 "CCNTR8,eMIOS Channel Counter Register"
  
group.long (0xC3FA0000+0x002C+0x20*8.)++0x03
  line.long    0x00 "CCR8,eMIOS Channel Control Register"
  bitfld.long  0x00 31.                  "FREN  ,Freeze enable" "0,1"
  bitfld.long  0x00 30.                  "      ODIS   ,Output disable" "0,1"
  bitfld.long  0x00 28.--29.             "     ODISSL ,Output disable select" "0,1,2,3"
  bitfld.long  0x00 26.--27.             "  UCPRE  ,Prescaler" "1,2,3,4"
  bitfld.long  0x00 25.                  "  UCPREN ,Prescaler enable" "0,1"
  bitfld.long  0x00 24.                  "  DMA ,Direct memory access" "int,dma"
  TEXTLINE "                "
  bitfld.long  0x00 19.--22.             "  IF    ,Input filter" "byp.,02,04,res.,08,res.,res.,res.,16,res.,res.,res.,res.,res.,res.,res."
  bitfld.long  0x00 18.                  "   FCK    ,Filter clock select" "presc,main"
  bitfld.long  0x00 17.                  " FEN    ,FLAG enable" "0,1"
  bitfld.long  0x00 13.                  "  FORCMA ,Force match A" "0,1"
  bitfld.long  0x00 12.                  "  FORCMB ,Force match B" "0,1"
  bitfld.long  0x00 09.--10.             "  BSL ,Bus select" "all A,mix,res.,int"
  TEXTLINE "                "
  bitfld.long  0x00 08.                  "  EDSEL ,Edge selection bit" "single,both"
  bitfld.long  0x00 07.                  " EDPOL  ,Edge polarity" "fal.,ris."
  hexmask.byte 0x03 00.--06. 1.          "  MODE  ,Mode selection"
  
  
group.long (0xC3FA0000+0x0030+0x20*8.)++0x03
  line.long    0x00 "CSR8,eMIOS Channel Status Register"
  eventfld.long  0x00 31.                  "OVR   ,Overrun (w1c)" "0,1"
  eventfld.long  0x00 15.                  "      OVFL   ,Overflow (w1c)" "0,1"
  bitfld.long  0x00 02.                  "     UCIN   ,Unified channel input pin" "0,1"
  bitfld.long  0x00 01.                  "   UCOUT ,Unified channel output pin" "0,1"
  eventfld.long  0x00 00.                  "  FLAG   ,FLAG" "0,1"
  
TEXTLINE ""



wgroup.long (0xC3FA0000+0x0020+0x20*9.)++0x03
  hide.long    0x00 "CADR9,eMIOS Channel A Data Register"
  in

wgroup.long (0xC3FA0000+0x0024+0x20*9.)++0x03
  hide.long    0x00 "CBDR9,eMIOS Channel B Data Register"
  in
  
group.long (0xC3FA0000+0x0028+0x20*9.)++0x03
  line.long    0x00 "CCNTR9,eMIOS Channel Counter Register"
  
group.long (0xC3FA0000+0x002C+0x20*9.)++0x03
  line.long    0x00 "CCR9,eMIOS Channel Control Register"
  bitfld.long  0x00 31.                  "FREN  ,Freeze enable" "0,1"
  bitfld.long  0x00 30.                  "      ODIS   ,Output disable" "0,1"
  bitfld.long  0x00 28.--29.             "     ODISSL ,Output disable select" "0,1,2,3"
  bitfld.long  0x00 26.--27.             "  UCPRE  ,Prescaler" "1,2,3,4"
  bitfld.long  0x00 25.                  "  UCPREN ,Prescaler enable" "0,1"
  bitfld.long  0x00 24.                  "  DMA ,Direct memory access" "int,dma"
  TEXTLINE "                "
  bitfld.long  0x00 19.--22.             "  IF    ,Input filter" "byp.,02,04,res.,08,res.,res.,res.,16,res.,res.,res.,res.,res.,res.,res."
  bitfld.long  0x00 18.                  "   FCK    ,Filter clock select" "presc,main"
  bitfld.long  0x00 17.                  " FEN    ,FLAG enable" "0,1"
  bitfld.long  0x00 13.                  "  FORCMA ,Force match A" "0,1"
  bitfld.long  0x00 12.                  "  FORCMB ,Force match B" "0,1"
  bitfld.long  0x00 09.--10.             "  BSL ,Bus select" "all A,mix,res.,int"
  TEXTLINE "                "
  bitfld.long  0x00 08.                  "  EDSEL ,Edge selection bit" "single,both"
  bitfld.long  0x00 07.                  " EDPOL  ,Edge polarity" "fal.,ris."
  hexmask.byte 0x03 00.--06. 1.          "  MODE  ,Mode selection"
  
  
group.long (0xC3FA0000+0x0030+0x20*9.)++0x03
  line.long    0x00 "CSR9,eMIOS Channel Status Register"
  eventfld.long  0x00 31.                  "OVR   ,Overrun (w1c)" "0,1"
  eventfld.long  0x00 15.                  "      OVFL   ,Overflow (w1c)" "0,1"
  bitfld.long  0x00 02.                  "     UCIN   ,Unified channel input pin" "0,1"
  bitfld.long  0x00 01.                  "   UCOUT ,Unified channel output pin" "0,1"
  eventfld.long  0x00 00.                  "  FLAG   ,FLAG" "0,1"
  
TEXTLINE ""



wgroup.long (0xC3FA0000+0x0020+0x20*10.)++0x03
  hide.long    0x00 "CADR10,eMIOS Channel A Data Register"
  in

wgroup.long (0xC3FA0000+0x0024+0x20*10.)++0x03
  hide.long    0x00 "CBDR10,eMIOS Channel B Data Register"
  in
  
group.long (0xC3FA0000+0x0028+0x20*10.)++0x03
  line.long    0x00 "CCNTR10,eMIOS Channel Counter Register"
  
group.long (0xC3FA0000+0x002C+0x20*10.)++0x03
  line.long    0x00 "CCR10,eMIOS Channel Control Register"
  bitfld.long  0x00 31.                  "FREN  ,Freeze enable" "0,1"
  bitfld.long  0x00 30.                  "      ODIS   ,Output disable" "0,1"
  bitfld.long  0x00 28.--29.             "     ODISSL ,Output disable select" "0,1,2,3"
  bitfld.long  0x00 26.--27.             "  UCPRE  ,Prescaler" "1,2,3,4"
  bitfld.long  0x00 25.                  "  UCPREN ,Prescaler enable" "0,1"
  bitfld.long  0x00 24.                  "  DMA ,Direct memory access" "int,dma"
  TEXTLINE "                "
  bitfld.long  0x00 19.--22.             "  IF    ,Input filter" "byp.,02,04,res.,08,res.,res.,res.,16,res.,res.,res.,res.,res.,res.,res."
  bitfld.long  0x00 18.                  "   FCK    ,Filter clock select" "presc,main"
  bitfld.long  0x00 17.                  " FEN    ,FLAG enable" "0,1"
  bitfld.long  0x00 13.                  "  FORCMA ,Force match A" "0,1"
  bitfld.long  0x00 12.                  "  FORCMB ,Force match B" "0,1"
  bitfld.long  0x00 09.--10.             "  BSL ,Bus select" "all A,mix,res.,int"
  TEXTLINE "                "
  bitfld.long  0x00 08.                  "  EDSEL ,Edge selection bit" "single,both"
  bitfld.long  0x00 07.                  " EDPOL  ,Edge polarity" "fal.,ris."
  hexmask.byte 0x03 00.--06. 1.          "  MODE  ,Mode selection"
  
  
group.long (0xC3FA0000+0x0030+0x20*10.)++0x03
  line.long    0x00 "CSR10,eMIOS Channel Status Register"
  eventfld.long  0x00 31.                  "OVR   ,Overrun (w1c)" "0,1"
  eventfld.long  0x00 15.                  "      OVFL   ,Overflow (w1c)" "0,1"
  bitfld.long  0x00 02.                  "     UCIN   ,Unified channel input pin" "0,1"
  bitfld.long  0x00 01.                  "   UCOUT ,Unified channel output pin" "0,1"
  eventfld.long  0x00 00.                  "  FLAG   ,FLAG" "0,1"
  
TEXTLINE ""



wgroup.long (0xC3FA0000+0x0020+0x20*11.)++0x03
  hide.long    0x00 "CADR11,eMIOS Channel A Data Register"
  in

wgroup.long (0xC3FA0000+0x0024+0x20*11.)++0x03
  hide.long    0x00 "CBDR11,eMIOS Channel B Data Register"
  in
  
group.long (0xC3FA0000+0x0028+0x20*11.)++0x03
  line.long    0x00 "CCNTR11,eMIOS Channel Counter Register"
  
group.long (0xC3FA0000+0x002C+0x20*11.)++0x03
  line.long    0x00 "CCR11,eMIOS Channel Control Register"
  bitfld.long  0x00 31.                  "FREN  ,Freeze enable" "0,1"
  bitfld.long  0x00 30.                  "      ODIS   ,Output disable" "0,1"
  bitfld.long  0x00 28.--29.             "     ODISSL ,Output disable select" "0,1,2,3"
  bitfld.long  0x00 26.--27.             "  UCPRE  ,Prescaler" "1,2,3,4"
  bitfld.long  0x00 25.                  "  UCPREN ,Prescaler enable" "0,1"
  bitfld.long  0x00 24.                  "  DMA ,Direct memory access" "int,dma"
  TEXTLINE "                "
  bitfld.long  0x00 19.--22.             "  IF    ,Input filter" "byp.,02,04,res.,08,res.,res.,res.,16,res.,res.,res.,res.,res.,res.,res."
  bitfld.long  0x00 18.                  "   FCK    ,Filter clock select" "presc,main"
  bitfld.long  0x00 17.                  " FEN    ,FLAG enable" "0,1"
  bitfld.long  0x00 13.                  "  FORCMA ,Force match A" "0,1"
  bitfld.long  0x00 12.                  "  FORCMB ,Force match B" "0,1"
  bitfld.long  0x00 09.--10.             "  BSL ,Bus select" "all A,mix,res.,int"
  TEXTLINE "                "
  bitfld.long  0x00 08.                  "  EDSEL ,Edge selection bit" "single,both"
  bitfld.long  0x00 07.                  " EDPOL  ,Edge polarity" "fal.,ris."
  hexmask.byte 0x03 00.--06. 1.          "  MODE  ,Mode selection"
  
  
group.long (0xC3FA0000+0x0030+0x20*11.)++0x03
  line.long    0x00 "CSR11,eMIOS Channel Status Register"
  eventfld.long  0x00 31.                  "OVR   ,Overrun (w1c)" "0,1"
  eventfld.long  0x00 15.                  "      OVFL   ,Overflow (w1c)" "0,1"
  bitfld.long  0x00 02.                  "     UCIN   ,Unified channel input pin" "0,1"
  bitfld.long  0x00 01.                  "   UCOUT ,Unified channel output pin" "0,1"
  eventfld.long  0x00 00.                  "  FLAG   ,FLAG" "0,1"
  
TEXTLINE ""



wgroup.long (0xC3FA0000+0x0020+0x20*12.)++0x03
  hide.long    0x00 "CADR12,eMIOS Channel A Data Register"
  in

wgroup.long (0xC3FA0000+0x0024+0x20*12.)++0x03
  hide.long    0x00 "CBDR12,eMIOS Channel B Data Register"
  in
  
group.long (0xC3FA0000+0x0028+0x20*12.)++0x03
  line.long    0x00 "CCNTR12,eMIOS Channel Counter Register"
  
group.long (0xC3FA0000+0x002C+0x20*12.)++0x03
  line.long    0x00 "CCR12,eMIOS Channel Control Register"
  bitfld.long  0x00 31.                  "FREN  ,Freeze enable" "0,1"
  bitfld.long  0x00 30.                  "      ODIS   ,Output disable" "0,1"
  bitfld.long  0x00 28.--29.             "     ODISSL ,Output disable select" "0,1,2,3"
  bitfld.long  0x00 26.--27.             "  UCPRE  ,Prescaler" "1,2,3,4"
  bitfld.long  0x00 25.                  "  UCPREN ,Prescaler enable" "0,1"
  bitfld.long  0x00 24.                  "  DMA ,Direct memory access" "int,dma"
  TEXTLINE "                "
  bitfld.long  0x00 19.--22.             "  IF    ,Input filter" "byp.,02,04,res.,08,res.,res.,res.,16,res.,res.,res.,res.,res.,res.,res."
  bitfld.long  0x00 18.                  "   FCK    ,Filter clock select" "presc,main"
  bitfld.long  0x00 17.                  " FEN    ,FLAG enable" "0,1"
  bitfld.long  0x00 13.                  "  FORCMA ,Force match A" "0,1"
  bitfld.long  0x00 12.                  "  FORCMB ,Force match B" "0,1"
  bitfld.long  0x00 09.--10.             "  BSL ,Bus select" "all A,mix,res.,int"
  TEXTLINE "                "
  bitfld.long  0x00 08.                  "  EDSEL ,Edge selection bit" "single,both"
  bitfld.long  0x00 07.                  " EDPOL  ,Edge polarity" "fal.,ris."
  hexmask.byte 0x03 00.--06. 1.          "  MODE  ,Mode selection"
  
  
group.long (0xC3FA0000+0x0030+0x20*12.)++0x03
  line.long    0x00 "CSR12,eMIOS Channel Status Register"
  eventfld.long  0x00 31.                  "OVR   ,Overrun (w1c)" "0,1"
  eventfld.long  0x00 15.                  "      OVFL   ,Overflow (w1c)" "0,1"
  bitfld.long  0x00 02.                  "     UCIN   ,Unified channel input pin" "0,1"
  bitfld.long  0x00 01.                  "   UCOUT ,Unified channel output pin" "0,1"
  eventfld.long  0x00 00.                  "  FLAG   ,FLAG" "0,1"
  
TEXTLINE ""



wgroup.long (0xC3FA0000+0x0020+0x20*13.)++0x03
  hide.long    0x00 "CADR13,eMIOS Channel A Data Register"
  in

wgroup.long (0xC3FA0000+0x0024+0x20*13.)++0x03
  hide.long    0x00 "CBDR13,eMIOS Channel B Data Register"
  in
  
group.long (0xC3FA0000+0x0028+0x20*13.)++0x03
  line.long    0x00 "CCNTR13,eMIOS Channel Counter Register"
  
group.long (0xC3FA0000+0x002C+0x20*13.)++0x03
  line.long    0x00 "CCR13,eMIOS Channel Control Register"
  bitfld.long  0x00 31.                  "FREN  ,Freeze enable" "0,1"
  bitfld.long  0x00 30.                  "      ODIS   ,Output disable" "0,1"
  bitfld.long  0x00 28.--29.             "     ODISSL ,Output disable select" "0,1,2,3"
  bitfld.long  0x00 26.--27.             "  UCPRE  ,Prescaler" "1,2,3,4"
  bitfld.long  0x00 25.                  "  UCPREN ,Prescaler enable" "0,1"
  bitfld.long  0x00 24.                  "  DMA ,Direct memory access" "int,dma"
  TEXTLINE "                "
  bitfld.long  0x00 19.--22.             "  IF    ,Input filter" "byp.,02,04,res.,08,res.,res.,res.,16,res.,res.,res.,res.,res.,res.,res."
  bitfld.long  0x00 18.                  "   FCK    ,Filter clock select" "presc,main"
  bitfld.long  0x00 17.                  " FEN    ,FLAG enable" "0,1"
  bitfld.long  0x00 13.                  "  FORCMA ,Force match A" "0,1"
  bitfld.long  0x00 12.                  "  FORCMB ,Force match B" "0,1"
  bitfld.long  0x00 09.--10.             "  BSL ,Bus select" "all A,mix,res.,int"
  TEXTLINE "                "
  bitfld.long  0x00 08.                  "  EDSEL ,Edge selection bit" "single,both"
  bitfld.long  0x00 07.                  " EDPOL  ,Edge polarity" "fal.,ris."
  hexmask.byte 0x03 00.--06. 1.          "  MODE  ,Mode selection"
  
  
group.long (0xC3FA0000+0x0030+0x20*13.)++0x03
  line.long    0x00 "CSR13,eMIOS Channel Status Register"
  eventfld.long  0x00 31.                  "OVR   ,Overrun (w1c)" "0,1"
  eventfld.long  0x00 15.                  "      OVFL   ,Overflow (w1c)" "0,1"
  bitfld.long  0x00 02.                  "     UCIN   ,Unified channel input pin" "0,1"
  bitfld.long  0x00 01.                  "   UCOUT ,Unified channel output pin" "0,1"
  eventfld.long  0x00 00.                  "  FLAG   ,FLAG" "0,1"
  
TEXTLINE ""



wgroup.long (0xC3FA0000+0x0020+0x20*14.)++0x03
  hide.long    0x00 "CADR14,eMIOS Channel A Data Register"
  in

wgroup.long (0xC3FA0000+0x0024+0x20*14.)++0x03
  hide.long    0x00 "CBDR14,eMIOS Channel B Data Register"
  in
  
group.long (0xC3FA0000+0x0028+0x20*14.)++0x03
  line.long    0x00 "CCNTR14,eMIOS Channel Counter Register"
  
group.long (0xC3FA0000+0x002C+0x20*14.)++0x03
  line.long    0x00 "CCR14,eMIOS Channel Control Register"
  bitfld.long  0x00 31.                  "FREN  ,Freeze enable" "0,1"
  bitfld.long  0x00 30.                  "      ODIS   ,Output disable" "0,1"
  bitfld.long  0x00 28.--29.             "     ODISSL ,Output disable select" "0,1,2,3"
  bitfld.long  0x00 26.--27.             "  UCPRE  ,Prescaler" "1,2,3,4"
  bitfld.long  0x00 25.                  "  UCPREN ,Prescaler enable" "0,1"
  bitfld.long  0x00 24.                  "  DMA ,Direct memory access" "int,dma"
  TEXTLINE "                "
  bitfld.long  0x00 19.--22.             "  IF    ,Input filter" "byp.,02,04,res.,08,res.,res.,res.,16,res.,res.,res.,res.,res.,res.,res."
  bitfld.long  0x00 18.                  "   FCK    ,Filter clock select" "presc,main"
  bitfld.long  0x00 17.                  " FEN    ,FLAG enable" "0,1"
  bitfld.long  0x00 13.                  "  FORCMA ,Force match A" "0,1"
  bitfld.long  0x00 12.                  "  FORCMB ,Force match B" "0,1"
  bitfld.long  0x00 09.--10.             "  BSL ,Bus select" "all A,mix,res.,int"
  TEXTLINE "                "
  bitfld.long  0x00 08.                  "  EDSEL ,Edge selection bit" "single,both"
  bitfld.long  0x00 07.                  " EDPOL  ,Edge polarity" "fal.,ris."
  hexmask.byte 0x03 00.--06. 1.          "  MODE  ,Mode selection"
  
  
group.long (0xC3FA0000+0x0030+0x20*14.)++0x03
  line.long    0x00 "CSR14,eMIOS Channel Status Register"
  eventfld.long  0x00 31.                  "OVR   ,Overrun (w1c)" "0,1"
  eventfld.long  0x00 15.                  "      OVFL   ,Overflow (w1c)" "0,1"
  bitfld.long  0x00 02.                  "     UCIN   ,Unified channel input pin" "0,1"
  bitfld.long  0x00 01.                  "   UCOUT ,Unified channel output pin" "0,1"
  eventfld.long  0x00 00.                  "  FLAG   ,FLAG" "0,1"
  
TEXTLINE ""



wgroup.long (0xC3FA0000+0x0020+0x20*15.)++0x03
  hide.long    0x00 "CADR15,eMIOS Channel A Data Register"
  in

wgroup.long (0xC3FA0000+0x0024+0x20*15.)++0x03
  hide.long    0x00 "CBDR15,eMIOS Channel B Data Register"
  in
  
group.long (0xC3FA0000+0x0028+0x20*15.)++0x03
  line.long    0x00 "CCNTR15,eMIOS Channel Counter Register"
  
group.long (0xC3FA0000+0x002C+0x20*15.)++0x03
  line.long    0x00 "CCR15,eMIOS Channel Control Register"
  bitfld.long  0x00 31.                  "FREN  ,Freeze enable" "0,1"
  bitfld.long  0x00 30.                  "      ODIS   ,Output disable" "0,1"
  bitfld.long  0x00 28.--29.             "     ODISSL ,Output disable select" "0,1,2,3"
  bitfld.long  0x00 26.--27.             "  UCPRE  ,Prescaler" "1,2,3,4"
  bitfld.long  0x00 25.                  "  UCPREN ,Prescaler enable" "0,1"
  bitfld.long  0x00 24.                  "  DMA ,Direct memory access" "int,dma"
  TEXTLINE "                "
  bitfld.long  0x00 19.--22.             "  IF    ,Input filter" "byp.,02,04,res.,08,res.,res.,res.,16,res.,res.,res.,res.,res.,res.,res."
  bitfld.long  0x00 18.                  "   FCK    ,Filter clock select" "presc,main"
  bitfld.long  0x00 17.                  " FEN    ,FLAG enable" "0,1"
  bitfld.long  0x00 13.                  "  FORCMA ,Force match A" "0,1"
  bitfld.long  0x00 12.                  "  FORCMB ,Force match B" "0,1"
  bitfld.long  0x00 09.--10.             "  BSL ,Bus select" "all A,mix,res.,int"
  TEXTLINE "                "
  bitfld.long  0x00 08.                  "  EDSEL ,Edge selection bit" "single,both"
  bitfld.long  0x00 07.                  " EDPOL  ,Edge polarity" "fal.,ris."
  hexmask.byte 0x03 00.--06. 1.          "  MODE  ,Mode selection"
  
  
group.long (0xC3FA0000+0x0030+0x20*15.)++0x03
  line.long    0x00 "CSR15,eMIOS Channel Status Register"
  eventfld.long  0x00 31.                  "OVR   ,Overrun (w1c)" "0,1"
  eventfld.long  0x00 15.                  "      OVFL   ,Overflow (w1c)" "0,1"
  bitfld.long  0x00 02.                  "     UCIN   ,Unified channel input pin" "0,1"
  bitfld.long  0x00 01.                  "   UCOUT ,Unified channel output pin" "0,1"
  eventfld.long  0x00 00.                  "  FLAG   ,FLAG" "0,1"
  
TEXTLINE ""



wgroup.long (0xC3FA0000+0x0020+0x20*16.)++0x03
  hide.long    0x00 "CADR16,eMIOS Channel A Data Register"
  in

wgroup.long (0xC3FA0000+0x0024+0x20*16.)++0x03
  hide.long    0x00 "CBDR16,eMIOS Channel B Data Register"
  in
  
group.long (0xC3FA0000+0x0028+0x20*16.)++0x03
  line.long    0x00 "CCNTR16,eMIOS Channel Counter Register"
  
group.long (0xC3FA0000+0x002C+0x20*16.)++0x03
  line.long    0x00 "CCR16,eMIOS Channel Control Register"
  bitfld.long  0x00 31.                  "FREN  ,Freeze enable" "0,1"
  bitfld.long  0x00 30.                  "      ODIS   ,Output disable" "0,1"
  bitfld.long  0x00 28.--29.             "     ODISSL ,Output disable select" "0,1,2,3"
  bitfld.long  0x00 26.--27.             "  UCPRE  ,Prescaler" "1,2,3,4"
  bitfld.long  0x00 25.                  "  UCPREN ,Prescaler enable" "0,1"
  bitfld.long  0x00 24.                  "  DMA ,Direct memory access" "int,dma"
  TEXTLINE "                "
  bitfld.long  0x00 19.--22.             "  IF    ,Input filter" "byp.,02,04,res.,08,res.,res.,res.,16,res.,res.,res.,res.,res.,res.,res."
  bitfld.long  0x00 18.                  "   FCK    ,Filter clock select" "presc,main"
  bitfld.long  0x00 17.                  " FEN    ,FLAG enable" "0,1"
  bitfld.long  0x00 13.                  "  FORCMA ,Force match A" "0,1"
  bitfld.long  0x00 12.                  "  FORCMB ,Force match B" "0,1"
  bitfld.long  0x00 09.--10.             "  BSL ,Bus select" "all A,mix,res.,int"
  TEXTLINE "                "
  bitfld.long  0x00 08.                  "  EDSEL ,Edge selection bit" "single,both"
  bitfld.long  0x00 07.                  " EDPOL  ,Edge polarity" "fal.,ris."
  hexmask.byte 0x03 00.--06. 1.          "  MODE  ,Mode selection"
  
  
group.long (0xC3FA0000+0x0030+0x20*16.)++0x03
  line.long    0x00 "CSR16,eMIOS Channel Status Register"
  eventfld.long  0x00 31.                  "OVR   ,Overrun (w1c)" "0,1"
  eventfld.long  0x00 15.                  "      OVFL   ,Overflow (w1c)" "0,1"
  bitfld.long  0x00 02.                  "     UCIN   ,Unified channel input pin" "0,1"
  bitfld.long  0x00 01.                  "   UCOUT ,Unified channel output pin" "0,1"
  eventfld.long  0x00 00.                  "  FLAG   ,FLAG" "0,1"
  
TEXTLINE ""



wgroup.long (0xC3FA0000+0x0020+0x20*17.)++0x03
  hide.long    0x00 "CADR17,eMIOS Channel A Data Register"
  in

wgroup.long (0xC3FA0000+0x0024+0x20*17.)++0x03
  hide.long    0x00 "CBDR17,eMIOS Channel B Data Register"
  in
  
group.long (0xC3FA0000+0x0028+0x20*17.)++0x03
  line.long    0x00 "CCNTR17,eMIOS Channel Counter Register"
  
group.long (0xC3FA0000+0x002C+0x20*17.)++0x03
  line.long    0x00 "CCR17,eMIOS Channel Control Register"
  bitfld.long  0x00 31.                  "FREN  ,Freeze enable" "0,1"
  bitfld.long  0x00 30.                  "      ODIS   ,Output disable" "0,1"
  bitfld.long  0x00 28.--29.             "     ODISSL ,Output disable select" "0,1,2,3"
  bitfld.long  0x00 26.--27.             "  UCPRE  ,Prescaler" "1,2,3,4"
  bitfld.long  0x00 25.                  "  UCPREN ,Prescaler enable" "0,1"
  bitfld.long  0x00 24.                  "  DMA ,Direct memory access" "int,dma"
  TEXTLINE "                "
  bitfld.long  0x00 19.--22.             "  IF    ,Input filter" "byp.,02,04,res.,08,res.,res.,res.,16,res.,res.,res.,res.,res.,res.,res."
  bitfld.long  0x00 18.                  "   FCK    ,Filter clock select" "presc,main"
  bitfld.long  0x00 17.                  " FEN    ,FLAG enable" "0,1"
  bitfld.long  0x00 13.                  "  FORCMA ,Force match A" "0,1"
  bitfld.long  0x00 12.                  "  FORCMB ,Force match B" "0,1"
  bitfld.long  0x00 09.--10.             "  BSL ,Bus select" "all A,mix,res.,int"
  TEXTLINE "                "
  bitfld.long  0x00 08.                  "  EDSEL ,Edge selection bit" "single,both"
  bitfld.long  0x00 07.                  " EDPOL  ,Edge polarity" "fal.,ris."
  hexmask.byte 0x03 00.--06. 1.          "  MODE  ,Mode selection"
  
  
group.long (0xC3FA0000+0x0030+0x20*17.)++0x03
  line.long    0x00 "CSR17,eMIOS Channel Status Register"
  eventfld.long  0x00 31.                  "OVR   ,Overrun (w1c)" "0,1"
  eventfld.long  0x00 15.                  "      OVFL   ,Overflow (w1c)" "0,1"
  bitfld.long  0x00 02.                  "     UCIN   ,Unified channel input pin" "0,1"
  bitfld.long  0x00 01.                  "   UCOUT ,Unified channel output pin" "0,1"
  eventfld.long  0x00 00.                  "  FLAG   ,FLAG" "0,1"
  
TEXTLINE ""



wgroup.long (0xC3FA0000+0x0020+0x20*18.)++0x03
  hide.long    0x00 "CADR18,eMIOS Channel A Data Register"
  in

wgroup.long (0xC3FA0000+0x0024+0x20*18.)++0x03
  hide.long    0x00 "CBDR18,eMIOS Channel B Data Register"
  in
  
group.long (0xC3FA0000+0x0028+0x20*18.)++0x03
  line.long    0x00 "CCNTR18,eMIOS Channel Counter Register"
  
group.long (0xC3FA0000+0x002C+0x20*18.)++0x03
  line.long    0x00 "CCR18,eMIOS Channel Control Register"
  bitfld.long  0x00 31.                  "FREN  ,Freeze enable" "0,1"
  bitfld.long  0x00 30.                  "      ODIS   ,Output disable" "0,1"
  bitfld.long  0x00 28.--29.             "     ODISSL ,Output disable select" "0,1,2,3"
  bitfld.long  0x00 26.--27.             "  UCPRE  ,Prescaler" "1,2,3,4"
  bitfld.long  0x00 25.                  "  UCPREN ,Prescaler enable" "0,1"
  bitfld.long  0x00 24.                  "  DMA ,Direct memory access" "int,dma"
  TEXTLINE "                "
  bitfld.long  0x00 19.--22.             "  IF    ,Input filter" "byp.,02,04,res.,08,res.,res.,res.,16,res.,res.,res.,res.,res.,res.,res."
  bitfld.long  0x00 18.                  "   FCK    ,Filter clock select" "presc,main"
  bitfld.long  0x00 17.                  " FEN    ,FLAG enable" "0,1"
  bitfld.long  0x00 13.                  "  FORCMA ,Force match A" "0,1"
  bitfld.long  0x00 12.                  "  FORCMB ,Force match B" "0,1"
  bitfld.long  0x00 09.--10.             "  BSL ,Bus select" "all A,mix,res.,int"
  TEXTLINE "                "
  bitfld.long  0x00 08.                  "  EDSEL ,Edge selection bit" "single,both"
  bitfld.long  0x00 07.                  " EDPOL  ,Edge polarity" "fal.,ris."
  hexmask.byte 0x03 00.--06. 1.          "  MODE  ,Mode selection"
  
  
group.long (0xC3FA0000+0x0030+0x20*18.)++0x03
  line.long    0x00 "CSR18,eMIOS Channel Status Register"
  eventfld.long  0x00 31.                  "OVR   ,Overrun (w1c)" "0,1"
  eventfld.long  0x00 15.                  "      OVFL   ,Overflow (w1c)" "0,1"
  bitfld.long  0x00 02.                  "     UCIN   ,Unified channel input pin" "0,1"
  bitfld.long  0x00 01.                  "   UCOUT ,Unified channel output pin" "0,1"
  eventfld.long  0x00 00.                  "  FLAG   ,FLAG" "0,1"
  
TEXTLINE ""



wgroup.long (0xC3FA0000+0x0020+0x20*19.)++0x03
  hide.long    0x00 "CADR19,eMIOS Channel A Data Register"
  in

wgroup.long (0xC3FA0000+0x0024+0x20*19.)++0x03
  hide.long    0x00 "CBDR19,eMIOS Channel B Data Register"
  in
  
group.long (0xC3FA0000+0x0028+0x20*19.)++0x03
  line.long    0x00 "CCNTR19,eMIOS Channel Counter Register"
  
group.long (0xC3FA0000+0x002C+0x20*19.)++0x03
  line.long    0x00 "CCR19,eMIOS Channel Control Register"
  bitfld.long  0x00 31.                  "FREN  ,Freeze enable" "0,1"
  bitfld.long  0x00 30.                  "      ODIS   ,Output disable" "0,1"
  bitfld.long  0x00 28.--29.             "     ODISSL ,Output disable select" "0,1,2,3"
  bitfld.long  0x00 26.--27.             "  UCPRE  ,Prescaler" "1,2,3,4"
  bitfld.long  0x00 25.                  "  UCPREN ,Prescaler enable" "0,1"
  bitfld.long  0x00 24.                  "  DMA ,Direct memory access" "int,dma"
  TEXTLINE "                "
  bitfld.long  0x00 19.--22.             "  IF    ,Input filter" "byp.,02,04,res.,08,res.,res.,res.,16,res.,res.,res.,res.,res.,res.,res."
  bitfld.long  0x00 18.                  "   FCK    ,Filter clock select" "presc,main"
  bitfld.long  0x00 17.                  " FEN    ,FLAG enable" "0,1"
  bitfld.long  0x00 13.                  "  FORCMA ,Force match A" "0,1"
  bitfld.long  0x00 12.                  "  FORCMB ,Force match B" "0,1"
  bitfld.long  0x00 09.--10.             "  BSL ,Bus select" "all A,mix,res.,int"
  TEXTLINE "                "
  bitfld.long  0x00 08.                  "  EDSEL ,Edge selection bit" "single,both"
  bitfld.long  0x00 07.                  " EDPOL  ,Edge polarity" "fal.,ris."
  hexmask.byte 0x03 00.--06. 1.          "  MODE  ,Mode selection"
  
  
group.long (0xC3FA0000+0x0030+0x20*19.)++0x03
  line.long    0x00 "CSR19,eMIOS Channel Status Register"
  eventfld.long  0x00 31.                  "OVR   ,Overrun (w1c)" "0,1"
  eventfld.long  0x00 15.                  "      OVFL   ,Overflow (w1c)" "0,1"
  bitfld.long  0x00 02.                  "     UCIN   ,Unified channel input pin" "0,1"
  bitfld.long  0x00 01.                  "   UCOUT ,Unified channel output pin" "0,1"
  eventfld.long  0x00 00.                  "  FLAG   ,FLAG" "0,1"
  
TEXTLINE ""



wgroup.long (0xC3FA0000+0x0020+0x20*20.)++0x03
  hide.long    0x00 "CADR20,eMIOS Channel A Data Register"
  in

wgroup.long (0xC3FA0000+0x0024+0x20*20.)++0x03
  hide.long    0x00 "CBDR20,eMIOS Channel B Data Register"
  in
  
group.long (0xC3FA0000+0x0028+0x20*20.)++0x03
  line.long    0x00 "CCNTR20,eMIOS Channel Counter Register"
  
group.long (0xC3FA0000+0x002C+0x20*20.)++0x03
  line.long    0x00 "CCR20,eMIOS Channel Control Register"
  bitfld.long  0x00 31.                  "FREN  ,Freeze enable" "0,1"
  bitfld.long  0x00 30.                  "      ODIS   ,Output disable" "0,1"
  bitfld.long  0x00 28.--29.             "     ODISSL ,Output disable select" "0,1,2,3"
  bitfld.long  0x00 26.--27.             "  UCPRE  ,Prescaler" "1,2,3,4"
  bitfld.long  0x00 25.                  "  UCPREN ,Prescaler enable" "0,1"
  bitfld.long  0x00 24.                  "  DMA ,Direct memory access" "int,dma"
  TEXTLINE "                "
  bitfld.long  0x00 19.--22.             "  IF    ,Input filter" "byp.,02,04,res.,08,res.,res.,res.,16,res.,res.,res.,res.,res.,res.,res."
  bitfld.long  0x00 18.                  "   FCK    ,Filter clock select" "presc,main"
  bitfld.long  0x00 17.                  " FEN    ,FLAG enable" "0,1"
  bitfld.long  0x00 13.                  "  FORCMA ,Force match A" "0,1"
  bitfld.long  0x00 12.                  "  FORCMB ,Force match B" "0,1"
  bitfld.long  0x00 09.--10.             "  BSL ,Bus select" "all A,mix,res.,int"
  TEXTLINE "                "
  bitfld.long  0x00 08.                  "  EDSEL ,Edge selection bit" "single,both"
  bitfld.long  0x00 07.                  " EDPOL  ,Edge polarity" "fal.,ris."
  hexmask.byte 0x03 00.--06. 1.          "  MODE  ,Mode selection"
  
  
group.long (0xC3FA0000+0x0030+0x20*20.)++0x03
  line.long    0x00 "CSR20,eMIOS Channel Status Register"
  eventfld.long  0x00 31.                  "OVR   ,Overrun (w1c)" "0,1"
  eventfld.long  0x00 15.                  "      OVFL   ,Overflow (w1c)" "0,1"
  bitfld.long  0x00 02.                  "     UCIN   ,Unified channel input pin" "0,1"
  bitfld.long  0x00 01.                  "   UCOUT ,Unified channel output pin" "0,1"
  eventfld.long  0x00 00.                  "  FLAG   ,FLAG" "0,1"
  
TEXTLINE ""



wgroup.long (0xC3FA0000+0x0020+0x20*21.)++0x03
  hide.long    0x00 "CADR21,eMIOS Channel A Data Register"
  in

wgroup.long (0xC3FA0000+0x0024+0x20*21.)++0x03
  hide.long    0x00 "CBDR21,eMIOS Channel B Data Register"
  in
  
group.long (0xC3FA0000+0x0028+0x20*21.)++0x03
  line.long    0x00 "CCNTR21,eMIOS Channel Counter Register"
  
group.long (0xC3FA0000+0x002C+0x20*21.)++0x03
  line.long    0x00 "CCR21,eMIOS Channel Control Register"
  bitfld.long  0x00 31.                  "FREN  ,Freeze enable" "0,1"
  bitfld.long  0x00 30.                  "      ODIS   ,Output disable" "0,1"
  bitfld.long  0x00 28.--29.             "     ODISSL ,Output disable select" "0,1,2,3"
  bitfld.long  0x00 26.--27.             "  UCPRE  ,Prescaler" "1,2,3,4"
  bitfld.long  0x00 25.                  "  UCPREN ,Prescaler enable" "0,1"
  bitfld.long  0x00 24.                  "  DMA ,Direct memory access" "int,dma"
  TEXTLINE "                "
  bitfld.long  0x00 19.--22.             "  IF    ,Input filter" "byp.,02,04,res.,08,res.,res.,res.,16,res.,res.,res.,res.,res.,res.,res."
  bitfld.long  0x00 18.                  "   FCK    ,Filter clock select" "presc,main"
  bitfld.long  0x00 17.                  " FEN    ,FLAG enable" "0,1"
  bitfld.long  0x00 13.                  "  FORCMA ,Force match A" "0,1"
  bitfld.long  0x00 12.                  "  FORCMB ,Force match B" "0,1"
  bitfld.long  0x00 09.--10.             "  BSL ,Bus select" "all A,mix,res.,int"
  TEXTLINE "                "
  bitfld.long  0x00 08.                  "  EDSEL ,Edge selection bit" "single,both"
  bitfld.long  0x00 07.                  " EDPOL  ,Edge polarity" "fal.,ris."
  hexmask.byte 0x03 00.--06. 1.          "  MODE  ,Mode selection"
  
  
group.long (0xC3FA0000+0x0030+0x20*21.)++0x03
  line.long    0x00 "CSR21,eMIOS Channel Status Register"
  eventfld.long  0x00 31.                  "OVR   ,Overrun (w1c)" "0,1"
  eventfld.long  0x00 15.                  "      OVFL   ,Overflow (w1c)" "0,1"
  bitfld.long  0x00 02.                  "     UCIN   ,Unified channel input pin" "0,1"
  bitfld.long  0x00 01.                  "   UCOUT ,Unified channel output pin" "0,1"
  eventfld.long  0x00 00.                  "  FLAG   ,FLAG" "0,1"
  
TEXTLINE ""



wgroup.long (0xC3FA0000+0x0020+0x20*22.)++0x03
  hide.long    0x00 "CADR22,eMIOS Channel A Data Register"
  in

wgroup.long (0xC3FA0000+0x0024+0x20*22.)++0x03
  hide.long    0x00 "CBDR22,eMIOS Channel B Data Register"
  in
  
group.long (0xC3FA0000+0x0028+0x20*22.)++0x03
  line.long    0x00 "CCNTR22,eMIOS Channel Counter Register"
  
group.long (0xC3FA0000+0x002C+0x20*22.)++0x03
  line.long    0x00 "CCR22,eMIOS Channel Control Register"
  bitfld.long  0x00 31.                  "FREN  ,Freeze enable" "0,1"
  bitfld.long  0x00 30.                  "      ODIS   ,Output disable" "0,1"
  bitfld.long  0x00 28.--29.             "     ODISSL ,Output disable select" "0,1,2,3"
  bitfld.long  0x00 26.--27.             "  UCPRE  ,Prescaler" "1,2,3,4"
  bitfld.long  0x00 25.                  "  UCPREN ,Prescaler enable" "0,1"
  bitfld.long  0x00 24.                  "  DMA ,Direct memory access" "int,dma"
  TEXTLINE "                "
  bitfld.long  0x00 19.--22.             "  IF    ,Input filter" "byp.,02,04,res.,08,res.,res.,res.,16,res.,res.,res.,res.,res.,res.,res."
  bitfld.long  0x00 18.                  "   FCK    ,Filter clock select" "presc,main"
  bitfld.long  0x00 17.                  " FEN    ,FLAG enable" "0,1"
  bitfld.long  0x00 13.                  "  FORCMA ,Force match A" "0,1"
  bitfld.long  0x00 12.                  "  FORCMB ,Force match B" "0,1"
  bitfld.long  0x00 09.--10.             "  BSL ,Bus select" "all A,mix,res.,int"
  TEXTLINE "                "
  bitfld.long  0x00 08.                  "  EDSEL ,Edge selection bit" "single,both"
  bitfld.long  0x00 07.                  " EDPOL  ,Edge polarity" "fal.,ris."
  hexmask.byte 0x03 00.--06. 1.          "  MODE  ,Mode selection"
  
  
group.long (0xC3FA0000+0x0030+0x20*22.)++0x03
  line.long    0x00 "CSR22,eMIOS Channel Status Register"
  eventfld.long  0x00 31.                  "OVR   ,Overrun (w1c)" "0,1"
  eventfld.long  0x00 15.                  "      OVFL   ,Overflow (w1c)" "0,1"
  bitfld.long  0x00 02.                  "     UCIN   ,Unified channel input pin" "0,1"
  bitfld.long  0x00 01.                  "   UCOUT ,Unified channel output pin" "0,1"
  eventfld.long  0x00 00.                  "  FLAG   ,FLAG" "0,1"
  
TEXTLINE ""



wgroup.long (0xC3FA0000+0x0020+0x20*23.)++0x03
  hide.long    0x00 "CADR23,eMIOS Channel A Data Register"
  in

wgroup.long (0xC3FA0000+0x0024+0x20*23.)++0x03
  hide.long    0x00 "CBDR23,eMIOS Channel B Data Register"
  in
  
group.long (0xC3FA0000+0x0028+0x20*23.)++0x03
  line.long    0x00 "CCNTR23,eMIOS Channel Counter Register"
  
group.long (0xC3FA0000+0x002C+0x20*23.)++0x03
  line.long    0x00 "CCR23,eMIOS Channel Control Register"
  bitfld.long  0x00 31.                  "FREN  ,Freeze enable" "0,1"
  bitfld.long  0x00 30.                  "      ODIS   ,Output disable" "0,1"
  bitfld.long  0x00 28.--29.             "     ODISSL ,Output disable select" "0,1,2,3"
  bitfld.long  0x00 26.--27.             "  UCPRE  ,Prescaler" "1,2,3,4"
  bitfld.long  0x00 25.                  "  UCPREN ,Prescaler enable" "0,1"
  bitfld.long  0x00 24.                  "  DMA ,Direct memory access" "int,dma"
  TEXTLINE "                "
  bitfld.long  0x00 19.--22.             "  IF    ,Input filter" "byp.,02,04,res.,08,res.,res.,res.,16,res.,res.,res.,res.,res.,res.,res."
  bitfld.long  0x00 18.                  "   FCK    ,Filter clock select" "presc,main"
  bitfld.long  0x00 17.                  " FEN    ,FLAG enable" "0,1"
  bitfld.long  0x00 13.                  "  FORCMA ,Force match A" "0,1"
  bitfld.long  0x00 12.                  "  FORCMB ,Force match B" "0,1"
  bitfld.long  0x00 09.--10.             "  BSL ,Bus select" "all A,mix,res.,int"
  TEXTLINE "                "
  bitfld.long  0x00 08.                  "  EDSEL ,Edge selection bit" "single,both"
  bitfld.long  0x00 07.                  " EDPOL  ,Edge polarity" "fal.,ris."
  hexmask.byte 0x03 00.--06. 1.          "  MODE  ,Mode selection"
  
  
group.long (0xC3FA0000+0x0030+0x20*23.)++0x03
  line.long    0x00 "CSR23,eMIOS Channel Status Register"
  eventfld.long  0x00 31.                  "OVR   ,Overrun (w1c)" "0,1"
  eventfld.long  0x00 15.                  "      OVFL   ,Overflow (w1c)" "0,1"
  bitfld.long  0x00 02.                  "     UCIN   ,Unified channel input pin" "0,1"
  bitfld.long  0x00 01.                  "   UCOUT ,Unified channel output pin" "0,1"
  eventfld.long  0x00 00.                  "  FLAG   ,FLAG" "0,1"
  
TEXTLINE ""



wgroup.long (0xC3FA0000+0x0020+0x20*24.)++0x03
  hide.long    0x00 "CADR24,eMIOS Channel A Data Register"
  in

wgroup.long (0xC3FA0000+0x0024+0x20*24.)++0x03
  hide.long    0x00 "CBDR24,eMIOS Channel B Data Register"
  in
  
group.long (0xC3FA0000+0x0028+0x20*24.)++0x03
  line.long    0x00 "CCNTR24,eMIOS Channel Counter Register"
  
group.long (0xC3FA0000+0x002C+0x20*24.)++0x03
  line.long    0x00 "CCR24,eMIOS Channel Control Register"
  bitfld.long  0x00 31.                  "FREN  ,Freeze enable" "0,1"
  bitfld.long  0x00 30.                  "      ODIS   ,Output disable" "0,1"
  bitfld.long  0x00 28.--29.             "     ODISSL ,Output disable select" "0,1,2,3"
  bitfld.long  0x00 26.--27.             "  UCPRE  ,Prescaler" "1,2,3,4"
  bitfld.long  0x00 25.                  "  UCPREN ,Prescaler enable" "0,1"
  bitfld.long  0x00 24.                  "  DMA ,Direct memory access" "int,dma"
  TEXTLINE "                "
  bitfld.long  0x00 19.--22.             "  IF    ,Input filter" "byp.,02,04,res.,08,res.,res.,res.,16,res.,res.,res.,res.,res.,res.,res."
  bitfld.long  0x00 18.                  "   FCK    ,Filter clock select" "presc,main"
  bitfld.long  0x00 17.                  " FEN    ,FLAG enable" "0,1"
  bitfld.long  0x00 13.                  "  FORCMA ,Force match A" "0,1"
  bitfld.long  0x00 12.                  "  FORCMB ,Force match B" "0,1"
  bitfld.long  0x00 09.--10.             "  BSL ,Bus select" "all A,mix,res.,int"
  TEXTLINE "                "
  bitfld.long  0x00 08.                  "  EDSEL ,Edge selection bit" "single,both"
  bitfld.long  0x00 07.                  " EDPOL  ,Edge polarity" "fal.,ris."
  hexmask.byte 0x03 00.--06. 1.          "  MODE  ,Mode selection"
  
  
group.long (0xC3FA0000+0x0030+0x20*24.)++0x03
  line.long    0x00 "CSR24,eMIOS Channel Status Register"
  eventfld.long  0x00 31.                  "OVR   ,Overrun (w1c)" "0,1"
  eventfld.long  0x00 15.                  "      OVFL   ,Overflow (w1c)" "0,1"
  bitfld.long  0x00 02.                  "     UCIN   ,Unified channel input pin" "0,1"
  bitfld.long  0x00 01.                  "   UCOUT ,Unified channel output pin" "0,1"
  eventfld.long  0x00 00.                  "  FLAG   ,FLAG" "0,1"
  
TEXTLINE ""



wgroup.long (0xC3FA0000+0x0020+0x20*25.)++0x03
  hide.long    0x00 "CADR25,eMIOS Channel A Data Register"
  in

wgroup.long (0xC3FA0000+0x0024+0x20*25.)++0x03
  hide.long    0x00 "CBDR25,eMIOS Channel B Data Register"
  in
  
group.long (0xC3FA0000+0x0028+0x20*25.)++0x03
  line.long    0x00 "CCNTR25,eMIOS Channel Counter Register"
  
group.long (0xC3FA0000+0x002C+0x20*25.)++0x03
  line.long    0x00 "CCR25,eMIOS Channel Control Register"
  bitfld.long  0x00 31.                  "FREN  ,Freeze enable" "0,1"
  bitfld.long  0x00 30.                  "      ODIS   ,Output disable" "0,1"
  bitfld.long  0x00 28.--29.             "     ODISSL ,Output disable select" "0,1,2,3"
  bitfld.long  0x00 26.--27.             "  UCPRE  ,Prescaler" "1,2,3,4"
  bitfld.long  0x00 25.                  "  UCPREN ,Prescaler enable" "0,1"
  bitfld.long  0x00 24.                  "  DMA ,Direct memory access" "int,dma"
  TEXTLINE "                "
  bitfld.long  0x00 19.--22.             "  IF    ,Input filter" "byp.,02,04,res.,08,res.,res.,res.,16,res.,res.,res.,res.,res.,res.,res."
  bitfld.long  0x00 18.                  "   FCK    ,Filter clock select" "presc,main"
  bitfld.long  0x00 17.                  " FEN    ,FLAG enable" "0,1"
  bitfld.long  0x00 13.                  "  FORCMA ,Force match A" "0,1"
  bitfld.long  0x00 12.                  "  FORCMB ,Force match B" "0,1"
  bitfld.long  0x00 09.--10.             "  BSL ,Bus select" "all A,mix,res.,int"
  TEXTLINE "                "
  bitfld.long  0x00 08.                  "  EDSEL ,Edge selection bit" "single,both"
  bitfld.long  0x00 07.                  " EDPOL  ,Edge polarity" "fal.,ris."
  hexmask.byte 0x03 00.--06. 1.          "  MODE  ,Mode selection"
  
  
group.long (0xC3FA0000+0x0030+0x20*25.)++0x03
  line.long    0x00 "CSR25,eMIOS Channel Status Register"
  eventfld.long  0x00 31.                  "OVR   ,Overrun (w1c)" "0,1"
  eventfld.long  0x00 15.                  "      OVFL   ,Overflow (w1c)" "0,1"
  bitfld.long  0x00 02.                  "     UCIN   ,Unified channel input pin" "0,1"
  bitfld.long  0x00 01.                  "   UCOUT ,Unified channel output pin" "0,1"
  eventfld.long  0x00 00.                  "  FLAG   ,FLAG" "0,1"
  
TEXTLINE ""



wgroup.long (0xC3FA0000+0x0020+0x20*26.)++0x03
  hide.long    0x00 "CADR26,eMIOS Channel A Data Register"
  in

wgroup.long (0xC3FA0000+0x0024+0x20*26.)++0x03
  hide.long    0x00 "CBDR26,eMIOS Channel B Data Register"
  in
  
group.long (0xC3FA0000+0x0028+0x20*26.)++0x03
  line.long    0x00 "CCNTR26,eMIOS Channel Counter Register"
  
group.long (0xC3FA0000+0x002C+0x20*26.)++0x03
  line.long    0x00 "CCR26,eMIOS Channel Control Register"
  bitfld.long  0x00 31.                  "FREN  ,Freeze enable" "0,1"
  bitfld.long  0x00 30.                  "      ODIS   ,Output disable" "0,1"
  bitfld.long  0x00 28.--29.             "     ODISSL ,Output disable select" "0,1,2,3"
  bitfld.long  0x00 26.--27.             "  UCPRE  ,Prescaler" "1,2,3,4"
  bitfld.long  0x00 25.                  "  UCPREN ,Prescaler enable" "0,1"
  bitfld.long  0x00 24.                  "  DMA ,Direct memory access" "int,dma"
  TEXTLINE "                "
  bitfld.long  0x00 19.--22.             "  IF    ,Input filter" "byp.,02,04,res.,08,res.,res.,res.,16,res.,res.,res.,res.,res.,res.,res."
  bitfld.long  0x00 18.                  "   FCK    ,Filter clock select" "presc,main"
  bitfld.long  0x00 17.                  " FEN    ,FLAG enable" "0,1"
  bitfld.long  0x00 13.                  "  FORCMA ,Force match A" "0,1"
  bitfld.long  0x00 12.                  "  FORCMB ,Force match B" "0,1"
  bitfld.long  0x00 09.--10.             "  BSL ,Bus select" "all A,mix,res.,int"
  TEXTLINE "                "
  bitfld.long  0x00 08.                  "  EDSEL ,Edge selection bit" "single,both"
  bitfld.long  0x00 07.                  " EDPOL  ,Edge polarity" "fal.,ris."
  hexmask.byte 0x03 00.--06. 1.          "  MODE  ,Mode selection"
  
  
group.long (0xC3FA0000+0x0030+0x20*26.)++0x03
  line.long    0x00 "CSR26,eMIOS Channel Status Register"
  eventfld.long  0x00 31.                  "OVR   ,Overrun (w1c)" "0,1"
  eventfld.long  0x00 15.                  "      OVFL   ,Overflow (w1c)" "0,1"
  bitfld.long  0x00 02.                  "     UCIN   ,Unified channel input pin" "0,1"
  bitfld.long  0x00 01.                  "   UCOUT ,Unified channel output pin" "0,1"
  eventfld.long  0x00 00.                  "  FLAG   ,FLAG" "0,1"
  
TEXTLINE ""



wgroup.long (0xC3FA0000+0x0020+0x20*27.)++0x03
  hide.long    0x00 "CADR27,eMIOS Channel A Data Register"
  in

wgroup.long (0xC3FA0000+0x0024+0x20*27.)++0x03
  hide.long    0x00 "CBDR27,eMIOS Channel B Data Register"
  in
  
group.long (0xC3FA0000+0x0028+0x20*27.)++0x03
  line.long    0x00 "CCNTR27,eMIOS Channel Counter Register"
  
group.long (0xC3FA0000+0x002C+0x20*27.)++0x03
  line.long    0x00 "CCR27,eMIOS Channel Control Register"
  bitfld.long  0x00 31.                  "FREN  ,Freeze enable" "0,1"
  bitfld.long  0x00 30.                  "      ODIS   ,Output disable" "0,1"
  bitfld.long  0x00 28.--29.             "     ODISSL ,Output disable select" "0,1,2,3"
  bitfld.long  0x00 26.--27.             "  UCPRE  ,Prescaler" "1,2,3,4"
  bitfld.long  0x00 25.                  "  UCPREN ,Prescaler enable" "0,1"
  bitfld.long  0x00 24.                  "  DMA ,Direct memory access" "int,dma"
  TEXTLINE "                "
  bitfld.long  0x00 19.--22.             "  IF    ,Input filter" "byp.,02,04,res.,08,res.,res.,res.,16,res.,res.,res.,res.,res.,res.,res."
  bitfld.long  0x00 18.                  "   FCK    ,Filter clock select" "presc,main"
  bitfld.long  0x00 17.                  " FEN    ,FLAG enable" "0,1"
  bitfld.long  0x00 13.                  "  FORCMA ,Force match A" "0,1"
  bitfld.long  0x00 12.                  "  FORCMB ,Force match B" "0,1"
  bitfld.long  0x00 09.--10.             "  BSL ,Bus select" "all A,mix,res.,int"
  TEXTLINE "                "
  bitfld.long  0x00 08.                  "  EDSEL ,Edge selection bit" "single,both"
  bitfld.long  0x00 07.                  " EDPOL  ,Edge polarity" "fal.,ris."
  hexmask.byte 0x03 00.--06. 1.          "  MODE  ,Mode selection"
  
  
group.long (0xC3FA0000+0x0030+0x20*27.)++0x03
  line.long    0x00 "CSR27,eMIOS Channel Status Register"
  eventfld.long  0x00 31.                  "OVR   ,Overrun (w1c)" "0,1"
  eventfld.long  0x00 15.                  "      OVFL   ,Overflow (w1c)" "0,1"
  bitfld.long  0x00 02.                  "     UCIN   ,Unified channel input pin" "0,1"
  bitfld.long  0x00 01.                  "   UCOUT ,Unified channel output pin" "0,1"
  eventfld.long  0x00 00.                  "  FLAG   ,FLAG" "0,1"
  
TEXTLINE ""



wgroup.long (0xC3FA0000+0x0020+0x20*28.)++0x03
  hide.long    0x00 "CADR28,eMIOS Channel A Data Register"
  in

wgroup.long (0xC3FA0000+0x0024+0x20*28.)++0x03
  hide.long    0x00 "CBDR28,eMIOS Channel B Data Register"
  in
  
group.long (0xC3FA0000+0x0028+0x20*28.)++0x03
  line.long    0x00 "CCNTR28,eMIOS Channel Counter Register"
  
group.long (0xC3FA0000+0x002C+0x20*28.)++0x03
  line.long    0x00 "CCR28,eMIOS Channel Control Register"
  bitfld.long  0x00 31.                  "FREN  ,Freeze enable" "0,1"
  bitfld.long  0x00 30.                  "      ODIS   ,Output disable" "0,1"
  bitfld.long  0x00 28.--29.             "     ODISSL ,Output disable select" "0,1,2,3"
  bitfld.long  0x00 26.--27.             "  UCPRE  ,Prescaler" "1,2,3,4"
  bitfld.long  0x00 25.                  "  UCPREN ,Prescaler enable" "0,1"
  bitfld.long  0x00 24.                  "  DMA ,Direct memory access" "int,dma"
  TEXTLINE "                "
  bitfld.long  0x00 19.--22.             "  IF    ,Input filter" "byp.,02,04,res.,08,res.,res.,res.,16,res.,res.,res.,res.,res.,res.,res."
  bitfld.long  0x00 18.                  "   FCK    ,Filter clock select" "presc,main"
  bitfld.long  0x00 17.                  " FEN    ,FLAG enable" "0,1"
  bitfld.long  0x00 13.                  "  FORCMA ,Force match A" "0,1"
  bitfld.long  0x00 12.                  "  FORCMB ,Force match B" "0,1"
  bitfld.long  0x00 09.--10.             "  BSL ,Bus select" "all A,mix,res.,int"
  TEXTLINE "                "
  bitfld.long  0x00 08.                  "  EDSEL ,Edge selection bit" "single,both"
  bitfld.long  0x00 07.                  " EDPOL  ,Edge polarity" "fal.,ris."
  hexmask.byte 0x03 00.--06. 1.          "  MODE  ,Mode selection"
  
  
group.long (0xC3FA0000+0x0030+0x20*28.)++0x03
  line.long    0x00 "CSR28,eMIOS Channel Status Register"
  eventfld.long  0x00 31.                  "OVR   ,Overrun (w1c)" "0,1"
  eventfld.long  0x00 15.                  "      OVFL   ,Overflow (w1c)" "0,1"
  bitfld.long  0x00 02.                  "     UCIN   ,Unified channel input pin" "0,1"
  bitfld.long  0x00 01.                  "   UCOUT ,Unified channel output pin" "0,1"
  eventfld.long  0x00 00.                  "  FLAG   ,FLAG" "0,1"
  
TEXTLINE ""



wgroup.long (0xC3FA0000+0x0020+0x20*29.)++0x03
  hide.long    0x00 "CADR29,eMIOS Channel A Data Register"
  in

wgroup.long (0xC3FA0000+0x0024+0x20*29.)++0x03
  hide.long    0x00 "CBDR29,eMIOS Channel B Data Register"
  in
  
group.long (0xC3FA0000+0x0028+0x20*29.)++0x03
  line.long    0x00 "CCNTR29,eMIOS Channel Counter Register"
  
group.long (0xC3FA0000+0x002C+0x20*29.)++0x03
  line.long    0x00 "CCR29,eMIOS Channel Control Register"
  bitfld.long  0x00 31.                  "FREN  ,Freeze enable" "0,1"
  bitfld.long  0x00 30.                  "      ODIS   ,Output disable" "0,1"
  bitfld.long  0x00 28.--29.             "     ODISSL ,Output disable select" "0,1,2,3"
  bitfld.long  0x00 26.--27.             "  UCPRE  ,Prescaler" "1,2,3,4"
  bitfld.long  0x00 25.                  "  UCPREN ,Prescaler enable" "0,1"
  bitfld.long  0x00 24.                  "  DMA ,Direct memory access" "int,dma"
  TEXTLINE "                "
  bitfld.long  0x00 19.--22.             "  IF    ,Input filter" "byp.,02,04,res.,08,res.,res.,res.,16,res.,res.,res.,res.,res.,res.,res."
  bitfld.long  0x00 18.                  "   FCK    ,Filter clock select" "presc,main"
  bitfld.long  0x00 17.                  " FEN    ,FLAG enable" "0,1"
  bitfld.long  0x00 13.                  "  FORCMA ,Force match A" "0,1"
  bitfld.long  0x00 12.                  "  FORCMB ,Force match B" "0,1"
  bitfld.long  0x00 09.--10.             "  BSL ,Bus select" "all A,mix,res.,int"
  TEXTLINE "                "
  bitfld.long  0x00 08.                  "  EDSEL ,Edge selection bit" "single,both"
  bitfld.long  0x00 07.                  " EDPOL  ,Edge polarity" "fal.,ris."
  hexmask.byte 0x03 00.--06. 1.          "  MODE  ,Mode selection"
  
  
group.long (0xC3FA0000+0x0030+0x20*29.)++0x03
  line.long    0x00 "CSR29,eMIOS Channel Status Register"
  eventfld.long  0x00 31.                  "OVR   ,Overrun (w1c)" "0,1"
  eventfld.long  0x00 15.                  "      OVFL   ,Overflow (w1c)" "0,1"
  bitfld.long  0x00 02.                  "     UCIN   ,Unified channel input pin" "0,1"
  bitfld.long  0x00 01.                  "   UCOUT ,Unified channel output pin" "0,1"
  eventfld.long  0x00 00.                  "  FLAG   ,FLAG" "0,1"
  
TEXTLINE ""



wgroup.long (0xC3FA0000+0x0020+0x20*30.)++0x03
  hide.long    0x00 "CADR30,eMIOS Channel A Data Register"
  in

wgroup.long (0xC3FA0000+0x0024+0x20*30.)++0x03
  hide.long    0x00 "CBDR30,eMIOS Channel B Data Register"
  in
  
group.long (0xC3FA0000+0x0028+0x20*30.)++0x03
  line.long    0x00 "CCNTR30,eMIOS Channel Counter Register"
  
group.long (0xC3FA0000+0x002C+0x20*30.)++0x03
  line.long    0x00 "CCR30,eMIOS Channel Control Register"
  bitfld.long  0x00 31.                  "FREN  ,Freeze enable" "0,1"
  bitfld.long  0x00 30.                  "      ODIS   ,Output disable" "0,1"
  bitfld.long  0x00 28.--29.             "     ODISSL ,Output disable select" "0,1,2,3"
  bitfld.long  0x00 26.--27.             "  UCPRE  ,Prescaler" "1,2,3,4"
  bitfld.long  0x00 25.                  "  UCPREN ,Prescaler enable" "0,1"
  bitfld.long  0x00 24.                  "  DMA ,Direct memory access" "int,dma"
  TEXTLINE "                "
  bitfld.long  0x00 19.--22.             "  IF    ,Input filter" "byp.,02,04,res.,08,res.,res.,res.,16,res.,res.,res.,res.,res.,res.,res."
  bitfld.long  0x00 18.                  "   FCK    ,Filter clock select" "presc,main"
  bitfld.long  0x00 17.                  " FEN    ,FLAG enable" "0,1"
  bitfld.long  0x00 13.                  "  FORCMA ,Force match A" "0,1"
  bitfld.long  0x00 12.                  "  FORCMB ,Force match B" "0,1"
  bitfld.long  0x00 09.--10.             "  BSL ,Bus select" "all A,mix,res.,int"
  TEXTLINE "                "
  bitfld.long  0x00 08.                  "  EDSEL ,Edge selection bit" "single,both"
  bitfld.long  0x00 07.                  " EDPOL  ,Edge polarity" "fal.,ris."
  hexmask.byte 0x03 00.--06. 1.          "  MODE  ,Mode selection"
  
  
group.long (0xC3FA0000+0x0030+0x20*30.)++0x03
  line.long    0x00 "CSR30,eMIOS Channel Status Register"
  eventfld.long  0x00 31.                  "OVR   ,Overrun (w1c)" "0,1"
  eventfld.long  0x00 15.                  "      OVFL   ,Overflow (w1c)" "0,1"
  bitfld.long  0x00 02.                  "     UCIN   ,Unified channel input pin" "0,1"
  bitfld.long  0x00 01.                  "   UCOUT ,Unified channel output pin" "0,1"
  eventfld.long  0x00 00.                  "  FLAG   ,FLAG" "0,1"
  
TEXTLINE ""



wgroup.long (0xC3FA0000+0x0020+0x20*31.)++0x03
  hide.long    0x00 "CADR31,eMIOS Channel A Data Register"
  in

wgroup.long (0xC3FA0000+0x0024+0x20*31.)++0x03
  hide.long    0x00 "CBDR31,eMIOS Channel B Data Register"
  in
  
group.long (0xC3FA0000+0x0028+0x20*31.)++0x03
  line.long    0x00 "CCNTR31,eMIOS Channel Counter Register"
  
group.long (0xC3FA0000+0x002C+0x20*31.)++0x03
  line.long    0x00 "CCR31,eMIOS Channel Control Register"
  bitfld.long  0x00 31.                  "FREN  ,Freeze enable" "0,1"
  bitfld.long  0x00 30.                  "      ODIS   ,Output disable" "0,1"
  bitfld.long  0x00 28.--29.             "     ODISSL ,Output disable select" "0,1,2,3"
  bitfld.long  0x00 26.--27.             "  UCPRE  ,Prescaler" "1,2,3,4"
  bitfld.long  0x00 25.                  "  UCPREN ,Prescaler enable" "0,1"
  bitfld.long  0x00 24.                  "  DMA ,Direct memory access" "int,dma"
  TEXTLINE "                "
  bitfld.long  0x00 19.--22.             "  IF    ,Input filter" "byp.,02,04,res.,08,res.,res.,res.,16,res.,res.,res.,res.,res.,res.,res."
  bitfld.long  0x00 18.                  "   FCK    ,Filter clock select" "presc,main"
  bitfld.long  0x00 17.                  " FEN    ,FLAG enable" "0,1"
  bitfld.long  0x00 13.                  "  FORCMA ,Force match A" "0,1"
  bitfld.long  0x00 12.                  "  FORCMB ,Force match B" "0,1"
  bitfld.long  0x00 09.--10.             "  BSL ,Bus select" "all A,mix,res.,int"
  TEXTLINE "                "
  bitfld.long  0x00 08.                  "  EDSEL ,Edge selection bit" "single,both"
  bitfld.long  0x00 07.                  " EDPOL  ,Edge polarity" "fal.,ris."
  hexmask.byte 0x03 00.--06. 1.          "  MODE  ,Mode selection"
  
  
group.long (0xC3FA0000+0x0030+0x20*31.)++0x03
  line.long    0x00 "CSR31,eMIOS Channel Status Register"
  eventfld.long  0x00 31.                  "OVR   ,Overrun (w1c)" "0,1"
  eventfld.long  0x00 15.                  "      OVFL   ,Overflow (w1c)" "0,1"
  bitfld.long  0x00 02.                  "     UCIN   ,Unified channel input pin" "0,1"
  bitfld.long  0x00 01.                  "   UCOUT ,Unified channel output pin" "0,1"
  eventfld.long  0x00 00.                  "  FLAG   ,FLAG" "0,1"
  
TEXTLINE ""


tree.end


tree.end

endif


sif (cpu()=="MPC5633M")||(cpu()=="MPC5634M")||(cpu()=="SPC563M60")||(cpu()=="SPC563M64")||(CPUIS("MPC5674*"))

tree "Periodic Interval Timer (PIT)"

group.long 0xC3FF0000++0x03
  line.long    0x00 "PITMCR,PIT Module Control"


tree "RTI Channel  "

group.long (0xC3FF00F0+0x0000)++0x03
  line.long    0x00 "TLVAL ,Timer Load Value Register"
  
group.long (0xC3FF00F0+0x0004)++0x03
  line.long    0x00 "CVAL ,Current Timer Value Register"

group.long (0xC3FF00F0+0x0008)++0x03
  line.long    0x00 "TCRTL ,Timer Load Value Register"
  
group.long (0xC3FF00F0+0x000c)++0x03
  line.long    0x00 "TFLG ,Current Timer Value Register"

tree.end

tree "PIT Channel 0"

group.long (0xC3FF0100+0x0000)++0x03
  line.long    0x00 "TLVAL0,Timer Load Value Register"
  
group.long (0xC3FF0100+0x0004)++0x03
  line.long    0x00 "CVAL0,Current Timer Value Register"

group.long (0xC3FF0100+0x0008)++0x03
  line.long    0x00 "TCRTL0,Timer Load Value Register"
  
group.long (0xC3FF0100+0x000c)++0x03
  line.long    0x00 "TFLG0,Current Timer Value Register"

tree.end

tree "PIT Channel 1"

group.long (0xC3FF0110+0x0000)++0x03
  line.long    0x00 "TLVAL1,Timer Load Value Register"
  
group.long (0xC3FF0110+0x0004)++0x03
  line.long    0x00 "CVAL1,Current Timer Value Register"

group.long (0xC3FF0110+0x0008)++0x03
  line.long    0x00 "TCRTL1,Timer Load Value Register"
  
group.long (0xC3FF0110+0x000c)++0x03
  line.long    0x00 "TFLG1,Current Timer Value Register"

tree.end

tree "PIT Channel 2"

group.long (0xC3FF0120+0x0000)++0x03
  line.long    0x00 "TLVAL2,Timer Load Value Register"
  
group.long (0xC3FF0120+0x0004)++0x03
  line.long    0x00 "CVAL2,Current Timer Value Register"

group.long (0xC3FF0120+0x0008)++0x03
  line.long    0x00 "TCRTL2,Timer Load Value Register"
  
group.long (0xC3FF0120+0x000c)++0x03
  line.long    0x00 "TFLG2,Current Timer Value Register"

tree.end

tree "PIT Channel 3"

group.long (0xC3FF0130+0x0000)++0x03
  line.long    0x00 "TLVAL3,Timer Load Value Register"
  
group.long (0xC3FF0130+0x0004)++0x03
  line.long    0x00 "CVAL3,Current Timer Value Register"

group.long (0xC3FF0130+0x0008)++0x03
  line.long    0x00 "TCRTL3,Timer Load Value Register"
  
group.long (0xC3FF0130+0x000c)++0x03
  line.long    0x00 "TFLG3,Current Timer Value Register"

tree.end

tree.end


tree "System Timer Module (STM)"

group.long 0xFFF3C000++0x03
  line.long    0x00 "STM_CR,STM Control Register"

group.long 0xFFF3C004++0x03
  line.long    0x00 "STM_CNT,STM Counter Value"

tree "Channel 0"

group.long (0xFFF3C010+0x00)++0x03
  line.long    0x00 "STM_CCR0,STM Channel 0 Control Register"

group.long (0xFFF3C010+0x04)++0x03
  line.long    0x00 "STM_CIR0,STM Channel 0 Interrupt Register"

group.long (0xFFF3C010+0x08)++0x03
  line.long    0x00 "STM_CMP0,STM Channel 0 Compare Register"

tree.end

tree "Channel 1"

group.long (0xFFF3C020+0x00)++0x03
  line.long    0x00 "STM_CCR1,STM Channel 1 Control Register"

group.long (0xFFF3C020+0x04)++0x03
  line.long    0x00 "STM_CIR1,STM Channel 1 Interrupt Register"

group.long (0xFFF3C020+0x08)++0x03
  line.long    0x00 "STM_CMP1,STM Channel 1 Compare Register"

tree.end

tree "Channel 2"

group.long (0xFFF3C030+0x00)++0x03
  line.long    0x00 "STM_CCR2,STM Channel 2 Control Register"

group.long (0xFFF3C030+0x04)++0x03
  line.long    0x00 "STM_CIR2,STM Channel 2 Interrupt Register"

group.long (0xFFF3C030+0x08)++0x03
  line.long    0x00 "STM_CMP2,STM Channel 2 Compare Register"

tree.end

tree "Channel 3"

group.long (0xFFF3C040+0x00)++0x03
  line.long    0x00 "STM_CCR3,STM Channel 3 Control Register"

group.long (0xFFF3C040+0x04)++0x03
  line.long    0x00 "STM_CIR3,STM Channel 3 Interrupt Register"

group.long (0xFFF3C040+0x08)++0x03
  line.long    0x00 "STM_CMP3,STM Channel 3 Compare Register"

tree.end


tree.end
tree "Software Watchdog Timer (SWT)"

group.long 0xFFF38000++0x03
  line.long    0 "SWT_CR,SWT Control Register"
  bitfld.long  0x00 31.                    "MAP0  ,Master Access Protection for Master 0" "0,1"
  bitfld.long  0x00 30.                  "  MAP1  ,Master Access Protection for Master 1" "0,1"
  bitfld.long  0x00 29.                  "  MAP2  ,Master Access Protection for Master 2" "0,1"
  bitfld.long  0x00 28.                  "  MAP3  ,Master Access Protection for Master 3" "0,1"
  bitfld.long  0x00 27.                  "  MAP4  ,Master Access Protection for Master 4" "0,1"
  bitfld.long  0x00 26.                  "  MAP5  ,Master Access Protection for Master 5" "0,1"
  bitfld.long  0x00 25.                  "  MAP6  ,Master Access Protection for Master 6" "0,1"
  bitfld.long  0x00 24.                  "  MAP7  ,Master Access Protection for Master 7" "0,1"
  TEXTLINE "                "
  bitfld.long  0x00 8.           "  RIA   ,Reset on invalid access" "0,1"
  bitfld.long  0x00 7.           "  WND   ,Window mode" "0,1"
  bitfld.long  0x00 6.           "  ITR   ,Interrupt then reset" "0,1"
  bitfld.long  0x00 5.           "  HLK   ,Hard lock. This bit is only cleared at reset" "0,1"
  bitfld.long  0x00 4.           "  SLK   ,Soft lock. This bit is cleared by writing the unlock sequence to the service register" "0,1"
  TEXTLINE "                "
  bitfld.long  0x00 3.           "  CSL   ,Clock selection" "system clock,oscillator clock"
  bitfld.long  0x00 2.           "     STP   ,Stop mode control" "0,1"
  bitfld.long  0x00 1.           "  FRZ   ,Debug mode control" "0,1"
  bitfld.long  0x00 0.           "  WEN   ,Watchdog enable" "0,1"
  TEXTLINE "                "

group.long 0xFFF38004++0x03
  line.long    0 "SWT_IR,SWT Interrupt Register"
  bitfld.long  0x00 0.             "TIF   ,Time-out interrupt flag" "0,1"
  TEXTLINE "                "

group.long 0xFFF38008++0x03
  line.long    0 "SWT_TO,SWT Time-out Register"

group.long 0xFFF3800C++0x03
  line.long    0 "SWT_WN,SWT Window Register"

group.long 0xFFF38010++0x03
  line.long    0 "SWT_SR,SWT Service Register"

group.long 0xFFF38014++0x03
  line.long    0 "SWT_CO,SWT Counter Output Register"

tree.end
endif

sif (cpu()=="MPC5533")||(cpu()=="MPC5534")||(cpu()=="MPC5553")||(cpu()=="MPC5554")||(cpu()=="MPC5565")||(cpu()=="MPC5566")||(cpu()=="MPC5567")||(cpu()=="MPC5633M")||(cpu()=="MPC5634M")||(cpu()=="SPC563M60")||(cpu()=="SPC563M64")||(CPUIS("MPC5674*"))
    tree "Enhanced Time Processing Unit (eTPU)"
width 12.
config 12. 8.

group.long (0xC3FC0000)++0x03
  line.long    0x00 "MCR,Module Configuration Register"
  bitfld.long  0x00 31.                  "GEC      ,Global exception clear" "0,1"
  bitfld.long  0x00 27.                  "  MGEA    ,Microcode global exception engine A" "0,1"
  bitfld.long  0x00 26.                  "  MGEB      ,Microcode global exception engine B" "0,1"
  bitfld.long  0x00 25.                  "  ILFA ,Illegal instruction flag eTPU A" "0,1"
  bitfld.long  0x00 24.                  "  ILFB ,Illegal instruction flag eTPU B" "0,1"
TEXTLINE "                   "
  hexmask.long.byte 0x00 16.--20. 1.          "  SCMSIZE ,SCM size. Holds the number of 2 Kbyte SCM Blocks minus 1"
  bitfld.long  0x00 10.                  "  SCMMISF ,SCM MISC Flag" "0,1"
  bitfld.long  0x00 09.                  "  SCMMISEN  ,SCM MISC enable" "0,1"
  bitfld.long  0x00 06.                  "  VIS  ,SCM visibility" "0,1"
  bitfld.long  0x00 00.                  "  GTBE ,Global time base enable" "0,1"
TEXTLINE ""

group.long (0xC3FC0004)++0x03
  line.long    0x00 "CDCR,eTPU Coherent Dual-Parameter Controller Register"
  bitfld.long  0x00 31.                  "STS      ,Start" "0,1"
  hexmask.long.byte 0x00 26.--30. 1.          "  CTBASE ,Channel transfer base address"
  hexmask.long.word 0x00 16.--25. 1.          "  PBBASE ,Parameter buffer base address"
  bitfld.long  0x00 15.                  "  PWIDTH ,Parameter width selection" "24 bit,32 bit"
TEXTLINE "                   "
  hexmask.long.byte 0x00 08.--14. 1.          "  PARM0   ,Channel Parameter number 0"
  bitfld.long  0x00 07.                  "  WR      ,Read/Write selection." "W,R"
  hexmask.long.byte 0x00 00.--06. 1.          "  PARM1    ,Channel Parameter number 1"

group.long (0xC3FC000C)++0x03
  line.long    0x00 "MISCCMPR,eTPU MISC Compare Register"

group.long (0xC3FC0010)++0x03
  line.long    0x00 "SCMOFFDATAR,eTPU SCM Off-Range Data Register"

width 9.
config 9. 8.



tree "eTPU A Registers"

group.long (0xC3FC0014+0)++0x03
  line.long    0x00 "ECR,eTPU A Engine Configuration Register"
  bitfld.long  0x00 31.                  "FEND ,Force end" "0,1"
  bitfld.long  0x00 30.                  "  MDIS ,Module disable internal stop" "0,1"
  bitfld.long  0x00 28.                  "  STF ,Stop flag bit" "0,1"
  bitfld.long  0x00 23.                  "  HLTF ,Halt mode flag" "0,1"
  bitfld.long  0x00 16.--18.             "  FPSCK ,Filter prescaler clock control" "2,4,8,16,32,64,128,256"
  bitfld.long  0x00 14.--15.             "  CDFC ,Channel digital filter control" "TPU2/3,res.,3 sample,cont.,"
  bitfld.long  0x00 00.--04.             "  ETB ,Entry table base." "0x00000,0x00800,0x01000,0x01800,0x02000,0x02800,0x03000,0x03800,0x04000,0x04800,0x05000,0x05800,0x06000,0x06800,0x07000,0x07800,0x08000,0x08800,0x09000,0x09800,0x0A000,0x0A800,0x0B000,0x0B800,0x0C000,0x0C800,0x0D000,0x0D800,0x0E000,0x0E800,0x0F000,0x0F800"


group.long (0xC3FC0020+0x08*0)++0x03
  line.long    0x00 "TBCR,eTPU A Time Base Configuration Register"
  bitfld.long  0x00 29.--31.             "TCR2CTL ,TCR2 clock/gate control" "000,001,010,011,100,101,110,111"
  bitfld.long  0x00 27.--28.             "  TCRCF ,TCRCLK signal filter control" "00,01,10,11"
  bitfld.long  0x00 25.                  "  AM ,Angle mode selection" "0,1"
  hexmask.long.byte 0x00 16.--21.  1.         "  TCR2P ,Timer count register 2 prescaler control"  
  bitfld.long  0x00 14.--15.             "  TCR1CTL ,TCR1 clock/gate control" "TCRCLK,res.,sysclk/2,res."
  hexmask.long.byte 0x00 00.--07.  1.         "  TCR1P ,Timer count register 1 prescaler control"

group.long (0xC3FC0024+0x08*0)++0x03
  line.long    0x00 "TB1R,eTPU A Time Base 1 (TCR1) Visibility Register"
  hexmask.long 0x00 00.--23.  1.         "TCR1 ,TCR1 value. Used on matches and captures"
  
group.long (0xC3FC0028+0x08*0)++0x03
  line.long    0x00 "TB2R,eTPU A Time Base 2 (TCR2) Visibility Register"
  hexmask.long 0x00 00.--23.  1.         "TCR2 ,TCR2 value. Used on matches and captures"
  
group.long (0xC3FC002C+0x08*0)++0x03
  line.long    0x00 "REDCR,eTPU A STAC Bus Configuration Register"
  bitfld.long  0x00 31.                  "REN1 ,TCR1 resource1 client/server operation enable" "0,1"
  bitfld.long  0x00 30.                  "  RSC1 ,TCR1 resource server/client assignment" "0,1"
  hexmask.long.byte 0x00 24.--27.  1.    "  SRV_ID1 ,STAC bus address for TCR1 as a server"
  hexmask.long.byte 0x00 16.--19.  1.    "  SRV1 ,TCR1 resource server"
  bitfld.long  0x00 15.                  "  REN2 ,TCR2 resource1 client/server operation enable" "0,1"
  bitfld.long  0x00 14.                  "  RSC2 ,TCR2 resource server/client assignment" "0,1"
  hexmask.long.byte 0x00 08.--11.  1.    "  SRV_ID2 ,STAC bus address for TCR2 as a server"
  hexmask.long.byte 0x00 00.--03.  1.    "  SRV2 ,TCR2 resource server"
  
TEXTLINE ""  
  
group.long (0xC3FC0200+0)++0x03
  line.long    0x00 "CISR,eTPU A Channel Interrupt Status Register (w1c)"
  eventfld.long  0x00 31.                  "CIC31-28  ,Channel 31 interrupt status" "0,1"
  eventfld.long  0x00 30.                  ",Channel 30 interrupt status" "0,1"
  eventfld.long  0x00 29.                  ",Channel 29 interrupt status" "0,1"
  eventfld.long  0x00 28.                  ",Channel 28 interrupt status" "0,1"

  eventfld.long  0x00 27.                  "  CIC27-24  ,Channel 27 interrupt status" "0,1"
  eventfld.long  0x00 26.                  ",Channel 26 interrupt status" "0,1"
  eventfld.long  0x00 25.                  ",Channel 25 interrupt status" "0,1"
  eventfld.long  0x00 24.                  ",Channel 24 interrupt status" "0,1"
    
  eventfld.long  0x00 23.                  "  CIC23-20  ,Channel 23 interrupt status" "0,1"
  eventfld.long  0x00 22.                  ",Channel 22 interrupt status" "0,1"
  eventfld.long  0x00 21.                  ",Channel 21 interrupt status" "0,1"
  eventfld.long  0x00 20.                  ",Channel 20 interrupt status" "0,1"
  
  eventfld.long  0x00 19.                  "  CIC19-16  ,Channel 19 interrupt status" "0,1"
  eventfld.long  0x00 18.                  ",Channel 18 interrupt status" "0,1"
  eventfld.long  0x00 17.                  ",Channel 17 interrupt status" "0,1"
  eventfld.long  0x00 16.                  ",Channel 16 interrupt status" "0,1"
TEXTLINE "                "
  eventfld.long  0x00 15.                  "  CIC15-12  ,Channel 15 interrupt status" "0,1"
  eventfld.long  0x00 14.                  ",Channel 14 interrupt status" "0,1"
  eventfld.long  0x00 13.                  ",Channel 13 interrupt status" "0,1"
  eventfld.long  0x00 12.                  ",Channel 12 interrupt status" "0,1"
  
  eventfld.long  0x00 11.                  "  CIC11-08  ,Channel 11 interrupt status" "0,1"
  eventfld.long  0x00 10.                  ",Channel 10 interrupt status" "0,1"
  eventfld.long  0x00 09.                  ",Channel 09 interrupt status" "0,1"
  eventfld.long  0x00 08.                  ",Channel 08 interrupt statusk" "0,1"
  
  eventfld.long  0x00 07.                  "  CIC17-04  ,Channel 07 interrupt status" "0,1"
  eventfld.long  0x00 06.                  ",Channel 06 interrupt statusk" "0,1"
  eventfld.long  0x00 05.                  ",Channel 05 interrupt status" "0,1"
  eventfld.long  0x00 04.                  ",Channel 04 interrupt status" "0,1"
  
  eventfld.long  0x00 03.                  "  CIC03-00  ,Channel 03 interrupt status" "0,1"
  eventfld.long  0x00 02.                  ",Channel 02 interrupt status" "0,1"
  eventfld.long  0x00 01.                  ",Channel 01 interrupt status" "0,1"
  eventfld.long  0x00 00.                  ",Channel 00 interrupt status" "0,1"
TEXTLINE ""

group.long (0xC3FC0210+0)++0x03
  line.long    0x00 "CDTRSR,eTPU A Channel Data Transfer Request Status Register (w1c)"
  eventfld.long  0x00 31.                  "DTR31-28  ,Channel 31 data transfer request status" "0,1"
  eventfld.long  0x00 30.                  ",Channel 30 data transfer request status" "0,1"
  eventfld.long  0x00 29.                  ",Channel 29 data transfer request status" "0,1"
  eventfld.long  0x00 28.                  ",Channel 28 data transfer request status" "0,1"

  eventfld.long  0x00 27.                  "  DTR27-24  ,Channel 27 data transfer request status" "0,1"
  eventfld.long  0x00 26.                  ",Channel 26 data transfer request status" "0,1"
  eventfld.long  0x00 25.                  ",Channel 25 data transfer request status" "0,1"
  eventfld.long  0x00 24.                  ",Channel 24 data transfer request status" "0,1"
    
  eventfld.long  0x00 23.                  "  DTR23-20  ,Channel 23 data transfer request status" "0,1"
  eventfld.long  0x00 22.                  ",Channel 22 data transfer request status" "0,1"
  eventfld.long  0x00 21.                  ",Channel 21 data transfer request status" "0,1"
  eventfld.long  0x00 20.                  ",Channel 20 data transfer request status" "0,1"
  
  eventfld.long  0x00 19.                  "  DTR19-16  ,Channel 19 data transfer request status" "0,1"
  eventfld.long  0x00 18.                  ",Channel 18 data transfer request status" "0,1"
  eventfld.long  0x00 17.                  ",Channel 17 data transfer request status" "0,1"
  eventfld.long  0x00 16.                  ",Channel 16 data transfer request status" "0,1"
TEXTLINE "                "
  eventfld.long  0x00 15.                  "  DTR15-12  ,Channel 15 data transfer request status" "0,1"
  eventfld.long  0x00 14.                  ",Channel 14 data transfer request status" "0,1"
  eventfld.long  0x00 13.                  ",Channel 13 data transfer request status" "0,1"
  eventfld.long  0x00 12.                  ",Channel 12 data transfer request status" "0,1"
  
  eventfld.long  0x00 11.                  "  DTR11-08  ,Channel 11 data transfer request status" "0,1"
  eventfld.long  0x00 10.                  ",Channel 10 data transfer request status" "0,1"
  eventfld.long  0x00 09.                  ",Channel 09 data transfer request status" "0,1"
  eventfld.long  0x00 08.                  ",Channel 08 data transfer request status" "0,1"
  
  eventfld.long  0x00 07.                  "  DTR17-04  ,Channel 07 data transfer request status" "0,1"
  eventfld.long  0x00 06.                  ",Channel 06 data transfer request status" "0,1"
  eventfld.long  0x00 05.                  ",Channel 05 data transfer request status" "0,1"
  eventfld.long  0x00 04.                  ",Channel 04 data transfer request status" "0,1"
  
  eventfld.long  0x00 03.                  "  DTR03-00  ,Channel 03 data transfer request status" "0,1"
  eventfld.long  0x00 02.                  ",Channel 02 data transfer request status" "0,1"
  eventfld.long  0x00 01.                  ",Channel 01 data transfer request status" "0,1"
  eventfld.long  0x00 00.                  ",Channel 00 data transfer request status" "0,1"
TEXTLINE ""


group.long (0xC3FC0220+0)++0x03
  line.long    0x00 "CIOSR,eTPU A Channel Interrupt Overflow Status Register (w1c)"
  eventfld.long  0x00 31.                  "CIO31-28  ,Channel 31 interrupt overflow status" "0,1"
  eventfld.long  0x00 30.                  ",Channel 30 interrupt overflow status" "0,1"
  eventfld.long  0x00 29.                  ",Channel 29 interrupt overflow status" "0,1"
  eventfld.long  0x00 28.                  ",Channel 28 interrupt overflow status" "0,1"

  eventfld.long  0x00 27.                  "  CIO27-24  ,Channel 27 interrupt overflow status" "0,1"
  eventfld.long  0x00 26.                  ",Channel 26 interrupt overflow status" "0,1"
  eventfld.long  0x00 25.                  ",Channel 25 interrupt overflow status" "0,1"
  eventfld.long  0x00 24.                  ",Channel 24 interrupt overflow status" "0,1"
    
  eventfld.long  0x00 23.                  "  CIO23-20  ,Channel 23 interrupt overflow status" "0,1"
  eventfld.long  0x00 22.                  ",Channel 22 interrupt overflow status" "0,1"
  eventfld.long  0x00 21.                  ",Channel 21 interrupt overflow status" "0,1"
  eventfld.long  0x00 20.                  ",Channel 20 interrupt overflow status" "0,1"
  
  eventfld.long  0x00 19.                  "  CIO19-16  ,Channel 19 interrupt overflow status" "0,1"
  eventfld.long  0x00 18.                  ",Channel 18 interrupt overflow status" "0,1"
  eventfld.long  0x00 17.                  ",Channel 17 interrupt overflow status" "0,1"
  eventfld.long  0x00 16.                  ",Channel 16 interrupt overflow status" "0,1"
TEXTLINE "                "
  eventfld.long  0x00 15.                  "  CIO15-12  ,Channel 15 interrupt overflow status" "0,1"
  eventfld.long  0x00 14.                  ",Channel 14 interrupt overflow status" "0,1"
  eventfld.long  0x00 13.                  ",Channel 13 interrupt overflow status" "0,1"
  eventfld.long  0x00 12.                  ",Channel 12 interrupt overflow status" "0,1"
  
  eventfld.long  0x00 11.                  "  CIO11-08  ,Channel 11 interrupt overflow status" "0,1"
  eventfld.long  0x00 10.                  ",Channel 10 interrupt overflow status" "0,1"
  eventfld.long  0x00 09.                  ",Channel 09 interrupt overflow status" "0,1"
  eventfld.long  0x00 08.                  ",Channel 08 interrupt overflow status" "0,1"
  
  eventfld.long  0x00 07.                  "  CIO17-04  ,Channel 07 interrupt overflow status" "0,1"
  eventfld.long  0x00 06.                  ",Channel 06 interrupt overflow status" "0,1"
  eventfld.long  0x00 05.                  ",Channel 05 interrupt overflow status" "0,1"
  eventfld.long  0x00 04.                  ",Channel 04 interrupt overflow status" "0,1"
  
  eventfld.long  0x00 03.                  "  CIO03-00  ,Channel 03 interrupt overflow status" "0,1"
  eventfld.long  0x00 02.                  ",Channel 02 interrupt overflow status" "0,1"
  eventfld.long  0x00 01.                  ",Channel 01 interrupt overflow status" "0,1"
  eventfld.long  0x00 00.                  ",Channel 00 interrupt overflow status" "0,1"
TEXTLINE ""



group.long (0xC3FC0230+0)++0x03
  line.long    0x00 "CDTROSR,eTPU A Channel Data Transfer Request Overflow Status Register (w1c)"
  eventfld.long  0x00 31.                  "DTRO31-28 ,Channel 31 data transfer request overflow status" "0,1"
  eventfld.long  0x00 30.                  ",Channel 30 data transfer request overflow status" "0,1"
  eventfld.long  0x00 29.                  ",Channel 29 data transfer request overflow status" "0,1"
  eventfld.long  0x00 28.                  ",Channel 28 data transfer request overflow status" "0,1"

  eventfld.long  0x00 27.                  "  DTRO27-24 ,Channel 27 data transfer request overflow status" "0,1"
  eventfld.long  0x00 26.                  ",Channel 26 data transfer request overflow status" "0,1"
  eventfld.long  0x00 25.                  ",Channel 25 data transfer request overflow status" "0,1"
  eventfld.long  0x00 24.                  ",Channel 24 data transfer request overflow status" "0,1"
    
  eventfld.long  0x00 23.                  "  DTRO23-20 ,Channel 23 data transfer request overflow status" "0,1"
  eventfld.long  0x00 22.                  ",Channel 22 data transfer request overflow status" "0,1"
  eventfld.long  0x00 21.                  ",Channel 21 data transfer request overflow status" "0,1"
  eventfld.long  0x00 20.                  ",Channel 20 data transfer request overflow status" "0,1"
  
  eventfld.long  0x00 19.                  "  DTRO19-16 ,Channel 19 data transfer request overflow status" "0,1"
  eventfld.long  0x00 18.                  ",Channel 18 data transfer request overflow status" "0,1"
  eventfld.long  0x00 17.                  ",Channel 17 data transfer request overflow status" "0,1"
  eventfld.long  0x00 16.                  ",Channel 16 data transfer request overflow status" "0,1"
TEXTLINE "                "
  eventfld.long  0x00 15.                  "  DTRO15-12 ,Channel 15 data transfer request overflow status" "0,1"
  eventfld.long  0x00 14.                  ",Channel 14 data transfer request overflow status" "0,1"
  eventfld.long  0x00 13.                  ",Channel 13 data transfer request overflow status" "0,1"
  eventfld.long  0x00 12.                  ",Channel 12 data transfer request overflow status" "0,1"
  
  eventfld.long  0x00 11.                  "  DTRO11-08 ,Channel 11 data transfer request overflow status" "0,1"
  eventfld.long  0x00 10.                  ",Channel 10 data transfer request overflow status" "0,1"
  eventfld.long  0x00 09.                  ",Channel 09 data transfer request overflow status" "0,1"
  eventfld.long  0x00 08.                  ",Channel 08 data transfer request overflow status" "0,1"
  
  eventfld.long  0x00 07.                  "  DTRO17-04 ,Channel 07 data transfer request overflow status" "0,1"
  eventfld.long  0x00 06.                  ",Channel 06 data transfer request overflow status" "0,1"
  eventfld.long  0x00 05.                  ",Channel 05 data transfer request overflow status" "0,1"
  eventfld.long  0x00 04.                  ",Channel 04 data transfer request overflow status" "0,1"
  
  eventfld.long  0x00 03.                  "  DTRO03-00 ,Channel 03 data transfer request overflow status" "0,1"
  eventfld.long  0x00 02.                  ",Channel 02 data transfer request overflow status" "0,1"
  eventfld.long  0x00 01.                  ",Channel 01 data transfer request overflow status" "0,1"
  eventfld.long  0x00 00.                  ",Channel 00 data transfer request overflow status" "0,1"
TEXTLINE ""

group.long (0xC3FC0240+0)++0x03
  line.long    0x00 "CIER,eTPU A Channel Interrupt Enable Register"
  bitfld.long  0x00 31.                  "CIE31-28  ,Channel 31 interrupt enable" "0,1"
  bitfld.long  0x00 30.                  ",Channel 30 interrupt enable" "0,1"
  bitfld.long  0x00 29.                  ",Channel 29 interrupt enable" "0,1"
  bitfld.long  0x00 28.                  ",Channel 28 interrupt enable" "0,1"

  bitfld.long  0x00 27.                  "  CIE27-24  ,Channel 27 interrupt enable" "0,1"
  bitfld.long  0x00 26.                  ",Channel 26 interrupt enable" "0,1"
  bitfld.long  0x00 25.                  ",Channel 25 interrupt enable" "0,1"
  bitfld.long  0x00 24.                  ",Channel 24 interrupt enable" "0,1"
    
  bitfld.long  0x00 23.                  "  CIE23-20  ,Channel 23 interrupt enable" "0,1"
  bitfld.long  0x00 22.                  ",Channel 22 interrupt enable" "0,1"
  bitfld.long  0x00 21.                  ",Channel 21 interrupt enable" "0,1"
  bitfld.long  0x00 20.                  ",Channel 20 interrupt enable" "0,1"
  
  bitfld.long  0x00 19.                  "  CIE19-16  ,Channel 19 interrupt enable" "0,1"
  bitfld.long  0x00 18.                  ",Channel 18 interrupt enable" "0,1"
  bitfld.long  0x00 17.                  ",Channel 17 interrupt enable" "0,1"
  bitfld.long  0x00 16.                  ",Channel 16 interrupt enable" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.                  "  CIE15-12  ,Channel 15 interrupt enable" "0,1"
  bitfld.long  0x00 14.                  ",Channel 14 interrupt enable" "0,1"
  bitfld.long  0x00 13.                  ",Channel 13 interrupt enable" "0,1"
  bitfld.long  0x00 12.                  ",Channel 12 interrupt enable" "0,1"
  
  bitfld.long  0x00 11.                  "  CIE11-08  ,Channel 11 interrupt enable" "0,1"
  bitfld.long  0x00 10.                  ",Channel 10 interrupt enable" "0,1"
  bitfld.long  0x00 09.                  ",Channel 09 interrupt enable" "0,1"
  bitfld.long  0x00 08.                  ",Channel 08 interrupt enable" "0,1"
  
  bitfld.long  0x00 07.                  "  CIE17-04  ,Channel 07 interrupt enable" "0,1"
  bitfld.long  0x00 06.                  ",Channel 06 interrupt enable" "0,1"
  bitfld.long  0x00 05.                  ",Channel 05 interrupt enable" "0,1"
  bitfld.long  0x00 04.                  ",Channel 04 interrupt enable" "0,1"
  
  bitfld.long  0x00 03.                  "  CIE03-00  ,Channel 03 interrupt enable" "0,1"
  bitfld.long  0x00 02.                  ",Channel 02 interrupt enable" "0,1"
  bitfld.long  0x00 01.                  ",Channel 01 interrupt enable" "0,1"
  bitfld.long  0x00 00.                  ",Channel 00 interrupt enable" "0,1"
TEXTLINE ""

group.long (0xC3FC0250+0)++0x03
  line.long    0x00 "CDTRER,eTPU A Channel Data Transfer Request Enable Register"
  bitfld.long  0x00 31.                  "DTRE31-28 ,Channel 31 data transfer request enable" "0,1"
  bitfld.long  0x00 30.                  ",Channel 30 data transfer request enable" "0,1"
  bitfld.long  0x00 29.                  ",Channel 29 data transfer request enable" "0,1"
  bitfld.long  0x00 28.                  ",Channel 28 data transfer request enable" "0,1"

  bitfld.long  0x00 27.                  "  DTRE27-24 ,Channel 27 data transfer request enable" "0,1"
  bitfld.long  0x00 26.                  ",Channel 26 data transfer request enable" "0,1"
  bitfld.long  0x00 25.                  ",Channel 25 data transfer request enable" "0,1"
  bitfld.long  0x00 24.                  ",Channel 24 data transfer request enable" "0,1"
    
  bitfld.long  0x00 23.                  "  DTRE23-20 ,Channel 23 data transfer request enable" "0,1"
  bitfld.long  0x00 22.                  ",Channel 22 data transfer request enable" "0,1"
  bitfld.long  0x00 21.                  ",Channel 21 data transfer request enable" "0,1"
  bitfld.long  0x00 20.                  ",Channel 20 data transfer request enable" "0,1"
  
  bitfld.long  0x00 19.                  "  DTRE19-16 ,Channel 19 data transfer request enable" "0,1"
  bitfld.long  0x00 18.                  ",Channel 18 data transfer request enable" "0,1"
  bitfld.long  0x00 17.                  ",Channel 17 data transfer request enable" "0,1"
  bitfld.long  0x00 16.                  ",Channel 16 data transfer request enable" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.                  "  DTRE15-12 ,Channel 15 data transfer request enable" "0,1"
  bitfld.long  0x00 14.                  ",Channel 14 data transfer request enable" "0,1"
  bitfld.long  0x00 13.                  ",Channel 13 data transfer request enable" "0,1"
  bitfld.long  0x00 12.                  ",Channel 12 data transfer request enable" "0,1"
  
  bitfld.long  0x00 11.                  "  DTRE11-08 ,Channel 11 data transfer request enable" "0,1"
  bitfld.long  0x00 10.                  ",Channel 10 data transfer request enable" "0,1"
  bitfld.long  0x00 09.                  ",Channel 09 data transfer request enable" "0,1"
  bitfld.long  0x00 08.                  ",Channel 08 data transfer request enable" "0,1"
  
  bitfld.long  0x00 07.                  "  DTRE17-04 ,Channel 07 data transfer request enable" "0,1"
  bitfld.long  0x00 06.                  ",Channel 06 data transfer request enable" "0,1"
  bitfld.long  0x00 05.                  ",Channel 05 data transfer request enable" "0,1"
  bitfld.long  0x00 04.                  ",Channel 04 data transfer request enable" "0,1"
  
  bitfld.long  0x00 03.                  "  DTRE03-00 ,Channel 03 data transfer request enable" "0,1"
  bitfld.long  0x00 02.                  ",Channel 02 data transfer request enable" "0,1"
  bitfld.long  0x00 01.                  ",Channel 01 data transfer request enable" "0,1"
  bitfld.long  0x00 00.                  ",Channel 00 data transfer request enable" "0,1"
TEXTLINE ""

rgroup.long (0xC3FC0280+0)++0x03
  line.long    0x00 "CPSSR,eTPU A Channel Pending Service Status Register"
  bitfld.long  0x00 31.                  "SR31-28   ,Channel 31 pending service request" "0,1"
  bitfld.long  0x00 30.                  ",Channel 30 pending service request" "0,1"
  bitfld.long  0x00 29.                  ",Channel 29 pending service request" "0,1"
  bitfld.long  0x00 28.                  ",Channel 28 pending service request" "0,1"

  bitfld.long  0x00 27.                  "  SR27-24   ,Channel 27 pending service request" "0,1"
  bitfld.long  0x00 26.                  ",Channel 26 pending service request" "0,1"
  bitfld.long  0x00 25.                  ",Channel 25 pending service request" "0,1"
  bitfld.long  0x00 24.                  ",Channel 24 pending service request" "0,1"
    
  bitfld.long  0x00 23.                  "  SR23-20   ,Channel 23 pending service request" "0,1"
  bitfld.long  0x00 22.                  ",Channel 22 pending service request" "0,1"
  bitfld.long  0x00 21.                  ",Channel 21 pending service request" "0,1"
  bitfld.long  0x00 20.                  ",Channel 20 pending service request" "0,1"
  
  bitfld.long  0x00 19.                  "  SR19-16   ,Channel 19 pending service request" "0,1"
  bitfld.long  0x00 18.                  ",Channel 18 pending service request" "0,1"
  bitfld.long  0x00 17.                  ",Channel 17 pending service request" "0,1"
  bitfld.long  0x00 16.                  ",Channel 16 pending service request" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.                  "  SR15-12   ,Channel 15 pending service request" "0,1"
  bitfld.long  0x00 14.                  ",Channel 14 pending service request" "0,1"
  bitfld.long  0x00 13.                  ",Channel 13 pending service request" "0,1"
  bitfld.long  0x00 12.                  ",Channel 12 pending service request" "0,1"
  
  bitfld.long  0x00 11.                  "  SR11-08   ,Channel 11 pending service request" "0,1"
  bitfld.long  0x00 10.                  ",Channel 10 pending service request" "0,1"
  bitfld.long  0x00 09.                  ",Channel 09 pending service request" "0,1"
  bitfld.long  0x00 08.                  ",Channel 08 pending service request" "0,1"
  
  bitfld.long  0x00 07.                  "  SR17-04   ,Channel 07 pending service request" "0,1"
  bitfld.long  0x00 06.                  ",Channel 06 pending service request" "0,1"
  bitfld.long  0x00 05.                  ",Channel 05 pending service request" "0,1"
  bitfld.long  0x00 04.                  ",Channel 04 pending service request" "0,1"
  
  bitfld.long  0x00 03.                  "  SR03-00   ,Channel 03 pending service request" "0,1"
  bitfld.long  0x00 02.                  ",Channel 02 pending service request" "0,1"
  bitfld.long  0x00 01.                  ",Channel 01 pending service request" "0,1"
  bitfld.long  0x00 00.                  ",Channel 00 pending service request" "0,1"
TEXTLINE ""

rgroup.long (0xC3FC0290+0)++0x03
  line.long    0x00 "CSSR,eTPU A Channel Service Status Register"
  bitfld.long  0x00 31.                  "SS31-28   ,Channel 31 service status" "0,1"
  bitfld.long  0x00 30.                  ",Channel 30 service status" "0,1"
  bitfld.long  0x00 29.                  ",Channel 29 service status" "0,1"
  bitfld.long  0x00 28.                  ",Channel 28 service status" "0,1"

  bitfld.long  0x00 27.                  "  SS27-24   ,Channel 27 service status" "0,1"
  bitfld.long  0x00 26.                  ",Channel 26 service status" "0,1"
  bitfld.long  0x00 25.                  ",Channel 25 service status" "0,1"
  bitfld.long  0x00 24.                  ",Channel 24 service status" "0,1"
    
  bitfld.long  0x00 23.                  "  SS23-20   ,Channel 23 service status" "0,1"
  bitfld.long  0x00 22.                  ",Channel 22 service status" "0,1"
  bitfld.long  0x00 21.                  ",Channel 21 service status" "0,1"
  bitfld.long  0x00 20.                  ",Channel 20 service status" "0,1"
  
  bitfld.long  0x00 19.                  "  SS19-16   ,Channel 19 service status" "0,1"
  bitfld.long  0x00 18.                  ",Channel 18 service status" "0,1"
  bitfld.long  0x00 17.                  ",Channel 17 service status" "0,1"
  bitfld.long  0x00 16.                  ",Channel 16 service status" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.                  "  SS15-12   ,Channel 15 service status" "0,1"
  bitfld.long  0x00 14.                  ",Channel 14 service status" "0,1"
  bitfld.long  0x00 13.                  ",Channel 13 service status" "0,1"
  bitfld.long  0x00 12.                  ",Channel 12 service status" "0,1"
  
  bitfld.long  0x00 11.                  "  SS11-08   ,Channel 11 service status" "0,1"
  bitfld.long  0x00 10.                  ",Channel 10 service status" "0,1"
  bitfld.long  0x00 09.                  ",Channel 09 service status" "0,1"
  bitfld.long  0x00 08.                  ",Channel 08 service status" "0,1"
  
  bitfld.long  0x00 07.                  "  SS17-04   ,Channel 07 service status" "0,1"
  bitfld.long  0x00 06.                  ",Channel 06 service status" "0,1"
  bitfld.long  0x00 05.                  ",Channel 05 service status" "0,1"
  bitfld.long  0x00 04.                  ",Channel 04 service status" "0,1"
  
  bitfld.long  0x00 03.                  "  SS03-00   ,Channel 03 service status" "0,1"
  bitfld.long  0x00 02.                  ",Channel 02 service status" "0,1"
  bitfld.long  0x00 01.                  ",Channel 01 service status" "0,1"
  bitfld.long  0x00 00.                  ",Channel 00 service status" "0,1"
TEXTLINE ""

tree "eTPU A Channel Registers"


group.long (0xC3FC0400+0x100*0.+0x10*0.)++0x03
  line.long    0x00 "CR0,eTPU A Channel 0 Configuration Register"
  bitfld.long  0x00 31.                  "CIE ,Channel interrupt enable" "0,1"
  bitfld.long  0x00 30.                  "  DTRE ,Channel data transfer request enable" "0,1"
  bitfld.long  0x00 28.--29.             "  CPR ,Channel priority" "dis,low,mid,high"
  bitfld.long  0x00 25.                  "  ETPD ,This bit selects which channel signal, input or output, is used in the entry point selection" "PSTI,PSTO"
  bitfld.long  0x00 24.                  "  ETCS ,Entry table condition select" "std,alt"
  bitfld.long  0x00 16.--20.             "  CFS ,Channel function select" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
  bitfld.long  0x00 15.                  "  ODIS ,Output disable" "0,1"
TEXTLINE "                "  
  bitfld.long  0x00 14.                  "  OPOL ,Output polarity" "act. low,act. high"
  hexmask.long.word 0x00 00.--10. 2.     " CPBA_eTPU ,channel parameter base address - eTPU addressing"
  hexmask.long.word 0x00 00.--10. 8.     "       CPBA_host ,channel parameter base address - host (byte) addressing"
  textfld "    "   
  button "Data.dump CHBASE" "Data.Dump ANC:(0xC3FC8000+((Data.Long(ANC:0xC3FC0400+0x100*0.+0x10*0.)&0x3FF)*8.)) /DIALOG"

group.long (0xC3FC0404+0x100*0.+0x10*0.)++0x03
  line.long    0x00 "SCR0,eTPU A Channel 0 Status Control Register"
  eventfld.long  0x00 31.                  "CIS ,Channel interrupt (w1c)" "0,1"
  eventfld.long  0x00 30.                  "  CIOS ,Channel interrupt overflow status (w1c)" "0,1"
  eventfld.long  0x00 23.                  "  DTRS ,Data transfer request status (w1c)" "0,1"
  eventfld.long  0x00 22.                  "    DTROS ,Data transfer request overflow status (w1c)" "0,1"
  bitfld.long  0x00 15.                  "    IPS  ,Channel input pin state" "0,1"
  bitfld.long  0x00 14.                  "    OPS ,Channel output pin state" "0,1"
  bitfld.long  0x00 00.--01.             "   FM   ,Channel function mode" "0,1,2,3"

group.long (0xC3FC0408+0x100*0.+0x10*0.)++0x03
  line.long    0x00 "HSRR0,eTPU A Channel 0 Host Service Request Register"
  bitfld.long  0x00 00.--02.             "HSR ,Host service request" "0,1,2,3,4,5,6,7"


TEXTLINE ""


group.long (0xC3FC0400+0x100*0.+0x10*1.)++0x03
  line.long    0x00 "CR1,eTPU A Channel 1 Configuration Register"
  bitfld.long  0x00 31.                  "CIE ,Channel interrupt enable" "0,1"
  bitfld.long  0x00 30.                  "  DTRE ,Channel data transfer request enable" "0,1"
  bitfld.long  0x00 28.--29.             "  CPR ,Channel priority" "dis,low,mid,high"
  bitfld.long  0x00 25.                  "  ETPD ,This bit selects which channel signal, input or output, is used in the entry point selection" "PSTI,PSTO"
  bitfld.long  0x00 24.                  "  ETCS ,Entry table condition select" "std,alt"
  bitfld.long  0x00 16.--20.             "  CFS ,Channel function select" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
  bitfld.long  0x00 15.                  "  ODIS ,Output disable" "0,1"
TEXTLINE "                "  
  bitfld.long  0x00 14.                  "  OPOL ,Output polarity" "act. low,act. high"
  hexmask.long.word 0x00 00.--10. 2.     " CPBA_eTPU ,channel parameter base address - eTPU addressing"
  hexmask.long.word 0x00 00.--10. 8.     "       CPBA_host ,channel parameter base address - host (byte) addressing"
  textfld "    "   
  button "Data.dump CHBASE" "Data.Dump ANC:(0xC3FC8000+((Data.Long(ANC:0xC3FC0400+0x100*0.+0x10*1.)&0x3FF)*8.)) /DIALOG"

group.long (0xC3FC0404+0x100*0.+0x10*1.)++0x03
  line.long    0x00 "SCR1,eTPU A Channel 1 Status Control Register"
  eventfld.long  0x00 31.                  "CIS ,Channel interrupt (w1c)" "0,1"
  eventfld.long  0x00 30.                  "  CIOS ,Channel interrupt overflow status (w1c)" "0,1"
  eventfld.long  0x00 23.                  "  DTRS ,Data transfer request status (w1c)" "0,1"
  eventfld.long  0x00 22.                  "    DTROS ,Data transfer request overflow status (w1c)" "0,1"
  bitfld.long  0x00 15.                  "    IPS  ,Channel input pin state" "0,1"
  bitfld.long  0x00 14.                  "    OPS ,Channel output pin state" "0,1"
  bitfld.long  0x00 00.--01.             "   FM   ,Channel function mode" "0,1,2,3"

group.long (0xC3FC0408+0x100*0.+0x10*1.)++0x03
  line.long    0x00 "HSRR1,eTPU A Channel 1 Host Service Request Register"
  bitfld.long  0x00 00.--02.             "HSR ,Host service request" "0,1,2,3,4,5,6,7"


TEXTLINE ""


group.long (0xC3FC0400+0x100*0.+0x10*2.)++0x03
  line.long    0x00 "CR2,eTPU A Channel 2 Configuration Register"
  bitfld.long  0x00 31.                  "CIE ,Channel interrupt enable" "0,1"
  bitfld.long  0x00 30.                  "  DTRE ,Channel data transfer request enable" "0,1"
  bitfld.long  0x00 28.--29.             "  CPR ,Channel priority" "dis,low,mid,high"
  bitfld.long  0x00 25.                  "  ETPD ,This bit selects which channel signal, input or output, is used in the entry point selection" "PSTI,PSTO"
  bitfld.long  0x00 24.                  "  ETCS ,Entry table condition select" "std,alt"
  bitfld.long  0x00 16.--20.             "  CFS ,Channel function select" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
  bitfld.long  0x00 15.                  "  ODIS ,Output disable" "0,1"
TEXTLINE "                "  
  bitfld.long  0x00 14.                  "  OPOL ,Output polarity" "act. low,act. high"
  hexmask.long.word 0x00 00.--10. 2.     " CPBA_eTPU ,channel parameter base address - eTPU addressing"
  hexmask.long.word 0x00 00.--10. 8.     "       CPBA_host ,channel parameter base address - host (byte) addressing"
  textfld "    "   
  button "Data.dump CHBASE" "Data.Dump ANC:(0xC3FC8000+((Data.Long(ANC:0xC3FC0400+0x100*0.+0x10*2.)&0x3FF)*8.)) /DIALOG"

group.long (0xC3FC0404+0x100*0.+0x10*2.)++0x03
  line.long    0x00 "SCR2,eTPU A Channel 2 Status Control Register"
  eventfld.long  0x00 31.                  "CIS ,Channel interrupt (w1c)" "0,1"
  eventfld.long  0x00 30.                  "  CIOS ,Channel interrupt overflow status (w1c)" "0,1"
  eventfld.long  0x00 23.                  "  DTRS ,Data transfer request status (w1c)" "0,1"
  eventfld.long  0x00 22.                  "    DTROS ,Data transfer request overflow status (w1c)" "0,1"
  bitfld.long  0x00 15.                  "    IPS  ,Channel input pin state" "0,1"
  bitfld.long  0x00 14.                  "    OPS ,Channel output pin state" "0,1"
  bitfld.long  0x00 00.--01.             "   FM   ,Channel function mode" "0,1,2,3"

group.long (0xC3FC0408+0x100*0.+0x10*2.)++0x03
  line.long    0x00 "HSRR2,eTPU A Channel 2 Host Service Request Register"
  bitfld.long  0x00 00.--02.             "HSR ,Host service request" "0,1,2,3,4,5,6,7"


TEXTLINE ""


group.long (0xC3FC0400+0x100*0.+0x10*3.)++0x03
  line.long    0x00 "CR3,eTPU A Channel 3 Configuration Register"
  bitfld.long  0x00 31.                  "CIE ,Channel interrupt enable" "0,1"
  bitfld.long  0x00 30.                  "  DTRE ,Channel data transfer request enable" "0,1"
  bitfld.long  0x00 28.--29.             "  CPR ,Channel priority" "dis,low,mid,high"
  bitfld.long  0x00 25.                  "  ETPD ,This bit selects which channel signal, input or output, is used in the entry point selection" "PSTI,PSTO"
  bitfld.long  0x00 24.                  "  ETCS ,Entry table condition select" "std,alt"
  bitfld.long  0x00 16.--20.             "  CFS ,Channel function select" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
  bitfld.long  0x00 15.                  "  ODIS ,Output disable" "0,1"
TEXTLINE "                "  
  bitfld.long  0x00 14.                  "  OPOL ,Output polarity" "act. low,act. high"
  hexmask.long.word 0x00 00.--10. 2.     " CPBA_eTPU ,channel parameter base address - eTPU addressing"
  hexmask.long.word 0x00 00.--10. 8.     "       CPBA_host ,channel parameter base address - host (byte) addressing"
  textfld "    "   
  button "Data.dump CHBASE" "Data.Dump ANC:(0xC3FC8000+((Data.Long(ANC:0xC3FC0400+0x100*0.+0x10*3.)&0x3FF)*8.)) /DIALOG"

group.long (0xC3FC0404+0x100*0.+0x10*3.)++0x03
  line.long    0x00 "SCR3,eTPU A Channel 3 Status Control Register"
  eventfld.long  0x00 31.                  "CIS ,Channel interrupt (w1c)" "0,1"
  eventfld.long  0x00 30.                  "  CIOS ,Channel interrupt overflow status (w1c)" "0,1"
  eventfld.long  0x00 23.                  "  DTRS ,Data transfer request status (w1c)" "0,1"
  eventfld.long  0x00 22.                  "    DTROS ,Data transfer request overflow status (w1c)" "0,1"
  bitfld.long  0x00 15.                  "    IPS  ,Channel input pin state" "0,1"
  bitfld.long  0x00 14.                  "    OPS ,Channel output pin state" "0,1"
  bitfld.long  0x00 00.--01.             "   FM   ,Channel function mode" "0,1,2,3"

group.long (0xC3FC0408+0x100*0.+0x10*3.)++0x03
  line.long    0x00 "HSRR3,eTPU A Channel 3 Host Service Request Register"
  bitfld.long  0x00 00.--02.             "HSR ,Host service request" "0,1,2,3,4,5,6,7"


TEXTLINE ""


group.long (0xC3FC0400+0x100*0.+0x10*4.)++0x03
  line.long    0x00 "CR4,eTPU A Channel 4 Configuration Register"
  bitfld.long  0x00 31.                  "CIE ,Channel interrupt enable" "0,1"
  bitfld.long  0x00 30.                  "  DTRE ,Channel data transfer request enable" "0,1"
  bitfld.long  0x00 28.--29.             "  CPR ,Channel priority" "dis,low,mid,high"
  bitfld.long  0x00 25.                  "  ETPD ,This bit selects which channel signal, input or output, is used in the entry point selection" "PSTI,PSTO"
  bitfld.long  0x00 24.                  "  ETCS ,Entry table condition select" "std,alt"
  bitfld.long  0x00 16.--20.             "  CFS ,Channel function select" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
  bitfld.long  0x00 15.                  "  ODIS ,Output disable" "0,1"
TEXTLINE "                "  
  bitfld.long  0x00 14.                  "  OPOL ,Output polarity" "act. low,act. high"
  hexmask.long.word 0x00 00.--10. 2.     " CPBA_eTPU ,channel parameter base address - eTPU addressing"
  hexmask.long.word 0x00 00.--10. 8.     "       CPBA_host ,channel parameter base address - host (byte) addressing"
  textfld "    "   
  button "Data.dump CHBASE" "Data.Dump ANC:(0xC3FC8000+((Data.Long(ANC:0xC3FC0400+0x100*0.+0x10*4.)&0x3FF)*8.)) /DIALOG"

group.long (0xC3FC0404+0x100*0.+0x10*4.)++0x03
  line.long    0x00 "SCR4,eTPU A Channel 4 Status Control Register"
  eventfld.long  0x00 31.                  "CIS ,Channel interrupt (w1c)" "0,1"
  eventfld.long  0x00 30.                  "  CIOS ,Channel interrupt overflow status (w1c)" "0,1"
  eventfld.long  0x00 23.                  "  DTRS ,Data transfer request status (w1c)" "0,1"
  eventfld.long  0x00 22.                  "    DTROS ,Data transfer request overflow status (w1c)" "0,1"
  bitfld.long  0x00 15.                  "    IPS  ,Channel input pin state" "0,1"
  bitfld.long  0x00 14.                  "    OPS ,Channel output pin state" "0,1"
  bitfld.long  0x00 00.--01.             "   FM   ,Channel function mode" "0,1,2,3"

group.long (0xC3FC0408+0x100*0.+0x10*4.)++0x03
  line.long    0x00 "HSRR4,eTPU A Channel 4 Host Service Request Register"
  bitfld.long  0x00 00.--02.             "HSR ,Host service request" "0,1,2,3,4,5,6,7"


TEXTLINE ""


group.long (0xC3FC0400+0x100*0.+0x10*5.)++0x03
  line.long    0x00 "CR5,eTPU A Channel 5 Configuration Register"
  bitfld.long  0x00 31.                  "CIE ,Channel interrupt enable" "0,1"
  bitfld.long  0x00 30.                  "  DTRE ,Channel data transfer request enable" "0,1"
  bitfld.long  0x00 28.--29.             "  CPR ,Channel priority" "dis,low,mid,high"
  bitfld.long  0x00 25.                  "  ETPD ,This bit selects which channel signal, input or output, is used in the entry point selection" "PSTI,PSTO"
  bitfld.long  0x00 24.                  "  ETCS ,Entry table condition select" "std,alt"
  bitfld.long  0x00 16.--20.             "  CFS ,Channel function select" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
  bitfld.long  0x00 15.                  "  ODIS ,Output disable" "0,1"
TEXTLINE "                "  
  bitfld.long  0x00 14.                  "  OPOL ,Output polarity" "act. low,act. high"
  hexmask.long.word 0x00 00.--10. 2.     " CPBA_eTPU ,channel parameter base address - eTPU addressing"
  hexmask.long.word 0x00 00.--10. 8.     "       CPBA_host ,channel parameter base address - host (byte) addressing"
  textfld "    "   
  button "Data.dump CHBASE" "Data.Dump ANC:(0xC3FC8000+((Data.Long(ANC:0xC3FC0400+0x100*0.+0x10*5.)&0x3FF)*8.)) /DIALOG"

group.long (0xC3FC0404+0x100*0.+0x10*5.)++0x03
  line.long    0x00 "SCR5,eTPU A Channel 5 Status Control Register"
  eventfld.long  0x00 31.                  "CIS ,Channel interrupt (w1c)" "0,1"
  eventfld.long  0x00 30.                  "  CIOS ,Channel interrupt overflow status (w1c)" "0,1"
  eventfld.long  0x00 23.                  "  DTRS ,Data transfer request status (w1c)" "0,1"
  eventfld.long  0x00 22.                  "    DTROS ,Data transfer request overflow status (w1c)" "0,1"
  bitfld.long  0x00 15.                  "    IPS  ,Channel input pin state" "0,1"
  bitfld.long  0x00 14.                  "    OPS ,Channel output pin state" "0,1"
  bitfld.long  0x00 00.--01.             "   FM   ,Channel function mode" "0,1,2,3"

group.long (0xC3FC0408+0x100*0.+0x10*5.)++0x03
  line.long    0x00 "HSRR5,eTPU A Channel 5 Host Service Request Register"
  bitfld.long  0x00 00.--02.             "HSR ,Host service request" "0,1,2,3,4,5,6,7"


TEXTLINE ""


group.long (0xC3FC0400+0x100*0.+0x10*6.)++0x03
  line.long    0x00 "CR6,eTPU A Channel 6 Configuration Register"
  bitfld.long  0x00 31.                  "CIE ,Channel interrupt enable" "0,1"
  bitfld.long  0x00 30.                  "  DTRE ,Channel data transfer request enable" "0,1"
  bitfld.long  0x00 28.--29.             "  CPR ,Channel priority" "dis,low,mid,high"
  bitfld.long  0x00 25.                  "  ETPD ,This bit selects which channel signal, input or output, is used in the entry point selection" "PSTI,PSTO"
  bitfld.long  0x00 24.                  "  ETCS ,Entry table condition select" "std,alt"
  bitfld.long  0x00 16.--20.             "  CFS ,Channel function select" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
  bitfld.long  0x00 15.                  "  ODIS ,Output disable" "0,1"
TEXTLINE "                "  
  bitfld.long  0x00 14.                  "  OPOL ,Output polarity" "act. low,act. high"
  hexmask.long.word 0x00 00.--10. 2.     " CPBA_eTPU ,channel parameter base address - eTPU addressing"
  hexmask.long.word 0x00 00.--10. 8.     "       CPBA_host ,channel parameter base address - host (byte) addressing"
  textfld "    "   
  button "Data.dump CHBASE" "Data.Dump ANC:(0xC3FC8000+((Data.Long(ANC:0xC3FC0400+0x100*0.+0x10*6.)&0x3FF)*8.)) /DIALOG"

group.long (0xC3FC0404+0x100*0.+0x10*6.)++0x03
  line.long    0x00 "SCR6,eTPU A Channel 6 Status Control Register"
  eventfld.long  0x00 31.                  "CIS ,Channel interrupt (w1c)" "0,1"
  eventfld.long  0x00 30.                  "  CIOS ,Channel interrupt overflow status (w1c)" "0,1"
  eventfld.long  0x00 23.                  "  DTRS ,Data transfer request status (w1c)" "0,1"
  eventfld.long  0x00 22.                  "    DTROS ,Data transfer request overflow status (w1c)" "0,1"
  bitfld.long  0x00 15.                  "    IPS  ,Channel input pin state" "0,1"
  bitfld.long  0x00 14.                  "    OPS ,Channel output pin state" "0,1"
  bitfld.long  0x00 00.--01.             "   FM   ,Channel function mode" "0,1,2,3"

group.long (0xC3FC0408+0x100*0.+0x10*6.)++0x03
  line.long    0x00 "HSRR6,eTPU A Channel 6 Host Service Request Register"
  bitfld.long  0x00 00.--02.             "HSR ,Host service request" "0,1,2,3,4,5,6,7"


TEXTLINE ""


group.long (0xC3FC0400+0x100*0.+0x10*7.)++0x03
  line.long    0x00 "CR7,eTPU A Channel 7 Configuration Register"
  bitfld.long  0x00 31.                  "CIE ,Channel interrupt enable" "0,1"
  bitfld.long  0x00 30.                  "  DTRE ,Channel data transfer request enable" "0,1"
  bitfld.long  0x00 28.--29.             "  CPR ,Channel priority" "dis,low,mid,high"
  bitfld.long  0x00 25.                  "  ETPD ,This bit selects which channel signal, input or output, is used in the entry point selection" "PSTI,PSTO"
  bitfld.long  0x00 24.                  "  ETCS ,Entry table condition select" "std,alt"
  bitfld.long  0x00 16.--20.             "  CFS ,Channel function select" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
  bitfld.long  0x00 15.                  "  ODIS ,Output disable" "0,1"
TEXTLINE "                "  
  bitfld.long  0x00 14.                  "  OPOL ,Output polarity" "act. low,act. high"
  hexmask.long.word 0x00 00.--10. 2.     " CPBA_eTPU ,channel parameter base address - eTPU addressing"
  hexmask.long.word 0x00 00.--10. 8.     "       CPBA_host ,channel parameter base address - host (byte) addressing"
  textfld "    "   
  button "Data.dump CHBASE" "Data.Dump ANC:(0xC3FC8000+((Data.Long(ANC:0xC3FC0400+0x100*0.+0x10*7.)&0x3FF)*8.)) /DIALOG"

group.long (0xC3FC0404+0x100*0.+0x10*7.)++0x03
  line.long    0x00 "SCR7,eTPU A Channel 7 Status Control Register"
  eventfld.long  0x00 31.                  "CIS ,Channel interrupt (w1c)" "0,1"
  eventfld.long  0x00 30.                  "  CIOS ,Channel interrupt overflow status (w1c)" "0,1"
  eventfld.long  0x00 23.                  "  DTRS ,Data transfer request status (w1c)" "0,1"
  eventfld.long  0x00 22.                  "    DTROS ,Data transfer request overflow status (w1c)" "0,1"
  bitfld.long  0x00 15.                  "    IPS  ,Channel input pin state" "0,1"
  bitfld.long  0x00 14.                  "    OPS ,Channel output pin state" "0,1"
  bitfld.long  0x00 00.--01.             "   FM   ,Channel function mode" "0,1,2,3"

group.long (0xC3FC0408+0x100*0.+0x10*7.)++0x03
  line.long    0x00 "HSRR7,eTPU A Channel 7 Host Service Request Register"
  bitfld.long  0x00 00.--02.             "HSR ,Host service request" "0,1,2,3,4,5,6,7"


TEXTLINE ""


group.long (0xC3FC0400+0x100*0.+0x10*8.)++0x03
  line.long    0x00 "CR8,eTPU A Channel 8 Configuration Register"
  bitfld.long  0x00 31.                  "CIE ,Channel interrupt enable" "0,1"
  bitfld.long  0x00 30.                  "  DTRE ,Channel data transfer request enable" "0,1"
  bitfld.long  0x00 28.--29.             "  CPR ,Channel priority" "dis,low,mid,high"
  bitfld.long  0x00 25.                  "  ETPD ,This bit selects which channel signal, input or output, is used in the entry point selection" "PSTI,PSTO"
  bitfld.long  0x00 24.                  "  ETCS ,Entry table condition select" "std,alt"
  bitfld.long  0x00 16.--20.             "  CFS ,Channel function select" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
  bitfld.long  0x00 15.                  "  ODIS ,Output disable" "0,1"
TEXTLINE "                "  
  bitfld.long  0x00 14.                  "  OPOL ,Output polarity" "act. low,act. high"
  hexmask.long.word 0x00 00.--10. 2.     " CPBA_eTPU ,channel parameter base address - eTPU addressing"
  hexmask.long.word 0x00 00.--10. 8.     "       CPBA_host ,channel parameter base address - host (byte) addressing"
  textfld "    "   
  button "Data.dump CHBASE" "Data.Dump ANC:(0xC3FC8000+((Data.Long(ANC:0xC3FC0400+0x100*0.+0x10*8.)&0x3FF)*8.)) /DIALOG"

group.long (0xC3FC0404+0x100*0.+0x10*8.)++0x03
  line.long    0x00 "SCR8,eTPU A Channel 8 Status Control Register"
  eventfld.long  0x00 31.                  "CIS ,Channel interrupt (w1c)" "0,1"
  eventfld.long  0x00 30.                  "  CIOS ,Channel interrupt overflow status (w1c)" "0,1"
  eventfld.long  0x00 23.                  "  DTRS ,Data transfer request status (w1c)" "0,1"
  eventfld.long  0x00 22.                  "    DTROS ,Data transfer request overflow status (w1c)" "0,1"
  bitfld.long  0x00 15.                  "    IPS  ,Channel input pin state" "0,1"
  bitfld.long  0x00 14.                  "    OPS ,Channel output pin state" "0,1"
  bitfld.long  0x00 00.--01.             "   FM   ,Channel function mode" "0,1,2,3"

group.long (0xC3FC0408+0x100*0.+0x10*8.)++0x03
  line.long    0x00 "HSRR8,eTPU A Channel 8 Host Service Request Register"
  bitfld.long  0x00 00.--02.             "HSR ,Host service request" "0,1,2,3,4,5,6,7"


TEXTLINE ""


group.long (0xC3FC0400+0x100*0.+0x10*9.)++0x03
  line.long    0x00 "CR9,eTPU A Channel 9 Configuration Register"
  bitfld.long  0x00 31.                  "CIE ,Channel interrupt enable" "0,1"
  bitfld.long  0x00 30.                  "  DTRE ,Channel data transfer request enable" "0,1"
  bitfld.long  0x00 28.--29.             "  CPR ,Channel priority" "dis,low,mid,high"
  bitfld.long  0x00 25.                  "  ETPD ,This bit selects which channel signal, input or output, is used in the entry point selection" "PSTI,PSTO"
  bitfld.long  0x00 24.                  "  ETCS ,Entry table condition select" "std,alt"
  bitfld.long  0x00 16.--20.             "  CFS ,Channel function select" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
  bitfld.long  0x00 15.                  "  ODIS ,Output disable" "0,1"
TEXTLINE "                "  
  bitfld.long  0x00 14.                  "  OPOL ,Output polarity" "act. low,act. high"
  hexmask.long.word 0x00 00.--10. 2.     " CPBA_eTPU ,channel parameter base address - eTPU addressing"
  hexmask.long.word 0x00 00.--10. 8.     "       CPBA_host ,channel parameter base address - host (byte) addressing"
  textfld "    "   
  button "Data.dump CHBASE" "Data.Dump ANC:(0xC3FC8000+((Data.Long(ANC:0xC3FC0400+0x100*0.+0x10*9.)&0x3FF)*8.)) /DIALOG"

group.long (0xC3FC0404+0x100*0.+0x10*9.)++0x03
  line.long    0x00 "SCR9,eTPU A Channel 9 Status Control Register"
  eventfld.long  0x00 31.                  "CIS ,Channel interrupt (w1c)" "0,1"
  eventfld.long  0x00 30.                  "  CIOS ,Channel interrupt overflow status (w1c)" "0,1"
  eventfld.long  0x00 23.                  "  DTRS ,Data transfer request status (w1c)" "0,1"
  eventfld.long  0x00 22.                  "    DTROS ,Data transfer request overflow status (w1c)" "0,1"
  bitfld.long  0x00 15.                  "    IPS  ,Channel input pin state" "0,1"
  bitfld.long  0x00 14.                  "    OPS ,Channel output pin state" "0,1"
  bitfld.long  0x00 00.--01.             "   FM   ,Channel function mode" "0,1,2,3"

group.long (0xC3FC0408+0x100*0.+0x10*9.)++0x03
  line.long    0x00 "HSRR9,eTPU A Channel 9 Host Service Request Register"
  bitfld.long  0x00 00.--02.             "HSR ,Host service request" "0,1,2,3,4,5,6,7"


TEXTLINE ""


group.long (0xC3FC0400+0x100*0.+0x10*10.)++0x03
  line.long    0x00 "CR10,eTPU A Channel 10 Configuration Register"
  bitfld.long  0x00 31.                  "CIE ,Channel interrupt enable" "0,1"
  bitfld.long  0x00 30.                  "  DTRE ,Channel data transfer request enable" "0,1"
  bitfld.long  0x00 28.--29.             "  CPR ,Channel priority" "dis,low,mid,high"
  bitfld.long  0x00 25.                  "  ETPD ,This bit selects which channel signal, input or output, is used in the entry point selection" "PSTI,PSTO"
  bitfld.long  0x00 24.                  "  ETCS ,Entry table condition select" "std,alt"
  bitfld.long  0x00 16.--20.             "  CFS ,Channel function select" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
  bitfld.long  0x00 15.                  "  ODIS ,Output disable" "0,1"
TEXTLINE "                "  
  bitfld.long  0x00 14.                  "  OPOL ,Output polarity" "act. low,act. high"
  hexmask.long.word 0x00 00.--10. 2.     " CPBA_eTPU ,channel parameter base address - eTPU addressing"
  hexmask.long.word 0x00 00.--10. 8.     "       CPBA_host ,channel parameter base address - host (byte) addressing"
  textfld "    "   
  button "Data.dump CHBASE" "Data.Dump ANC:(0xC3FC8000+((Data.Long(ANC:0xC3FC0400+0x100*0.+0x10*10.)&0x3FF)*8.)) /DIALOG"

group.long (0xC3FC0404+0x100*0.+0x10*10.)++0x03
  line.long    0x00 "SCR10,eTPU A Channel 10 Status Control Register"
  eventfld.long  0x00 31.                  "CIS ,Channel interrupt (w1c)" "0,1"
  eventfld.long  0x00 30.                  "  CIOS ,Channel interrupt overflow status (w1c)" "0,1"
  eventfld.long  0x00 23.                  "  DTRS ,Data transfer request status (w1c)" "0,1"
  eventfld.long  0x00 22.                  "    DTROS ,Data transfer request overflow status (w1c)" "0,1"
  bitfld.long  0x00 15.                  "    IPS  ,Channel input pin state" "0,1"
  bitfld.long  0x00 14.                  "    OPS ,Channel output pin state" "0,1"
  bitfld.long  0x00 00.--01.             "   FM   ,Channel function mode" "0,1,2,3"

group.long (0xC3FC0408+0x100*0.+0x10*10.)++0x03
  line.long    0x00 "HSRR10,eTPU A Channel 10 Host Service Request Register"
  bitfld.long  0x00 00.--02.             "HSR ,Host service request" "0,1,2,3,4,5,6,7"


TEXTLINE ""


group.long (0xC3FC0400+0x100*0.+0x10*11.)++0x03
  line.long    0x00 "CR11,eTPU A Channel 11 Configuration Register"
  bitfld.long  0x00 31.                  "CIE ,Channel interrupt enable" "0,1"
  bitfld.long  0x00 30.                  "  DTRE ,Channel data transfer request enable" "0,1"
  bitfld.long  0x00 28.--29.             "  CPR ,Channel priority" "dis,low,mid,high"
  bitfld.long  0x00 25.                  "  ETPD ,This bit selects which channel signal, input or output, is used in the entry point selection" "PSTI,PSTO"
  bitfld.long  0x00 24.                  "  ETCS ,Entry table condition select" "std,alt"
  bitfld.long  0x00 16.--20.             "  CFS ,Channel function select" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
  bitfld.long  0x00 15.                  "  ODIS ,Output disable" "0,1"
TEXTLINE "                "  
  bitfld.long  0x00 14.                  "  OPOL ,Output polarity" "act. low,act. high"
  hexmask.long.word 0x00 00.--10. 2.     " CPBA_eTPU ,channel parameter base address - eTPU addressing"
  hexmask.long.word 0x00 00.--10. 8.     "       CPBA_host ,channel parameter base address - host (byte) addressing"
  textfld "    "   
  button "Data.dump CHBASE" "Data.Dump ANC:(0xC3FC8000+((Data.Long(ANC:0xC3FC0400+0x100*0.+0x10*11.)&0x3FF)*8.)) /DIALOG"

group.long (0xC3FC0404+0x100*0.+0x10*11.)++0x03
  line.long    0x00 "SCR11,eTPU A Channel 11 Status Control Register"
  eventfld.long  0x00 31.                  "CIS ,Channel interrupt (w1c)" "0,1"
  eventfld.long  0x00 30.                  "  CIOS ,Channel interrupt overflow status (w1c)" "0,1"
  eventfld.long  0x00 23.                  "  DTRS ,Data transfer request status (w1c)" "0,1"
  eventfld.long  0x00 22.                  "    DTROS ,Data transfer request overflow status (w1c)" "0,1"
  bitfld.long  0x00 15.                  "    IPS  ,Channel input pin state" "0,1"
  bitfld.long  0x00 14.                  "    OPS ,Channel output pin state" "0,1"
  bitfld.long  0x00 00.--01.             "   FM   ,Channel function mode" "0,1,2,3"

group.long (0xC3FC0408+0x100*0.+0x10*11.)++0x03
  line.long    0x00 "HSRR11,eTPU A Channel 11 Host Service Request Register"
  bitfld.long  0x00 00.--02.             "HSR ,Host service request" "0,1,2,3,4,5,6,7"


TEXTLINE ""


group.long (0xC3FC0400+0x100*0.+0x10*12.)++0x03
  line.long    0x00 "CR12,eTPU A Channel 12 Configuration Register"
  bitfld.long  0x00 31.                  "CIE ,Channel interrupt enable" "0,1"
  bitfld.long  0x00 30.                  "  DTRE ,Channel data transfer request enable" "0,1"
  bitfld.long  0x00 28.--29.             "  CPR ,Channel priority" "dis,low,mid,high"
  bitfld.long  0x00 25.                  "  ETPD ,This bit selects which channel signal, input or output, is used in the entry point selection" "PSTI,PSTO"
  bitfld.long  0x00 24.                  "  ETCS ,Entry table condition select" "std,alt"
  bitfld.long  0x00 16.--20.             "  CFS ,Channel function select" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
  bitfld.long  0x00 15.                  "  ODIS ,Output disable" "0,1"
TEXTLINE "                "  
  bitfld.long  0x00 14.                  "  OPOL ,Output polarity" "act. low,act. high"
  hexmask.long.word 0x00 00.--10. 2.     " CPBA_eTPU ,channel parameter base address - eTPU addressing"
  hexmask.long.word 0x00 00.--10. 8.     "       CPBA_host ,channel parameter base address - host (byte) addressing"
  textfld "    "   
  button "Data.dump CHBASE" "Data.Dump ANC:(0xC3FC8000+((Data.Long(ANC:0xC3FC0400+0x100*0.+0x10*12.)&0x3FF)*8.)) /DIALOG"

group.long (0xC3FC0404+0x100*0.+0x10*12.)++0x03
  line.long    0x00 "SCR12,eTPU A Channel 12 Status Control Register"
  eventfld.long  0x00 31.                  "CIS ,Channel interrupt (w1c)" "0,1"
  eventfld.long  0x00 30.                  "  CIOS ,Channel interrupt overflow status (w1c)" "0,1"
  eventfld.long  0x00 23.                  "  DTRS ,Data transfer request status (w1c)" "0,1"
  eventfld.long  0x00 22.                  "    DTROS ,Data transfer request overflow status (w1c)" "0,1"
  bitfld.long  0x00 15.                  "    IPS  ,Channel input pin state" "0,1"
  bitfld.long  0x00 14.                  "    OPS ,Channel output pin state" "0,1"
  bitfld.long  0x00 00.--01.             "   FM   ,Channel function mode" "0,1,2,3"

group.long (0xC3FC0408+0x100*0.+0x10*12.)++0x03
  line.long    0x00 "HSRR12,eTPU A Channel 12 Host Service Request Register"
  bitfld.long  0x00 00.--02.             "HSR ,Host service request" "0,1,2,3,4,5,6,7"


TEXTLINE ""


group.long (0xC3FC0400+0x100*0.+0x10*13.)++0x03
  line.long    0x00 "CR13,eTPU A Channel 13 Configuration Register"
  bitfld.long  0x00 31.                  "CIE ,Channel interrupt enable" "0,1"
  bitfld.long  0x00 30.                  "  DTRE ,Channel data transfer request enable" "0,1"
  bitfld.long  0x00 28.--29.             "  CPR ,Channel priority" "dis,low,mid,high"
  bitfld.long  0x00 25.                  "  ETPD ,This bit selects which channel signal, input or output, is used in the entry point selection" "PSTI,PSTO"
  bitfld.long  0x00 24.                  "  ETCS ,Entry table condition select" "std,alt"
  bitfld.long  0x00 16.--20.             "  CFS ,Channel function select" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
  bitfld.long  0x00 15.                  "  ODIS ,Output disable" "0,1"
TEXTLINE "                "  
  bitfld.long  0x00 14.                  "  OPOL ,Output polarity" "act. low,act. high"
  hexmask.long.word 0x00 00.--10. 2.     " CPBA_eTPU ,channel parameter base address - eTPU addressing"
  hexmask.long.word 0x00 00.--10. 8.     "       CPBA_host ,channel parameter base address - host (byte) addressing"
  textfld "    "   
  button "Data.dump CHBASE" "Data.Dump ANC:(0xC3FC8000+((Data.Long(ANC:0xC3FC0400+0x100*0.+0x10*13.)&0x3FF)*8.)) /DIALOG"

group.long (0xC3FC0404+0x100*0.+0x10*13.)++0x03
  line.long    0x00 "SCR13,eTPU A Channel 13 Status Control Register"
  eventfld.long  0x00 31.                  "CIS ,Channel interrupt (w1c)" "0,1"
  eventfld.long  0x00 30.                  "  CIOS ,Channel interrupt overflow status (w1c)" "0,1"
  eventfld.long  0x00 23.                  "  DTRS ,Data transfer request status (w1c)" "0,1"
  eventfld.long  0x00 22.                  "    DTROS ,Data transfer request overflow status (w1c)" "0,1"
  bitfld.long  0x00 15.                  "    IPS  ,Channel input pin state" "0,1"
  bitfld.long  0x00 14.                  "    OPS ,Channel output pin state" "0,1"
  bitfld.long  0x00 00.--01.             "   FM   ,Channel function mode" "0,1,2,3"

group.long (0xC3FC0408+0x100*0.+0x10*13.)++0x03
  line.long    0x00 "HSRR13,eTPU A Channel 13 Host Service Request Register"
  bitfld.long  0x00 00.--02.             "HSR ,Host service request" "0,1,2,3,4,5,6,7"


TEXTLINE ""


group.long (0xC3FC0400+0x100*0.+0x10*14.)++0x03
  line.long    0x00 "CR14,eTPU A Channel 14 Configuration Register"
  bitfld.long  0x00 31.                  "CIE ,Channel interrupt enable" "0,1"
  bitfld.long  0x00 30.                  "  DTRE ,Channel data transfer request enable" "0,1"
  bitfld.long  0x00 28.--29.             "  CPR ,Channel priority" "dis,low,mid,high"
  bitfld.long  0x00 25.                  "  ETPD ,This bit selects which channel signal, input or output, is used in the entry point selection" "PSTI,PSTO"
  bitfld.long  0x00 24.                  "  ETCS ,Entry table condition select" "std,alt"
  bitfld.long  0x00 16.--20.             "  CFS ,Channel function select" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
  bitfld.long  0x00 15.                  "  ODIS ,Output disable" "0,1"
TEXTLINE "                "  
  bitfld.long  0x00 14.                  "  OPOL ,Output polarity" "act. low,act. high"
  hexmask.long.word 0x00 00.--10. 2.     " CPBA_eTPU ,channel parameter base address - eTPU addressing"
  hexmask.long.word 0x00 00.--10. 8.     "       CPBA_host ,channel parameter base address - host (byte) addressing"
  textfld "    "   
  button "Data.dump CHBASE" "Data.Dump ANC:(0xC3FC8000+((Data.Long(ANC:0xC3FC0400+0x100*0.+0x10*14.)&0x3FF)*8.)) /DIALOG"

group.long (0xC3FC0404+0x100*0.+0x10*14.)++0x03
  line.long    0x00 "SCR14,eTPU A Channel 14 Status Control Register"
  eventfld.long  0x00 31.                  "CIS ,Channel interrupt (w1c)" "0,1"
  eventfld.long  0x00 30.                  "  CIOS ,Channel interrupt overflow status (w1c)" "0,1"
  eventfld.long  0x00 23.                  "  DTRS ,Data transfer request status (w1c)" "0,1"
  eventfld.long  0x00 22.                  "    DTROS ,Data transfer request overflow status (w1c)" "0,1"
  bitfld.long  0x00 15.                  "    IPS  ,Channel input pin state" "0,1"
  bitfld.long  0x00 14.                  "    OPS ,Channel output pin state" "0,1"
  bitfld.long  0x00 00.--01.             "   FM   ,Channel function mode" "0,1,2,3"

group.long (0xC3FC0408+0x100*0.+0x10*14.)++0x03
  line.long    0x00 "HSRR14,eTPU A Channel 14 Host Service Request Register"
  bitfld.long  0x00 00.--02.             "HSR ,Host service request" "0,1,2,3,4,5,6,7"


TEXTLINE ""


group.long (0xC3FC0400+0x100*0.+0x10*15.)++0x03
  line.long    0x00 "CR15,eTPU A Channel 15 Configuration Register"
  bitfld.long  0x00 31.                  "CIE ,Channel interrupt enable" "0,1"
  bitfld.long  0x00 30.                  "  DTRE ,Channel data transfer request enable" "0,1"
  bitfld.long  0x00 28.--29.             "  CPR ,Channel priority" "dis,low,mid,high"
  bitfld.long  0x00 25.                  "  ETPD ,This bit selects which channel signal, input or output, is used in the entry point selection" "PSTI,PSTO"
  bitfld.long  0x00 24.                  "  ETCS ,Entry table condition select" "std,alt"
  bitfld.long  0x00 16.--20.             "  CFS ,Channel function select" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
  bitfld.long  0x00 15.                  "  ODIS ,Output disable" "0,1"
TEXTLINE "                "  
  bitfld.long  0x00 14.                  "  OPOL ,Output polarity" "act. low,act. high"
  hexmask.long.word 0x00 00.--10. 2.     " CPBA_eTPU ,channel parameter base address - eTPU addressing"
  hexmask.long.word 0x00 00.--10. 8.     "       CPBA_host ,channel parameter base address - host (byte) addressing"
  textfld "    "   
  button "Data.dump CHBASE" "Data.Dump ANC:(0xC3FC8000+((Data.Long(ANC:0xC3FC0400+0x100*0.+0x10*15.)&0x3FF)*8.)) /DIALOG"

group.long (0xC3FC0404+0x100*0.+0x10*15.)++0x03
  line.long    0x00 "SCR15,eTPU A Channel 15 Status Control Register"
  eventfld.long  0x00 31.                  "CIS ,Channel interrupt (w1c)" "0,1"
  eventfld.long  0x00 30.                  "  CIOS ,Channel interrupt overflow status (w1c)" "0,1"
  eventfld.long  0x00 23.                  "  DTRS ,Data transfer request status (w1c)" "0,1"
  eventfld.long  0x00 22.                  "    DTROS ,Data transfer request overflow status (w1c)" "0,1"
  bitfld.long  0x00 15.                  "    IPS  ,Channel input pin state" "0,1"
  bitfld.long  0x00 14.                  "    OPS ,Channel output pin state" "0,1"
  bitfld.long  0x00 00.--01.             "   FM   ,Channel function mode" "0,1,2,3"

group.long (0xC3FC0408+0x100*0.+0x10*15.)++0x03
  line.long    0x00 "HSRR15,eTPU A Channel 15 Host Service Request Register"
  bitfld.long  0x00 00.--02.             "HSR ,Host service request" "0,1,2,3,4,5,6,7"


TEXTLINE ""


group.long (0xC3FC0400+0x100*0.+0x10*16.)++0x03
  line.long    0x00 "CR16,eTPU A Channel 16 Configuration Register"
  bitfld.long  0x00 31.                  "CIE ,Channel interrupt enable" "0,1"
  bitfld.long  0x00 30.                  "  DTRE ,Channel data transfer request enable" "0,1"
  bitfld.long  0x00 28.--29.             "  CPR ,Channel priority" "dis,low,mid,high"
  bitfld.long  0x00 25.                  "  ETPD ,This bit selects which channel signal, input or output, is used in the entry point selection" "PSTI,PSTO"
  bitfld.long  0x00 24.                  "  ETCS ,Entry table condition select" "std,alt"
  bitfld.long  0x00 16.--20.             "  CFS ,Channel function select" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
  bitfld.long  0x00 15.                  "  ODIS ,Output disable" "0,1"
TEXTLINE "                "  
  bitfld.long  0x00 14.                  "  OPOL ,Output polarity" "act. low,act. high"
  hexmask.long.word 0x00 00.--10. 2.     " CPBA_eTPU ,channel parameter base address - eTPU addressing"
  hexmask.long.word 0x00 00.--10. 8.     "       CPBA_host ,channel parameter base address - host (byte) addressing"
  textfld "    "   
  button "Data.dump CHBASE" "Data.Dump ANC:(0xC3FC8000+((Data.Long(ANC:0xC3FC0400+0x100*0.+0x10*16.)&0x3FF)*8.)) /DIALOG"

group.long (0xC3FC0404+0x100*0.+0x10*16.)++0x03
  line.long    0x00 "SCR16,eTPU A Channel 16 Status Control Register"
  eventfld.long  0x00 31.                  "CIS ,Channel interrupt (w1c)" "0,1"
  eventfld.long  0x00 30.                  "  CIOS ,Channel interrupt overflow status (w1c)" "0,1"
  eventfld.long  0x00 23.                  "  DTRS ,Data transfer request status (w1c)" "0,1"
  eventfld.long  0x00 22.                  "    DTROS ,Data transfer request overflow status (w1c)" "0,1"
  bitfld.long  0x00 15.                  "    IPS  ,Channel input pin state" "0,1"
  bitfld.long  0x00 14.                  "    OPS ,Channel output pin state" "0,1"
  bitfld.long  0x00 00.--01.             "   FM   ,Channel function mode" "0,1,2,3"

group.long (0xC3FC0408+0x100*0.+0x10*16.)++0x03
  line.long    0x00 "HSRR16,eTPU A Channel 16 Host Service Request Register"
  bitfld.long  0x00 00.--02.             "HSR ,Host service request" "0,1,2,3,4,5,6,7"


TEXTLINE ""


group.long (0xC3FC0400+0x100*0.+0x10*17.)++0x03
  line.long    0x00 "CR17,eTPU A Channel 17 Configuration Register"
  bitfld.long  0x00 31.                  "CIE ,Channel interrupt enable" "0,1"
  bitfld.long  0x00 30.                  "  DTRE ,Channel data transfer request enable" "0,1"
  bitfld.long  0x00 28.--29.             "  CPR ,Channel priority" "dis,low,mid,high"
  bitfld.long  0x00 25.                  "  ETPD ,This bit selects which channel signal, input or output, is used in the entry point selection" "PSTI,PSTO"
  bitfld.long  0x00 24.                  "  ETCS ,Entry table condition select" "std,alt"
  bitfld.long  0x00 16.--20.             "  CFS ,Channel function select" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
  bitfld.long  0x00 15.                  "  ODIS ,Output disable" "0,1"
TEXTLINE "                "  
  bitfld.long  0x00 14.                  "  OPOL ,Output polarity" "act. low,act. high"
  hexmask.long.word 0x00 00.--10. 2.     " CPBA_eTPU ,channel parameter base address - eTPU addressing"
  hexmask.long.word 0x00 00.--10. 8.     "       CPBA_host ,channel parameter base address - host (byte) addressing"
  textfld "    "   
  button "Data.dump CHBASE" "Data.Dump ANC:(0xC3FC8000+((Data.Long(ANC:0xC3FC0400+0x100*0.+0x10*17.)&0x3FF)*8.)) /DIALOG"

group.long (0xC3FC0404+0x100*0.+0x10*17.)++0x03
  line.long    0x00 "SCR17,eTPU A Channel 17 Status Control Register"
  eventfld.long  0x00 31.                  "CIS ,Channel interrupt (w1c)" "0,1"
  eventfld.long  0x00 30.                  "  CIOS ,Channel interrupt overflow status (w1c)" "0,1"
  eventfld.long  0x00 23.                  "  DTRS ,Data transfer request status (w1c)" "0,1"
  eventfld.long  0x00 22.                  "    DTROS ,Data transfer request overflow status (w1c)" "0,1"
  bitfld.long  0x00 15.                  "    IPS  ,Channel input pin state" "0,1"
  bitfld.long  0x00 14.                  "    OPS ,Channel output pin state" "0,1"
  bitfld.long  0x00 00.--01.             "   FM   ,Channel function mode" "0,1,2,3"

group.long (0xC3FC0408+0x100*0.+0x10*17.)++0x03
  line.long    0x00 "HSRR17,eTPU A Channel 17 Host Service Request Register"
  bitfld.long  0x00 00.--02.             "HSR ,Host service request" "0,1,2,3,4,5,6,7"


TEXTLINE ""


group.long (0xC3FC0400+0x100*0.+0x10*18.)++0x03
  line.long    0x00 "CR18,eTPU A Channel 18 Configuration Register"
  bitfld.long  0x00 31.                  "CIE ,Channel interrupt enable" "0,1"
  bitfld.long  0x00 30.                  "  DTRE ,Channel data transfer request enable" "0,1"
  bitfld.long  0x00 28.--29.             "  CPR ,Channel priority" "dis,low,mid,high"
  bitfld.long  0x00 25.                  "  ETPD ,This bit selects which channel signal, input or output, is used in the entry point selection" "PSTI,PSTO"
  bitfld.long  0x00 24.                  "  ETCS ,Entry table condition select" "std,alt"
  bitfld.long  0x00 16.--20.             "  CFS ,Channel function select" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
  bitfld.long  0x00 15.                  "  ODIS ,Output disable" "0,1"
TEXTLINE "                "  
  bitfld.long  0x00 14.                  "  OPOL ,Output polarity" "act. low,act. high"
  hexmask.long.word 0x00 00.--10. 2.     " CPBA_eTPU ,channel parameter base address - eTPU addressing"
  hexmask.long.word 0x00 00.--10. 8.     "       CPBA_host ,channel parameter base address - host (byte) addressing"
  textfld "    "   
  button "Data.dump CHBASE" "Data.Dump ANC:(0xC3FC8000+((Data.Long(ANC:0xC3FC0400+0x100*0.+0x10*18.)&0x3FF)*8.)) /DIALOG"

group.long (0xC3FC0404+0x100*0.+0x10*18.)++0x03
  line.long    0x00 "SCR18,eTPU A Channel 18 Status Control Register"
  eventfld.long  0x00 31.                  "CIS ,Channel interrupt (w1c)" "0,1"
  eventfld.long  0x00 30.                  "  CIOS ,Channel interrupt overflow status (w1c)" "0,1"
  eventfld.long  0x00 23.                  "  DTRS ,Data transfer request status (w1c)" "0,1"
  eventfld.long  0x00 22.                  "    DTROS ,Data transfer request overflow status (w1c)" "0,1"
  bitfld.long  0x00 15.                  "    IPS  ,Channel input pin state" "0,1"
  bitfld.long  0x00 14.                  "    OPS ,Channel output pin state" "0,1"
  bitfld.long  0x00 00.--01.             "   FM   ,Channel function mode" "0,1,2,3"

group.long (0xC3FC0408+0x100*0.+0x10*18.)++0x03
  line.long    0x00 "HSRR18,eTPU A Channel 18 Host Service Request Register"
  bitfld.long  0x00 00.--02.             "HSR ,Host service request" "0,1,2,3,4,5,6,7"


TEXTLINE ""


group.long (0xC3FC0400+0x100*0.+0x10*19.)++0x03
  line.long    0x00 "CR19,eTPU A Channel 19 Configuration Register"
  bitfld.long  0x00 31.                  "CIE ,Channel interrupt enable" "0,1"
  bitfld.long  0x00 30.                  "  DTRE ,Channel data transfer request enable" "0,1"
  bitfld.long  0x00 28.--29.             "  CPR ,Channel priority" "dis,low,mid,high"
  bitfld.long  0x00 25.                  "  ETPD ,This bit selects which channel signal, input or output, is used in the entry point selection" "PSTI,PSTO"
  bitfld.long  0x00 24.                  "  ETCS ,Entry table condition select" "std,alt"
  bitfld.long  0x00 16.--20.             "  CFS ,Channel function select" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
  bitfld.long  0x00 15.                  "  ODIS ,Output disable" "0,1"
TEXTLINE "                "  
  bitfld.long  0x00 14.                  "  OPOL ,Output polarity" "act. low,act. high"
  hexmask.long.word 0x00 00.--10. 2.     " CPBA_eTPU ,channel parameter base address - eTPU addressing"
  hexmask.long.word 0x00 00.--10. 8.     "       CPBA_host ,channel parameter base address - host (byte) addressing"
  textfld "    "   
  button "Data.dump CHBASE" "Data.Dump ANC:(0xC3FC8000+((Data.Long(ANC:0xC3FC0400+0x100*0.+0x10*19.)&0x3FF)*8.)) /DIALOG"

group.long (0xC3FC0404+0x100*0.+0x10*19.)++0x03
  line.long    0x00 "SCR19,eTPU A Channel 19 Status Control Register"
  eventfld.long  0x00 31.                  "CIS ,Channel interrupt (w1c)" "0,1"
  eventfld.long  0x00 30.                  "  CIOS ,Channel interrupt overflow status (w1c)" "0,1"
  eventfld.long  0x00 23.                  "  DTRS ,Data transfer request status (w1c)" "0,1"
  eventfld.long  0x00 22.                  "    DTROS ,Data transfer request overflow status (w1c)" "0,1"
  bitfld.long  0x00 15.                  "    IPS  ,Channel input pin state" "0,1"
  bitfld.long  0x00 14.                  "    OPS ,Channel output pin state" "0,1"
  bitfld.long  0x00 00.--01.             "   FM   ,Channel function mode" "0,1,2,3"

group.long (0xC3FC0408+0x100*0.+0x10*19.)++0x03
  line.long    0x00 "HSRR19,eTPU A Channel 19 Host Service Request Register"
  bitfld.long  0x00 00.--02.             "HSR ,Host service request" "0,1,2,3,4,5,6,7"


TEXTLINE ""


group.long (0xC3FC0400+0x100*0.+0x10*20.)++0x03
  line.long    0x00 "CR20,eTPU A Channel 20 Configuration Register"
  bitfld.long  0x00 31.                  "CIE ,Channel interrupt enable" "0,1"
  bitfld.long  0x00 30.                  "  DTRE ,Channel data transfer request enable" "0,1"
  bitfld.long  0x00 28.--29.             "  CPR ,Channel priority" "dis,low,mid,high"
  bitfld.long  0x00 25.                  "  ETPD ,This bit selects which channel signal, input or output, is used in the entry point selection" "PSTI,PSTO"
  bitfld.long  0x00 24.                  "  ETCS ,Entry table condition select" "std,alt"
  bitfld.long  0x00 16.--20.             "  CFS ,Channel function select" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
  bitfld.long  0x00 15.                  "  ODIS ,Output disable" "0,1"
TEXTLINE "                "  
  bitfld.long  0x00 14.                  "  OPOL ,Output polarity" "act. low,act. high"
  hexmask.long.word 0x00 00.--10. 2.     " CPBA_eTPU ,channel parameter base address - eTPU addressing"
  hexmask.long.word 0x00 00.--10. 8.     "       CPBA_host ,channel parameter base address - host (byte) addressing"
  textfld "    "   
  button "Data.dump CHBASE" "Data.Dump ANC:(0xC3FC8000+((Data.Long(ANC:0xC3FC0400+0x100*0.+0x10*20.)&0x3FF)*8.)) /DIALOG"

group.long (0xC3FC0404+0x100*0.+0x10*20.)++0x03
  line.long    0x00 "SCR20,eTPU A Channel 20 Status Control Register"
  eventfld.long  0x00 31.                  "CIS ,Channel interrupt (w1c)" "0,1"
  eventfld.long  0x00 30.                  "  CIOS ,Channel interrupt overflow status (w1c)" "0,1"
  eventfld.long  0x00 23.                  "  DTRS ,Data transfer request status (w1c)" "0,1"
  eventfld.long  0x00 22.                  "    DTROS ,Data transfer request overflow status (w1c)" "0,1"
  bitfld.long  0x00 15.                  "    IPS  ,Channel input pin state" "0,1"
  bitfld.long  0x00 14.                  "    OPS ,Channel output pin state" "0,1"
  bitfld.long  0x00 00.--01.             "   FM   ,Channel function mode" "0,1,2,3"

group.long (0xC3FC0408+0x100*0.+0x10*20.)++0x03
  line.long    0x00 "HSRR20,eTPU A Channel 20 Host Service Request Register"
  bitfld.long  0x00 00.--02.             "HSR ,Host service request" "0,1,2,3,4,5,6,7"


TEXTLINE ""


group.long (0xC3FC0400+0x100*0.+0x10*21.)++0x03
  line.long    0x00 "CR21,eTPU A Channel 21 Configuration Register"
  bitfld.long  0x00 31.                  "CIE ,Channel interrupt enable" "0,1"
  bitfld.long  0x00 30.                  "  DTRE ,Channel data transfer request enable" "0,1"
  bitfld.long  0x00 28.--29.             "  CPR ,Channel priority" "dis,low,mid,high"
  bitfld.long  0x00 25.                  "  ETPD ,This bit selects which channel signal, input or output, is used in the entry point selection" "PSTI,PSTO"
  bitfld.long  0x00 24.                  "  ETCS ,Entry table condition select" "std,alt"
  bitfld.long  0x00 16.--20.             "  CFS ,Channel function select" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
  bitfld.long  0x00 15.                  "  ODIS ,Output disable" "0,1"
TEXTLINE "                "  
  bitfld.long  0x00 14.                  "  OPOL ,Output polarity" "act. low,act. high"
  hexmask.long.word 0x00 00.--10. 2.     " CPBA_eTPU ,channel parameter base address - eTPU addressing"
  hexmask.long.word 0x00 00.--10. 8.     "       CPBA_host ,channel parameter base address - host (byte) addressing"
  textfld "    "   
  button "Data.dump CHBASE" "Data.Dump ANC:(0xC3FC8000+((Data.Long(ANC:0xC3FC0400+0x100*0.+0x10*21.)&0x3FF)*8.)) /DIALOG"

group.long (0xC3FC0404+0x100*0.+0x10*21.)++0x03
  line.long    0x00 "SCR21,eTPU A Channel 21 Status Control Register"
  eventfld.long  0x00 31.                  "CIS ,Channel interrupt (w1c)" "0,1"
  eventfld.long  0x00 30.                  "  CIOS ,Channel interrupt overflow status (w1c)" "0,1"
  eventfld.long  0x00 23.                  "  DTRS ,Data transfer request status (w1c)" "0,1"
  eventfld.long  0x00 22.                  "    DTROS ,Data transfer request overflow status (w1c)" "0,1"
  bitfld.long  0x00 15.                  "    IPS  ,Channel input pin state" "0,1"
  bitfld.long  0x00 14.                  "    OPS ,Channel output pin state" "0,1"
  bitfld.long  0x00 00.--01.             "   FM   ,Channel function mode" "0,1,2,3"

group.long (0xC3FC0408+0x100*0.+0x10*21.)++0x03
  line.long    0x00 "HSRR21,eTPU A Channel 21 Host Service Request Register"
  bitfld.long  0x00 00.--02.             "HSR ,Host service request" "0,1,2,3,4,5,6,7"


TEXTLINE ""


group.long (0xC3FC0400+0x100*0.+0x10*22.)++0x03
  line.long    0x00 "CR22,eTPU A Channel 22 Configuration Register"
  bitfld.long  0x00 31.                  "CIE ,Channel interrupt enable" "0,1"
  bitfld.long  0x00 30.                  "  DTRE ,Channel data transfer request enable" "0,1"
  bitfld.long  0x00 28.--29.             "  CPR ,Channel priority" "dis,low,mid,high"
  bitfld.long  0x00 25.                  "  ETPD ,This bit selects which channel signal, input or output, is used in the entry point selection" "PSTI,PSTO"
  bitfld.long  0x00 24.                  "  ETCS ,Entry table condition select" "std,alt"
  bitfld.long  0x00 16.--20.             "  CFS ,Channel function select" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
  bitfld.long  0x00 15.                  "  ODIS ,Output disable" "0,1"
TEXTLINE "                "  
  bitfld.long  0x00 14.                  "  OPOL ,Output polarity" "act. low,act. high"
  hexmask.long.word 0x00 00.--10. 2.     " CPBA_eTPU ,channel parameter base address - eTPU addressing"
  hexmask.long.word 0x00 00.--10. 8.     "       CPBA_host ,channel parameter base address - host (byte) addressing"
  textfld "    "   
  button "Data.dump CHBASE" "Data.Dump ANC:(0xC3FC8000+((Data.Long(ANC:0xC3FC0400+0x100*0.+0x10*22.)&0x3FF)*8.)) /DIALOG"

group.long (0xC3FC0404+0x100*0.+0x10*22.)++0x03
  line.long    0x00 "SCR22,eTPU A Channel 22 Status Control Register"
  eventfld.long  0x00 31.                  "CIS ,Channel interrupt (w1c)" "0,1"
  eventfld.long  0x00 30.                  "  CIOS ,Channel interrupt overflow status (w1c)" "0,1"
  eventfld.long  0x00 23.                  "  DTRS ,Data transfer request status (w1c)" "0,1"
  eventfld.long  0x00 22.                  "    DTROS ,Data transfer request overflow status (w1c)" "0,1"
  bitfld.long  0x00 15.                  "    IPS  ,Channel input pin state" "0,1"
  bitfld.long  0x00 14.                  "    OPS ,Channel output pin state" "0,1"
  bitfld.long  0x00 00.--01.             "   FM   ,Channel function mode" "0,1,2,3"

group.long (0xC3FC0408+0x100*0.+0x10*22.)++0x03
  line.long    0x00 "HSRR22,eTPU A Channel 22 Host Service Request Register"
  bitfld.long  0x00 00.--02.             "HSR ,Host service request" "0,1,2,3,4,5,6,7"


TEXTLINE ""


group.long (0xC3FC0400+0x100*0.+0x10*23.)++0x03
  line.long    0x00 "CR23,eTPU A Channel 23 Configuration Register"
  bitfld.long  0x00 31.                  "CIE ,Channel interrupt enable" "0,1"
  bitfld.long  0x00 30.                  "  DTRE ,Channel data transfer request enable" "0,1"
  bitfld.long  0x00 28.--29.             "  CPR ,Channel priority" "dis,low,mid,high"
  bitfld.long  0x00 25.                  "  ETPD ,This bit selects which channel signal, input or output, is used in the entry point selection" "PSTI,PSTO"
  bitfld.long  0x00 24.                  "  ETCS ,Entry table condition select" "std,alt"
  bitfld.long  0x00 16.--20.             "  CFS ,Channel function select" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
  bitfld.long  0x00 15.                  "  ODIS ,Output disable" "0,1"
TEXTLINE "                "  
  bitfld.long  0x00 14.                  "  OPOL ,Output polarity" "act. low,act. high"
  hexmask.long.word 0x00 00.--10. 2.     " CPBA_eTPU ,channel parameter base address - eTPU addressing"
  hexmask.long.word 0x00 00.--10. 8.     "       CPBA_host ,channel parameter base address - host (byte) addressing"
  textfld "    "   
  button "Data.dump CHBASE" "Data.Dump ANC:(0xC3FC8000+((Data.Long(ANC:0xC3FC0400+0x100*0.+0x10*23.)&0x3FF)*8.)) /DIALOG"

group.long (0xC3FC0404+0x100*0.+0x10*23.)++0x03
  line.long    0x00 "SCR23,eTPU A Channel 23 Status Control Register"
  eventfld.long  0x00 31.                  "CIS ,Channel interrupt (w1c)" "0,1"
  eventfld.long  0x00 30.                  "  CIOS ,Channel interrupt overflow status (w1c)" "0,1"
  eventfld.long  0x00 23.                  "  DTRS ,Data transfer request status (w1c)" "0,1"
  eventfld.long  0x00 22.                  "    DTROS ,Data transfer request overflow status (w1c)" "0,1"
  bitfld.long  0x00 15.                  "    IPS  ,Channel input pin state" "0,1"
  bitfld.long  0x00 14.                  "    OPS ,Channel output pin state" "0,1"
  bitfld.long  0x00 00.--01.             "   FM   ,Channel function mode" "0,1,2,3"

group.long (0xC3FC0408+0x100*0.+0x10*23.)++0x03
  line.long    0x00 "HSRR23,eTPU A Channel 23 Host Service Request Register"
  bitfld.long  0x00 00.--02.             "HSR ,Host service request" "0,1,2,3,4,5,6,7"


TEXTLINE ""


group.long (0xC3FC0400+0x100*0.+0x10*24.)++0x03
  line.long    0x00 "CR24,eTPU A Channel 24 Configuration Register"
  bitfld.long  0x00 31.                  "CIE ,Channel interrupt enable" "0,1"
  bitfld.long  0x00 30.                  "  DTRE ,Channel data transfer request enable" "0,1"
  bitfld.long  0x00 28.--29.             "  CPR ,Channel priority" "dis,low,mid,high"
  bitfld.long  0x00 25.                  "  ETPD ,This bit selects which channel signal, input or output, is used in the entry point selection" "PSTI,PSTO"
  bitfld.long  0x00 24.                  "  ETCS ,Entry table condition select" "std,alt"
  bitfld.long  0x00 16.--20.             "  CFS ,Channel function select" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
  bitfld.long  0x00 15.                  "  ODIS ,Output disable" "0,1"
TEXTLINE "                "  
  bitfld.long  0x00 14.                  "  OPOL ,Output polarity" "act. low,act. high"
  hexmask.long.word 0x00 00.--10. 2.     " CPBA_eTPU ,channel parameter base address - eTPU addressing"
  hexmask.long.word 0x00 00.--10. 8.     "       CPBA_host ,channel parameter base address - host (byte) addressing"
  textfld "    "   
  button "Data.dump CHBASE" "Data.Dump ANC:(0xC3FC8000+((Data.Long(ANC:0xC3FC0400+0x100*0.+0x10*24.)&0x3FF)*8.)) /DIALOG"

group.long (0xC3FC0404+0x100*0.+0x10*24.)++0x03
  line.long    0x00 "SCR24,eTPU A Channel 24 Status Control Register"
  eventfld.long  0x00 31.                  "CIS ,Channel interrupt (w1c)" "0,1"
  eventfld.long  0x00 30.                  "  CIOS ,Channel interrupt overflow status (w1c)" "0,1"
  eventfld.long  0x00 23.                  "  DTRS ,Data transfer request status (w1c)" "0,1"
  eventfld.long  0x00 22.                  "    DTROS ,Data transfer request overflow status (w1c)" "0,1"
  bitfld.long  0x00 15.                  "    IPS  ,Channel input pin state" "0,1"
  bitfld.long  0x00 14.                  "    OPS ,Channel output pin state" "0,1"
  bitfld.long  0x00 00.--01.             "   FM   ,Channel function mode" "0,1,2,3"

group.long (0xC3FC0408+0x100*0.+0x10*24.)++0x03
  line.long    0x00 "HSRR24,eTPU A Channel 24 Host Service Request Register"
  bitfld.long  0x00 00.--02.             "HSR ,Host service request" "0,1,2,3,4,5,6,7"


TEXTLINE ""


group.long (0xC3FC0400+0x100*0.+0x10*25.)++0x03
  line.long    0x00 "CR25,eTPU A Channel 25 Configuration Register"
  bitfld.long  0x00 31.                  "CIE ,Channel interrupt enable" "0,1"
  bitfld.long  0x00 30.                  "  DTRE ,Channel data transfer request enable" "0,1"
  bitfld.long  0x00 28.--29.             "  CPR ,Channel priority" "dis,low,mid,high"
  bitfld.long  0x00 25.                  "  ETPD ,This bit selects which channel signal, input or output, is used in the entry point selection" "PSTI,PSTO"
  bitfld.long  0x00 24.                  "  ETCS ,Entry table condition select" "std,alt"
  bitfld.long  0x00 16.--20.             "  CFS ,Channel function select" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
  bitfld.long  0x00 15.                  "  ODIS ,Output disable" "0,1"
TEXTLINE "                "  
  bitfld.long  0x00 14.                  "  OPOL ,Output polarity" "act. low,act. high"
  hexmask.long.word 0x00 00.--10. 2.     " CPBA_eTPU ,channel parameter base address - eTPU addressing"
  hexmask.long.word 0x00 00.--10. 8.     "       CPBA_host ,channel parameter base address - host (byte) addressing"
  textfld "    "   
  button "Data.dump CHBASE" "Data.Dump ANC:(0xC3FC8000+((Data.Long(ANC:0xC3FC0400+0x100*0.+0x10*25.)&0x3FF)*8.)) /DIALOG"

group.long (0xC3FC0404+0x100*0.+0x10*25.)++0x03
  line.long    0x00 "SCR25,eTPU A Channel 25 Status Control Register"
  eventfld.long  0x00 31.                  "CIS ,Channel interrupt (w1c)" "0,1"
  eventfld.long  0x00 30.                  "  CIOS ,Channel interrupt overflow status (w1c)" "0,1"
  eventfld.long  0x00 23.                  "  DTRS ,Data transfer request status (w1c)" "0,1"
  eventfld.long  0x00 22.                  "    DTROS ,Data transfer request overflow status (w1c)" "0,1"
  bitfld.long  0x00 15.                  "    IPS  ,Channel input pin state" "0,1"
  bitfld.long  0x00 14.                  "    OPS ,Channel output pin state" "0,1"
  bitfld.long  0x00 00.--01.             "   FM   ,Channel function mode" "0,1,2,3"

group.long (0xC3FC0408+0x100*0.+0x10*25.)++0x03
  line.long    0x00 "HSRR25,eTPU A Channel 25 Host Service Request Register"
  bitfld.long  0x00 00.--02.             "HSR ,Host service request" "0,1,2,3,4,5,6,7"


TEXTLINE ""


group.long (0xC3FC0400+0x100*0.+0x10*26.)++0x03
  line.long    0x00 "CR26,eTPU A Channel 26 Configuration Register"
  bitfld.long  0x00 31.                  "CIE ,Channel interrupt enable" "0,1"
  bitfld.long  0x00 30.                  "  DTRE ,Channel data transfer request enable" "0,1"
  bitfld.long  0x00 28.--29.             "  CPR ,Channel priority" "dis,low,mid,high"
  bitfld.long  0x00 25.                  "  ETPD ,This bit selects which channel signal, input or output, is used in the entry point selection" "PSTI,PSTO"
  bitfld.long  0x00 24.                  "  ETCS ,Entry table condition select" "std,alt"
  bitfld.long  0x00 16.--20.             "  CFS ,Channel function select" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
  bitfld.long  0x00 15.                  "  ODIS ,Output disable" "0,1"
TEXTLINE "                "  
  bitfld.long  0x00 14.                  "  OPOL ,Output polarity" "act. low,act. high"
  hexmask.long.word 0x00 00.--10. 2.     " CPBA_eTPU ,channel parameter base address - eTPU addressing"
  hexmask.long.word 0x00 00.--10. 8.     "       CPBA_host ,channel parameter base address - host (byte) addressing"
  textfld "    "   
  button "Data.dump CHBASE" "Data.Dump ANC:(0xC3FC8000+((Data.Long(ANC:0xC3FC0400+0x100*0.+0x10*26.)&0x3FF)*8.)) /DIALOG"

group.long (0xC3FC0404+0x100*0.+0x10*26.)++0x03
  line.long    0x00 "SCR26,eTPU A Channel 26 Status Control Register"
  eventfld.long  0x00 31.                  "CIS ,Channel interrupt (w1c)" "0,1"
  eventfld.long  0x00 30.                  "  CIOS ,Channel interrupt overflow status (w1c)" "0,1"
  eventfld.long  0x00 23.                  "  DTRS ,Data transfer request status (w1c)" "0,1"
  eventfld.long  0x00 22.                  "    DTROS ,Data transfer request overflow status (w1c)" "0,1"
  bitfld.long  0x00 15.                  "    IPS  ,Channel input pin state" "0,1"
  bitfld.long  0x00 14.                  "    OPS ,Channel output pin state" "0,1"
  bitfld.long  0x00 00.--01.             "   FM   ,Channel function mode" "0,1,2,3"

group.long (0xC3FC0408+0x100*0.+0x10*26.)++0x03
  line.long    0x00 "HSRR26,eTPU A Channel 26 Host Service Request Register"
  bitfld.long  0x00 00.--02.             "HSR ,Host service request" "0,1,2,3,4,5,6,7"


TEXTLINE ""


group.long (0xC3FC0400+0x100*0.+0x10*27.)++0x03
  line.long    0x00 "CR27,eTPU A Channel 27 Configuration Register"
  bitfld.long  0x00 31.                  "CIE ,Channel interrupt enable" "0,1"
  bitfld.long  0x00 30.                  "  DTRE ,Channel data transfer request enable" "0,1"
  bitfld.long  0x00 28.--29.             "  CPR ,Channel priority" "dis,low,mid,high"
  bitfld.long  0x00 25.                  "  ETPD ,This bit selects which channel signal, input or output, is used in the entry point selection" "PSTI,PSTO"
  bitfld.long  0x00 24.                  "  ETCS ,Entry table condition select" "std,alt"
  bitfld.long  0x00 16.--20.             "  CFS ,Channel function select" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
  bitfld.long  0x00 15.                  "  ODIS ,Output disable" "0,1"
TEXTLINE "                "  
  bitfld.long  0x00 14.                  "  OPOL ,Output polarity" "act. low,act. high"
  hexmask.long.word 0x00 00.--10. 2.     " CPBA_eTPU ,channel parameter base address - eTPU addressing"
  hexmask.long.word 0x00 00.--10. 8.     "       CPBA_host ,channel parameter base address - host (byte) addressing"
  textfld "    "   
  button "Data.dump CHBASE" "Data.Dump ANC:(0xC3FC8000+((Data.Long(ANC:0xC3FC0400+0x100*0.+0x10*27.)&0x3FF)*8.)) /DIALOG"

group.long (0xC3FC0404+0x100*0.+0x10*27.)++0x03
  line.long    0x00 "SCR27,eTPU A Channel 27 Status Control Register"
  eventfld.long  0x00 31.                  "CIS ,Channel interrupt (w1c)" "0,1"
  eventfld.long  0x00 30.                  "  CIOS ,Channel interrupt overflow status (w1c)" "0,1"
  eventfld.long  0x00 23.                  "  DTRS ,Data transfer request status (w1c)" "0,1"
  eventfld.long  0x00 22.                  "    DTROS ,Data transfer request overflow status (w1c)" "0,1"
  bitfld.long  0x00 15.                  "    IPS  ,Channel input pin state" "0,1"
  bitfld.long  0x00 14.                  "    OPS ,Channel output pin state" "0,1"
  bitfld.long  0x00 00.--01.             "   FM   ,Channel function mode" "0,1,2,3"

group.long (0xC3FC0408+0x100*0.+0x10*27.)++0x03
  line.long    0x00 "HSRR27,eTPU A Channel 27 Host Service Request Register"
  bitfld.long  0x00 00.--02.             "HSR ,Host service request" "0,1,2,3,4,5,6,7"


TEXTLINE ""


group.long (0xC3FC0400+0x100*0.+0x10*28.)++0x03
  line.long    0x00 "CR28,eTPU A Channel 28 Configuration Register"
  bitfld.long  0x00 31.                  "CIE ,Channel interrupt enable" "0,1"
  bitfld.long  0x00 30.                  "  DTRE ,Channel data transfer request enable" "0,1"
  bitfld.long  0x00 28.--29.             "  CPR ,Channel priority" "dis,low,mid,high"
  bitfld.long  0x00 25.                  "  ETPD ,This bit selects which channel signal, input or output, is used in the entry point selection" "PSTI,PSTO"
  bitfld.long  0x00 24.                  "  ETCS ,Entry table condition select" "std,alt"
  bitfld.long  0x00 16.--20.             "  CFS ,Channel function select" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
  bitfld.long  0x00 15.                  "  ODIS ,Output disable" "0,1"
TEXTLINE "                "  
  bitfld.long  0x00 14.                  "  OPOL ,Output polarity" "act. low,act. high"
  hexmask.long.word 0x00 00.--10. 2.     " CPBA_eTPU ,channel parameter base address - eTPU addressing"
  hexmask.long.word 0x00 00.--10. 8.     "       CPBA_host ,channel parameter base address - host (byte) addressing"
  textfld "    "   
  button "Data.dump CHBASE" "Data.Dump ANC:(0xC3FC8000+((Data.Long(ANC:0xC3FC0400+0x100*0.+0x10*28.)&0x3FF)*8.)) /DIALOG"

group.long (0xC3FC0404+0x100*0.+0x10*28.)++0x03
  line.long    0x00 "SCR28,eTPU A Channel 28 Status Control Register"
  eventfld.long  0x00 31.                  "CIS ,Channel interrupt (w1c)" "0,1"
  eventfld.long  0x00 30.                  "  CIOS ,Channel interrupt overflow status (w1c)" "0,1"
  eventfld.long  0x00 23.                  "  DTRS ,Data transfer request status (w1c)" "0,1"
  eventfld.long  0x00 22.                  "    DTROS ,Data transfer request overflow status (w1c)" "0,1"
  bitfld.long  0x00 15.                  "    IPS  ,Channel input pin state" "0,1"
  bitfld.long  0x00 14.                  "    OPS ,Channel output pin state" "0,1"
  bitfld.long  0x00 00.--01.             "   FM   ,Channel function mode" "0,1,2,3"

group.long (0xC3FC0408+0x100*0.+0x10*28.)++0x03
  line.long    0x00 "HSRR28,eTPU A Channel 28 Host Service Request Register"
  bitfld.long  0x00 00.--02.             "HSR ,Host service request" "0,1,2,3,4,5,6,7"


TEXTLINE ""


group.long (0xC3FC0400+0x100*0.+0x10*29.)++0x03
  line.long    0x00 "CR29,eTPU A Channel 29 Configuration Register"
  bitfld.long  0x00 31.                  "CIE ,Channel interrupt enable" "0,1"
  bitfld.long  0x00 30.                  "  DTRE ,Channel data transfer request enable" "0,1"
  bitfld.long  0x00 28.--29.             "  CPR ,Channel priority" "dis,low,mid,high"
  bitfld.long  0x00 25.                  "  ETPD ,This bit selects which channel signal, input or output, is used in the entry point selection" "PSTI,PSTO"
  bitfld.long  0x00 24.                  "  ETCS ,Entry table condition select" "std,alt"
  bitfld.long  0x00 16.--20.             "  CFS ,Channel function select" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
  bitfld.long  0x00 15.                  "  ODIS ,Output disable" "0,1"
TEXTLINE "                "  
  bitfld.long  0x00 14.                  "  OPOL ,Output polarity" "act. low,act. high"
  hexmask.long.word 0x00 00.--10. 2.     " CPBA_eTPU ,channel parameter base address - eTPU addressing"
  hexmask.long.word 0x00 00.--10. 8.     "       CPBA_host ,channel parameter base address - host (byte) addressing"
  textfld "    "   
  button "Data.dump CHBASE" "Data.Dump ANC:(0xC3FC8000+((Data.Long(ANC:0xC3FC0400+0x100*0.+0x10*29.)&0x3FF)*8.)) /DIALOG"

group.long (0xC3FC0404+0x100*0.+0x10*29.)++0x03
  line.long    0x00 "SCR29,eTPU A Channel 29 Status Control Register"
  eventfld.long  0x00 31.                  "CIS ,Channel interrupt (w1c)" "0,1"
  eventfld.long  0x00 30.                  "  CIOS ,Channel interrupt overflow status (w1c)" "0,1"
  eventfld.long  0x00 23.                  "  DTRS ,Data transfer request status (w1c)" "0,1"
  eventfld.long  0x00 22.                  "    DTROS ,Data transfer request overflow status (w1c)" "0,1"
  bitfld.long  0x00 15.                  "    IPS  ,Channel input pin state" "0,1"
  bitfld.long  0x00 14.                  "    OPS ,Channel output pin state" "0,1"
  bitfld.long  0x00 00.--01.             "   FM   ,Channel function mode" "0,1,2,3"

group.long (0xC3FC0408+0x100*0.+0x10*29.)++0x03
  line.long    0x00 "HSRR29,eTPU A Channel 29 Host Service Request Register"
  bitfld.long  0x00 00.--02.             "HSR ,Host service request" "0,1,2,3,4,5,6,7"


TEXTLINE ""


group.long (0xC3FC0400+0x100*0.+0x10*30.)++0x03
  line.long    0x00 "CR30,eTPU A Channel 30 Configuration Register"
  bitfld.long  0x00 31.                  "CIE ,Channel interrupt enable" "0,1"
  bitfld.long  0x00 30.                  "  DTRE ,Channel data transfer request enable" "0,1"
  bitfld.long  0x00 28.--29.             "  CPR ,Channel priority" "dis,low,mid,high"
  bitfld.long  0x00 25.                  "  ETPD ,This bit selects which channel signal, input or output, is used in the entry point selection" "PSTI,PSTO"
  bitfld.long  0x00 24.                  "  ETCS ,Entry table condition select" "std,alt"
  bitfld.long  0x00 16.--20.             "  CFS ,Channel function select" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
  bitfld.long  0x00 15.                  "  ODIS ,Output disable" "0,1"
TEXTLINE "                "  
  bitfld.long  0x00 14.                  "  OPOL ,Output polarity" "act. low,act. high"
  hexmask.long.word 0x00 00.--10. 2.     " CPBA_eTPU ,channel parameter base address - eTPU addressing"
  hexmask.long.word 0x00 00.--10. 8.     "       CPBA_host ,channel parameter base address - host (byte) addressing"
  textfld "    "   
  button "Data.dump CHBASE" "Data.Dump ANC:(0xC3FC8000+((Data.Long(ANC:0xC3FC0400+0x100*0.+0x10*30.)&0x3FF)*8.)) /DIALOG"

group.long (0xC3FC0404+0x100*0.+0x10*30.)++0x03
  line.long    0x00 "SCR30,eTPU A Channel 30 Status Control Register"
  eventfld.long  0x00 31.                  "CIS ,Channel interrupt (w1c)" "0,1"
  eventfld.long  0x00 30.                  "  CIOS ,Channel interrupt overflow status (w1c)" "0,1"
  eventfld.long  0x00 23.                  "  DTRS ,Data transfer request status (w1c)" "0,1"
  eventfld.long  0x00 22.                  "    DTROS ,Data transfer request overflow status (w1c)" "0,1"
  bitfld.long  0x00 15.                  "    IPS  ,Channel input pin state" "0,1"
  bitfld.long  0x00 14.                  "    OPS ,Channel output pin state" "0,1"
  bitfld.long  0x00 00.--01.             "   FM   ,Channel function mode" "0,1,2,3"

group.long (0xC3FC0408+0x100*0.+0x10*30.)++0x03
  line.long    0x00 "HSRR30,eTPU A Channel 30 Host Service Request Register"
  bitfld.long  0x00 00.--02.             "HSR ,Host service request" "0,1,2,3,4,5,6,7"


TEXTLINE ""


group.long (0xC3FC0400+0x100*0.+0x10*31.)++0x03
  line.long    0x00 "CR31,eTPU A Channel 31 Configuration Register"
  bitfld.long  0x00 31.                  "CIE ,Channel interrupt enable" "0,1"
  bitfld.long  0x00 30.                  "  DTRE ,Channel data transfer request enable" "0,1"
  bitfld.long  0x00 28.--29.             "  CPR ,Channel priority" "dis,low,mid,high"
  bitfld.long  0x00 25.                  "  ETPD ,This bit selects which channel signal, input or output, is used in the entry point selection" "PSTI,PSTO"
  bitfld.long  0x00 24.                  "  ETCS ,Entry table condition select" "std,alt"
  bitfld.long  0x00 16.--20.             "  CFS ,Channel function select" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
  bitfld.long  0x00 15.                  "  ODIS ,Output disable" "0,1"
TEXTLINE "                "  
  bitfld.long  0x00 14.                  "  OPOL ,Output polarity" "act. low,act. high"
  hexmask.long.word 0x00 00.--10. 2.     " CPBA_eTPU ,channel parameter base address - eTPU addressing"
  hexmask.long.word 0x00 00.--10. 8.     "       CPBA_host ,channel parameter base address - host (byte) addressing"
  textfld "    "   
  button "Data.dump CHBASE" "Data.Dump ANC:(0xC3FC8000+((Data.Long(ANC:0xC3FC0400+0x100*0.+0x10*31.)&0x3FF)*8.)) /DIALOG"

group.long (0xC3FC0404+0x100*0.+0x10*31.)++0x03
  line.long    0x00 "SCR31,eTPU A Channel 31 Status Control Register"
  eventfld.long  0x00 31.                  "CIS ,Channel interrupt (w1c)" "0,1"
  eventfld.long  0x00 30.                  "  CIOS ,Channel interrupt overflow status (w1c)" "0,1"
  eventfld.long  0x00 23.                  "  DTRS ,Data transfer request status (w1c)" "0,1"
  eventfld.long  0x00 22.                  "    DTROS ,Data transfer request overflow status (w1c)" "0,1"
  bitfld.long  0x00 15.                  "    IPS  ,Channel input pin state" "0,1"
  bitfld.long  0x00 14.                  "    OPS ,Channel output pin state" "0,1"
  bitfld.long  0x00 00.--01.             "   FM   ,Channel function mode" "0,1,2,3"

group.long (0xC3FC0408+0x100*0.+0x10*31.)++0x03
  line.long    0x00 "HSRR31,eTPU A Channel 31 Host Service Request Register"
  bitfld.long  0x00 00.--02.             "HSR ,Host service request" "0,1,2,3,4,5,6,7"


TEXTLINE ""


tree.end 


tree.end

    sif (cpu()=="MPC5554")||(cpu()=="MPC5566")||(CPUIS("MPC5674*"))

tree "eTPU B Registers"

group.long (0xC3FC0014+4)++0x03
  line.long    0x00 "ECR,eTPU B Engine Configuration Register"
  bitfld.long  0x00 31.                  "FEND ,Force end" "0,1"
  bitfld.long  0x00 30.                  "  MDIS ,Module disable internal stop" "0,1"
  bitfld.long  0x00 28.                  "  STF ,Stop flag bit" "0,1"
  bitfld.long  0x00 23.                  "  HLTF ,Halt mode flag" "0,1"
  bitfld.long  0x00 16.--18.             "  FPSCK ,Filter prescaler clock control" "2,4,8,16,32,64,128,256"
  bitfld.long  0x00 14.--15.             "  CDFC ,Channel digital filter control" "TPU2/3,res.,3 sample,cont.,"
  bitfld.long  0x00 00.--04.             "  ETB ,Entry table base." "0x00000,0x00800,0x01000,0x01800,0x02000,0x02800,0x03000,0x03800,0x04000,0x04800,0x05000,0x05800,0x06000,0x06800,0x07000,0x07800,0x08000,0x08800,0x09000,0x09800,0x0A000,0x0A800,0x0B000,0x0B800,0x0C000,0x0C800,0x0D000,0x0D800,0x0E000,0x0E800,0x0F000,0x0F800"


group.long (0xC3FC0020+0x08*4)++0x03
  line.long    0x00 "TBCR,eTPU B Time Base Configuration Register"
  bitfld.long  0x00 29.--31.             "TCR2CTL ,TCR2 clock/gate control" "000,001,010,011,100,101,110,111"
  bitfld.long  0x00 27.--28.             "  TCRCF ,TCRCLK signal filter control" "00,01,10,11"
  bitfld.long  0x00 25.                  "  AM ,Angle mode selection" "0,1"
  hexmask.long.byte 0x00 16.--21.  1.         "  TCR2P ,Timer count register 2 prescaler control"  
  bitfld.long  0x00 14.--15.             "  TCR1CTL ,TCR1 clock/gate control" "TCRCLK,res.,sysclk/2,res."
  hexmask.long.byte 0x00 00.--07.  1.         "  TCR1P ,Timer count register 1 prescaler control"

group.long (0xC3FC0024+0x08*4)++0x03
  line.long    0x00 "TB1R,eTPU B Time Base 1 (TCR1) Visibility Register"
  hexmask.long 0x00 00.--23.  1.         "TCR1 ,TCR1 value. Used on matches and captures"
  
group.long (0xC3FC0028+0x08*4)++0x03
  line.long    0x00 "TB2R,eTPU B Time Base 2 (TCR2) Visibility Register"
  hexmask.long 0x00 00.--23.  1.         "TCR2 ,TCR2 value. Used on matches and captures"
  
group.long (0xC3FC002C+0x08*4)++0x03
  line.long    0x00 "REDCR,eTPU B STAC Bus Configuration Register"
  bitfld.long  0x00 31.                  "REN1 ,TCR1 resource1 client/server operation enable" "0,1"
  bitfld.long  0x00 30.                  "  RSC1 ,TCR1 resource server/client assignment" "0,1"
  hexmask.long.byte 0x00 24.--27.  1.    "  SRV_ID1 ,STAC bus address for TCR1 as a server"
  hexmask.long.byte 0x00 16.--19.  1.    "  SRV1 ,TCR1 resource server"
  bitfld.long  0x00 15.                  "  REN2 ,TCR2 resource1 client/server operation enable" "0,1"
  bitfld.long  0x00 14.                  "  RSC2 ,TCR2 resource server/client assignment" "0,1"
  hexmask.long.byte 0x00 08.--11.  1.    "  SRV_ID2 ,STAC bus address for TCR2 as a server"
  hexmask.long.byte 0x00 00.--03.  1.    "  SRV2 ,TCR2 resource server"
  
TEXTLINE ""  
  
group.long (0xC3FC0200+4)++0x03
  line.long    0x00 "CISR,eTPU B Channel Interrupt Status Register (w1c)"
  eventfld.long  0x00 31.                  "CIC31-28  ,Channel 31 interrupt status" "0,1"
  eventfld.long  0x00 30.                  ",Channel 30 interrupt status" "0,1"
  eventfld.long  0x00 29.                  ",Channel 29 interrupt status" "0,1"
  eventfld.long  0x00 28.                  ",Channel 28 interrupt status" "0,1"

  eventfld.long  0x00 27.                  "  CIC27-24  ,Channel 27 interrupt status" "0,1"
  eventfld.long  0x00 26.                  ",Channel 26 interrupt status" "0,1"
  eventfld.long  0x00 25.                  ",Channel 25 interrupt status" "0,1"
  eventfld.long  0x00 24.                  ",Channel 24 interrupt status" "0,1"
    
  eventfld.long  0x00 23.                  "  CIC23-20  ,Channel 23 interrupt status" "0,1"
  eventfld.long  0x00 22.                  ",Channel 22 interrupt status" "0,1"
  eventfld.long  0x00 21.                  ",Channel 21 interrupt status" "0,1"
  eventfld.long  0x00 20.                  ",Channel 20 interrupt status" "0,1"
  
  eventfld.long  0x00 19.                  "  CIC19-16  ,Channel 19 interrupt status" "0,1"
  eventfld.long  0x00 18.                  ",Channel 18 interrupt status" "0,1"
  eventfld.long  0x00 17.                  ",Channel 17 interrupt status" "0,1"
  eventfld.long  0x00 16.                  ",Channel 16 interrupt status" "0,1"
TEXTLINE "                "
  eventfld.long  0x00 15.                  "  CIC15-12  ,Channel 15 interrupt status" "0,1"
  eventfld.long  0x00 14.                  ",Channel 14 interrupt status" "0,1"
  eventfld.long  0x00 13.                  ",Channel 13 interrupt status" "0,1"
  eventfld.long  0x00 12.                  ",Channel 12 interrupt status" "0,1"
  
  eventfld.long  0x00 11.                  "  CIC11-08  ,Channel 11 interrupt status" "0,1"
  eventfld.long  0x00 10.                  ",Channel 10 interrupt status" "0,1"
  eventfld.long  0x00 09.                  ",Channel 09 interrupt status" "0,1"
  eventfld.long  0x00 08.                  ",Channel 08 interrupt statusk" "0,1"
  
  eventfld.long  0x00 07.                  "  CIC17-04  ,Channel 07 interrupt status" "0,1"
  eventfld.long  0x00 06.                  ",Channel 06 interrupt statusk" "0,1"
  eventfld.long  0x00 05.                  ",Channel 05 interrupt status" "0,1"
  eventfld.long  0x00 04.                  ",Channel 04 interrupt status" "0,1"
  
  eventfld.long  0x00 03.                  "  CIC03-00  ,Channel 03 interrupt status" "0,1"
  eventfld.long  0x00 02.                  ",Channel 02 interrupt status" "0,1"
  eventfld.long  0x00 01.                  ",Channel 01 interrupt status" "0,1"
  eventfld.long  0x00 00.                  ",Channel 00 interrupt status" "0,1"
TEXTLINE ""

group.long (0xC3FC0210+4)++0x03
  line.long    0x00 "CDTRSR,eTPU B Channel Data Transfer Request Status Register (w1c)"
  eventfld.long  0x00 31.                  "DTR31-28  ,Channel 31 data transfer request status" "0,1"
  eventfld.long  0x00 30.                  ",Channel 30 data transfer request status" "0,1"
  eventfld.long  0x00 29.                  ",Channel 29 data transfer request status" "0,1"
  eventfld.long  0x00 28.                  ",Channel 28 data transfer request status" "0,1"

  eventfld.long  0x00 27.                  "  DTR27-24  ,Channel 27 data transfer request status" "0,1"
  eventfld.long  0x00 26.                  ",Channel 26 data transfer request status" "0,1"
  eventfld.long  0x00 25.                  ",Channel 25 data transfer request status" "0,1"
  eventfld.long  0x00 24.                  ",Channel 24 data transfer request status" "0,1"
    
  eventfld.long  0x00 23.                  "  DTR23-20  ,Channel 23 data transfer request status" "0,1"
  eventfld.long  0x00 22.                  ",Channel 22 data transfer request status" "0,1"
  eventfld.long  0x00 21.                  ",Channel 21 data transfer request status" "0,1"
  eventfld.long  0x00 20.                  ",Channel 20 data transfer request status" "0,1"
  
  eventfld.long  0x00 19.                  "  DTR19-16  ,Channel 19 data transfer request status" "0,1"
  eventfld.long  0x00 18.                  ",Channel 18 data transfer request status" "0,1"
  eventfld.long  0x00 17.                  ",Channel 17 data transfer request status" "0,1"
  eventfld.long  0x00 16.                  ",Channel 16 data transfer request status" "0,1"
TEXTLINE "                "
  eventfld.long  0x00 15.                  "  DTR15-12  ,Channel 15 data transfer request status" "0,1"
  eventfld.long  0x00 14.                  ",Channel 14 data transfer request status" "0,1"
  eventfld.long  0x00 13.                  ",Channel 13 data transfer request status" "0,1"
  eventfld.long  0x00 12.                  ",Channel 12 data transfer request status" "0,1"
  
  eventfld.long  0x00 11.                  "  DTR11-08  ,Channel 11 data transfer request status" "0,1"
  eventfld.long  0x00 10.                  ",Channel 10 data transfer request status" "0,1"
  eventfld.long  0x00 09.                  ",Channel 09 data transfer request status" "0,1"
  eventfld.long  0x00 08.                  ",Channel 08 data transfer request status" "0,1"
  
  eventfld.long  0x00 07.                  "  DTR17-04  ,Channel 07 data transfer request status" "0,1"
  eventfld.long  0x00 06.                  ",Channel 06 data transfer request status" "0,1"
  eventfld.long  0x00 05.                  ",Channel 05 data transfer request status" "0,1"
  eventfld.long  0x00 04.                  ",Channel 04 data transfer request status" "0,1"
  
  eventfld.long  0x00 03.                  "  DTR03-00  ,Channel 03 data transfer request status" "0,1"
  eventfld.long  0x00 02.                  ",Channel 02 data transfer request status" "0,1"
  eventfld.long  0x00 01.                  ",Channel 01 data transfer request status" "0,1"
  eventfld.long  0x00 00.                  ",Channel 00 data transfer request status" "0,1"
TEXTLINE ""


group.long (0xC3FC0220+4)++0x03
  line.long    0x00 "CIOSR,eTPU B Channel Interrupt Overflow Status Register (w1c)"
  eventfld.long  0x00 31.                  "CIO31-28  ,Channel 31 interrupt overflow status" "0,1"
  eventfld.long  0x00 30.                  ",Channel 30 interrupt overflow status" "0,1"
  eventfld.long  0x00 29.                  ",Channel 29 interrupt overflow status" "0,1"
  eventfld.long  0x00 28.                  ",Channel 28 interrupt overflow status" "0,1"

  eventfld.long  0x00 27.                  "  CIO27-24  ,Channel 27 interrupt overflow status" "0,1"
  eventfld.long  0x00 26.                  ",Channel 26 interrupt overflow status" "0,1"
  eventfld.long  0x00 25.                  ",Channel 25 interrupt overflow status" "0,1"
  eventfld.long  0x00 24.                  ",Channel 24 interrupt overflow status" "0,1"
    
  eventfld.long  0x00 23.                  "  CIO23-20  ,Channel 23 interrupt overflow status" "0,1"
  eventfld.long  0x00 22.                  ",Channel 22 interrupt overflow status" "0,1"
  eventfld.long  0x00 21.                  ",Channel 21 interrupt overflow status" "0,1"
  eventfld.long  0x00 20.                  ",Channel 20 interrupt overflow status" "0,1"
  
  eventfld.long  0x00 19.                  "  CIO19-16  ,Channel 19 interrupt overflow status" "0,1"
  eventfld.long  0x00 18.                  ",Channel 18 interrupt overflow status" "0,1"
  eventfld.long  0x00 17.                  ",Channel 17 interrupt overflow status" "0,1"
  eventfld.long  0x00 16.                  ",Channel 16 interrupt overflow status" "0,1"
TEXTLINE "                "
  eventfld.long  0x00 15.                  "  CIO15-12  ,Channel 15 interrupt overflow status" "0,1"
  eventfld.long  0x00 14.                  ",Channel 14 interrupt overflow status" "0,1"
  eventfld.long  0x00 13.                  ",Channel 13 interrupt overflow status" "0,1"
  eventfld.long  0x00 12.                  ",Channel 12 interrupt overflow status" "0,1"
  
  eventfld.long  0x00 11.                  "  CIO11-08  ,Channel 11 interrupt overflow status" "0,1"
  eventfld.long  0x00 10.                  ",Channel 10 interrupt overflow status" "0,1"
  eventfld.long  0x00 09.                  ",Channel 09 interrupt overflow status" "0,1"
  eventfld.long  0x00 08.                  ",Channel 08 interrupt overflow status" "0,1"
  
  eventfld.long  0x00 07.                  "  CIO17-04  ,Channel 07 interrupt overflow status" "0,1"
  eventfld.long  0x00 06.                  ",Channel 06 interrupt overflow status" "0,1"
  eventfld.long  0x00 05.                  ",Channel 05 interrupt overflow status" "0,1"
  eventfld.long  0x00 04.                  ",Channel 04 interrupt overflow status" "0,1"
  
  eventfld.long  0x00 03.                  "  CIO03-00  ,Channel 03 interrupt overflow status" "0,1"
  eventfld.long  0x00 02.                  ",Channel 02 interrupt overflow status" "0,1"
  eventfld.long  0x00 01.                  ",Channel 01 interrupt overflow status" "0,1"
  eventfld.long  0x00 00.                  ",Channel 00 interrupt overflow status" "0,1"
TEXTLINE ""



group.long (0xC3FC0230+4)++0x03
  line.long    0x00 "CDTROSR,eTPU B Channel Data Transfer Request Overflow Status Register (w1c)"
  eventfld.long  0x00 31.                  "DTRO31-28 ,Channel 31 data transfer request overflow status" "0,1"
  eventfld.long  0x00 30.                  ",Channel 30 data transfer request overflow status" "0,1"
  eventfld.long  0x00 29.                  ",Channel 29 data transfer request overflow status" "0,1"
  eventfld.long  0x00 28.                  ",Channel 28 data transfer request overflow status" "0,1"

  eventfld.long  0x00 27.                  "  DTRO27-24 ,Channel 27 data transfer request overflow status" "0,1"
  eventfld.long  0x00 26.                  ",Channel 26 data transfer request overflow status" "0,1"
  eventfld.long  0x00 25.                  ",Channel 25 data transfer request overflow status" "0,1"
  eventfld.long  0x00 24.                  ",Channel 24 data transfer request overflow status" "0,1"
    
  eventfld.long  0x00 23.                  "  DTRO23-20 ,Channel 23 data transfer request overflow status" "0,1"
  eventfld.long  0x00 22.                  ",Channel 22 data transfer request overflow status" "0,1"
  eventfld.long  0x00 21.                  ",Channel 21 data transfer request overflow status" "0,1"
  eventfld.long  0x00 20.                  ",Channel 20 data transfer request overflow status" "0,1"
  
  eventfld.long  0x00 19.                  "  DTRO19-16 ,Channel 19 data transfer request overflow status" "0,1"
  eventfld.long  0x00 18.                  ",Channel 18 data transfer request overflow status" "0,1"
  eventfld.long  0x00 17.                  ",Channel 17 data transfer request overflow status" "0,1"
  eventfld.long  0x00 16.                  ",Channel 16 data transfer request overflow status" "0,1"
TEXTLINE "                "
  eventfld.long  0x00 15.                  "  DTRO15-12 ,Channel 15 data transfer request overflow status" "0,1"
  eventfld.long  0x00 14.                  ",Channel 14 data transfer request overflow status" "0,1"
  eventfld.long  0x00 13.                  ",Channel 13 data transfer request overflow status" "0,1"
  eventfld.long  0x00 12.                  ",Channel 12 data transfer request overflow status" "0,1"
  
  eventfld.long  0x00 11.                  "  DTRO11-08 ,Channel 11 data transfer request overflow status" "0,1"
  eventfld.long  0x00 10.                  ",Channel 10 data transfer request overflow status" "0,1"
  eventfld.long  0x00 09.                  ",Channel 09 data transfer request overflow status" "0,1"
  eventfld.long  0x00 08.                  ",Channel 08 data transfer request overflow status" "0,1"
  
  eventfld.long  0x00 07.                  "  DTRO17-04 ,Channel 07 data transfer request overflow status" "0,1"
  eventfld.long  0x00 06.                  ",Channel 06 data transfer request overflow status" "0,1"
  eventfld.long  0x00 05.                  ",Channel 05 data transfer request overflow status" "0,1"
  eventfld.long  0x00 04.                  ",Channel 04 data transfer request overflow status" "0,1"
  
  eventfld.long  0x00 03.                  "  DTRO03-00 ,Channel 03 data transfer request overflow status" "0,1"
  eventfld.long  0x00 02.                  ",Channel 02 data transfer request overflow status" "0,1"
  eventfld.long  0x00 01.                  ",Channel 01 data transfer request overflow status" "0,1"
  eventfld.long  0x00 00.                  ",Channel 00 data transfer request overflow status" "0,1"
TEXTLINE ""

group.long (0xC3FC0240+4)++0x03
  line.long    0x00 "CIER,eTPU B Channel Interrupt Enable Register"
  bitfld.long  0x00 31.                  "CIE31-28  ,Channel 31 interrupt enable" "0,1"
  bitfld.long  0x00 30.                  ",Channel 30 interrupt enable" "0,1"
  bitfld.long  0x00 29.                  ",Channel 29 interrupt enable" "0,1"
  bitfld.long  0x00 28.                  ",Channel 28 interrupt enable" "0,1"

  bitfld.long  0x00 27.                  "  CIE27-24  ,Channel 27 interrupt enable" "0,1"
  bitfld.long  0x00 26.                  ",Channel 26 interrupt enable" "0,1"
  bitfld.long  0x00 25.                  ",Channel 25 interrupt enable" "0,1"
  bitfld.long  0x00 24.                  ",Channel 24 interrupt enable" "0,1"
    
  bitfld.long  0x00 23.                  "  CIE23-20  ,Channel 23 interrupt enable" "0,1"
  bitfld.long  0x00 22.                  ",Channel 22 interrupt enable" "0,1"
  bitfld.long  0x00 21.                  ",Channel 21 interrupt enable" "0,1"
  bitfld.long  0x00 20.                  ",Channel 20 interrupt enable" "0,1"
  
  bitfld.long  0x00 19.                  "  CIE19-16  ,Channel 19 interrupt enable" "0,1"
  bitfld.long  0x00 18.                  ",Channel 18 interrupt enable" "0,1"
  bitfld.long  0x00 17.                  ",Channel 17 interrupt enable" "0,1"
  bitfld.long  0x00 16.                  ",Channel 16 interrupt enable" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.                  "  CIE15-12  ,Channel 15 interrupt enable" "0,1"
  bitfld.long  0x00 14.                  ",Channel 14 interrupt enable" "0,1"
  bitfld.long  0x00 13.                  ",Channel 13 interrupt enable" "0,1"
  bitfld.long  0x00 12.                  ",Channel 12 interrupt enable" "0,1"
  
  bitfld.long  0x00 11.                  "  CIE11-08  ,Channel 11 interrupt enable" "0,1"
  bitfld.long  0x00 10.                  ",Channel 10 interrupt enable" "0,1"
  bitfld.long  0x00 09.                  ",Channel 09 interrupt enable" "0,1"
  bitfld.long  0x00 08.                  ",Channel 08 interrupt enable" "0,1"
  
  bitfld.long  0x00 07.                  "  CIE17-04  ,Channel 07 interrupt enable" "0,1"
  bitfld.long  0x00 06.                  ",Channel 06 interrupt enable" "0,1"
  bitfld.long  0x00 05.                  ",Channel 05 interrupt enable" "0,1"
  bitfld.long  0x00 04.                  ",Channel 04 interrupt enable" "0,1"
  
  bitfld.long  0x00 03.                  "  CIE03-00  ,Channel 03 interrupt enable" "0,1"
  bitfld.long  0x00 02.                  ",Channel 02 interrupt enable" "0,1"
  bitfld.long  0x00 01.                  ",Channel 01 interrupt enable" "0,1"
  bitfld.long  0x00 00.                  ",Channel 00 interrupt enable" "0,1"
TEXTLINE ""

group.long (0xC3FC0250+4)++0x03
  line.long    0x00 "CDTRER,eTPU B Channel Data Transfer Request Enable Register"
  bitfld.long  0x00 31.                  "DTRE31-28 ,Channel 31 data transfer request enable" "0,1"
  bitfld.long  0x00 30.                  ",Channel 30 data transfer request enable" "0,1"
  bitfld.long  0x00 29.                  ",Channel 29 data transfer request enable" "0,1"
  bitfld.long  0x00 28.                  ",Channel 28 data transfer request enable" "0,1"

  bitfld.long  0x00 27.                  "  DTRE27-24 ,Channel 27 data transfer request enable" "0,1"
  bitfld.long  0x00 26.                  ",Channel 26 data transfer request enable" "0,1"
  bitfld.long  0x00 25.                  ",Channel 25 data transfer request enable" "0,1"
  bitfld.long  0x00 24.                  ",Channel 24 data transfer request enable" "0,1"
    
  bitfld.long  0x00 23.                  "  DTRE23-20 ,Channel 23 data transfer request enable" "0,1"
  bitfld.long  0x00 22.                  ",Channel 22 data transfer request enable" "0,1"
  bitfld.long  0x00 21.                  ",Channel 21 data transfer request enable" "0,1"
  bitfld.long  0x00 20.                  ",Channel 20 data transfer request enable" "0,1"
  
  bitfld.long  0x00 19.                  "  DTRE19-16 ,Channel 19 data transfer request enable" "0,1"
  bitfld.long  0x00 18.                  ",Channel 18 data transfer request enable" "0,1"
  bitfld.long  0x00 17.                  ",Channel 17 data transfer request enable" "0,1"
  bitfld.long  0x00 16.                  ",Channel 16 data transfer request enable" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.                  "  DTRE15-12 ,Channel 15 data transfer request enable" "0,1"
  bitfld.long  0x00 14.                  ",Channel 14 data transfer request enable" "0,1"
  bitfld.long  0x00 13.                  ",Channel 13 data transfer request enable" "0,1"
  bitfld.long  0x00 12.                  ",Channel 12 data transfer request enable" "0,1"
  
  bitfld.long  0x00 11.                  "  DTRE11-08 ,Channel 11 data transfer request enable" "0,1"
  bitfld.long  0x00 10.                  ",Channel 10 data transfer request enable" "0,1"
  bitfld.long  0x00 09.                  ",Channel 09 data transfer request enable" "0,1"
  bitfld.long  0x00 08.                  ",Channel 08 data transfer request enable" "0,1"
  
  bitfld.long  0x00 07.                  "  DTRE17-04 ,Channel 07 data transfer request enable" "0,1"
  bitfld.long  0x00 06.                  ",Channel 06 data transfer request enable" "0,1"
  bitfld.long  0x00 05.                  ",Channel 05 data transfer request enable" "0,1"
  bitfld.long  0x00 04.                  ",Channel 04 data transfer request enable" "0,1"
  
  bitfld.long  0x00 03.                  "  DTRE03-00 ,Channel 03 data transfer request enable" "0,1"
  bitfld.long  0x00 02.                  ",Channel 02 data transfer request enable" "0,1"
  bitfld.long  0x00 01.                  ",Channel 01 data transfer request enable" "0,1"
  bitfld.long  0x00 00.                  ",Channel 00 data transfer request enable" "0,1"
TEXTLINE ""

rgroup.long (0xC3FC0280+4)++0x03
  line.long    0x00 "CPSSR,eTPU B Channel Pending Service Status Register"
  bitfld.long  0x00 31.                  "SR31-28   ,Channel 31 pending service request" "0,1"
  bitfld.long  0x00 30.                  ",Channel 30 pending service request" "0,1"
  bitfld.long  0x00 29.                  ",Channel 29 pending service request" "0,1"
  bitfld.long  0x00 28.                  ",Channel 28 pending service request" "0,1"

  bitfld.long  0x00 27.                  "  SR27-24   ,Channel 27 pending service request" "0,1"
  bitfld.long  0x00 26.                  ",Channel 26 pending service request" "0,1"
  bitfld.long  0x00 25.                  ",Channel 25 pending service request" "0,1"
  bitfld.long  0x00 24.                  ",Channel 24 pending service request" "0,1"
    
  bitfld.long  0x00 23.                  "  SR23-20   ,Channel 23 pending service request" "0,1"
  bitfld.long  0x00 22.                  ",Channel 22 pending service request" "0,1"
  bitfld.long  0x00 21.                  ",Channel 21 pending service request" "0,1"
  bitfld.long  0x00 20.                  ",Channel 20 pending service request" "0,1"
  
  bitfld.long  0x00 19.                  "  SR19-16   ,Channel 19 pending service request" "0,1"
  bitfld.long  0x00 18.                  ",Channel 18 pending service request" "0,1"
  bitfld.long  0x00 17.                  ",Channel 17 pending service request" "0,1"
  bitfld.long  0x00 16.                  ",Channel 16 pending service request" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.                  "  SR15-12   ,Channel 15 pending service request" "0,1"
  bitfld.long  0x00 14.                  ",Channel 14 pending service request" "0,1"
  bitfld.long  0x00 13.                  ",Channel 13 pending service request" "0,1"
  bitfld.long  0x00 12.                  ",Channel 12 pending service request" "0,1"
  
  bitfld.long  0x00 11.                  "  SR11-08   ,Channel 11 pending service request" "0,1"
  bitfld.long  0x00 10.                  ",Channel 10 pending service request" "0,1"
  bitfld.long  0x00 09.                  ",Channel 09 pending service request" "0,1"
  bitfld.long  0x00 08.                  ",Channel 08 pending service request" "0,1"
  
  bitfld.long  0x00 07.                  "  SR17-04   ,Channel 07 pending service request" "0,1"
  bitfld.long  0x00 06.                  ",Channel 06 pending service request" "0,1"
  bitfld.long  0x00 05.                  ",Channel 05 pending service request" "0,1"
  bitfld.long  0x00 04.                  ",Channel 04 pending service request" "0,1"
  
  bitfld.long  0x00 03.                  "  SR03-00   ,Channel 03 pending service request" "0,1"
  bitfld.long  0x00 02.                  ",Channel 02 pending service request" "0,1"
  bitfld.long  0x00 01.                  ",Channel 01 pending service request" "0,1"
  bitfld.long  0x00 00.                  ",Channel 00 pending service request" "0,1"
TEXTLINE ""

rgroup.long (0xC3FC0290+4)++0x03
  line.long    0x00 "CSSR,eTPU B Channel Service Status Register"
  bitfld.long  0x00 31.                  "SS31-28   ,Channel 31 service status" "0,1"
  bitfld.long  0x00 30.                  ",Channel 30 service status" "0,1"
  bitfld.long  0x00 29.                  ",Channel 29 service status" "0,1"
  bitfld.long  0x00 28.                  ",Channel 28 service status" "0,1"

  bitfld.long  0x00 27.                  "  SS27-24   ,Channel 27 service status" "0,1"
  bitfld.long  0x00 26.                  ",Channel 26 service status" "0,1"
  bitfld.long  0x00 25.                  ",Channel 25 service status" "0,1"
  bitfld.long  0x00 24.                  ",Channel 24 service status" "0,1"
    
  bitfld.long  0x00 23.                  "  SS23-20   ,Channel 23 service status" "0,1"
  bitfld.long  0x00 22.                  ",Channel 22 service status" "0,1"
  bitfld.long  0x00 21.                  ",Channel 21 service status" "0,1"
  bitfld.long  0x00 20.                  ",Channel 20 service status" "0,1"
  
  bitfld.long  0x00 19.                  "  SS19-16   ,Channel 19 service status" "0,1"
  bitfld.long  0x00 18.                  ",Channel 18 service status" "0,1"
  bitfld.long  0x00 17.                  ",Channel 17 service status" "0,1"
  bitfld.long  0x00 16.                  ",Channel 16 service status" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 15.                  "  SS15-12   ,Channel 15 service status" "0,1"
  bitfld.long  0x00 14.                  ",Channel 14 service status" "0,1"
  bitfld.long  0x00 13.                  ",Channel 13 service status" "0,1"
  bitfld.long  0x00 12.                  ",Channel 12 service status" "0,1"
  
  bitfld.long  0x00 11.                  "  SS11-08   ,Channel 11 service status" "0,1"
  bitfld.long  0x00 10.                  ",Channel 10 service status" "0,1"
  bitfld.long  0x00 09.                  ",Channel 09 service status" "0,1"
  bitfld.long  0x00 08.                  ",Channel 08 service status" "0,1"
  
  bitfld.long  0x00 07.                  "  SS17-04   ,Channel 07 service status" "0,1"
  bitfld.long  0x00 06.                  ",Channel 06 service status" "0,1"
  bitfld.long  0x00 05.                  ",Channel 05 service status" "0,1"
  bitfld.long  0x00 04.                  ",Channel 04 service status" "0,1"
  
  bitfld.long  0x00 03.                  "  SS03-00   ,Channel 03 service status" "0,1"
  bitfld.long  0x00 02.                  ",Channel 02 service status" "0,1"
  bitfld.long  0x00 01.                  ",Channel 01 service status" "0,1"
  bitfld.long  0x00 00.                  ",Channel 00 service status" "0,1"
TEXTLINE ""

tree "eTPU B Channel Registers"


group.long (0xC3FC0400+0x100*4.+0x10*0.)++0x03
  line.long    0x00 "CR0,eTPU B Channel 0 Configuration Register"
  bitfld.long  0x00 31.                  "CIE ,Channel interrupt enable" "0,1"
  bitfld.long  0x00 30.                  "  DTRE ,Channel data transfer request enable" "0,1"
  bitfld.long  0x00 28.--29.             "  CPR ,Channel priority" "dis,low,mid,high"
  bitfld.long  0x00 25.                  "  ETPD ,This bit selects which channel signal, input or output, is used in the entry point selection" "PSTI,PSTO"
  bitfld.long  0x00 24.                  "  ETCS ,Entry table condition select" "std,alt"
  bitfld.long  0x00 16.--20.             "  CFS ,Channel function select" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
  bitfld.long  0x00 15.                  "  ODIS ,Output disable" "0,1"
TEXTLINE "                "  
  bitfld.long  0x00 14.                  "  OPOL ,Output polarity" "act. low,act. high"
  hexmask.long.word 0x00 00.--10. 2.     " CPBA_eTPU ,channel parameter base address - eTPU addressing"
  hexmask.long.word 0x00 00.--10. 8.     "       CPBA_host ,channel parameter base address - host (byte) addressing"
  textfld "    "   
  button "Data.dump CHBASE" "Data.Dump ANC:(0xC3FC8000+((Data.Long(ANC:0xC3FC0400+0x100*4.+0x10*0.)&0x3FF)*8.)) /DIALOG"

group.long (0xC3FC0404+0x100*4.+0x10*0.)++0x03
  line.long    0x00 "SCR0,eTPU B Channel 0 Status Control Register"
  eventfld.long  0x00 31.                  "CIS ,Channel interrupt (w1c)" "0,1"
  eventfld.long  0x00 30.                  "  CIOS ,Channel interrupt overflow status (w1c)" "0,1"
  eventfld.long  0x00 23.                  "  DTRS ,Data transfer request status (w1c)" "0,1"
  eventfld.long  0x00 22.                  "    DTROS ,Data transfer request overflow status (w1c)" "0,1"
  bitfld.long  0x00 15.                  "    IPS  ,Channel input pin state" "0,1"
  bitfld.long  0x00 14.                  "    OPS ,Channel output pin state" "0,1"
  bitfld.long  0x00 00.--01.             "   FM   ,Channel function mode" "0,1,2,3"

group.long (0xC3FC0408+0x100*4.+0x10*0.)++0x03
  line.long    0x00 "HSRR0,eTPU B Channel 0 Host Service Request Register"
  bitfld.long  0x00 00.--02.             "HSR ,Host service request" "0,1,2,3,4,5,6,7"


TEXTLINE ""


group.long (0xC3FC0400+0x100*4.+0x10*1.)++0x03
  line.long    0x00 "CR1,eTPU B Channel 1 Configuration Register"
  bitfld.long  0x00 31.                  "CIE ,Channel interrupt enable" "0,1"
  bitfld.long  0x00 30.                  "  DTRE ,Channel data transfer request enable" "0,1"
  bitfld.long  0x00 28.--29.             "  CPR ,Channel priority" "dis,low,mid,high"
  bitfld.long  0x00 25.                  "  ETPD ,This bit selects which channel signal, input or output, is used in the entry point selection" "PSTI,PSTO"
  bitfld.long  0x00 24.                  "  ETCS ,Entry table condition select" "std,alt"
  bitfld.long  0x00 16.--20.             "  CFS ,Channel function select" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
  bitfld.long  0x00 15.                  "  ODIS ,Output disable" "0,1"
TEXTLINE "                "  
  bitfld.long  0x00 14.                  "  OPOL ,Output polarity" "act. low,act. high"
  hexmask.long.word 0x00 00.--10. 2.     " CPBA_eTPU ,channel parameter base address - eTPU addressing"
  hexmask.long.word 0x00 00.--10. 8.     "       CPBA_host ,channel parameter base address - host (byte) addressing"
  textfld "    "   
  button "Data.dump CHBASE" "Data.Dump ANC:(0xC3FC8000+((Data.Long(ANC:0xC3FC0400+0x100*4.+0x10*1.)&0x3FF)*8.)) /DIALOG"

group.long (0xC3FC0404+0x100*4.+0x10*1.)++0x03
  line.long    0x00 "SCR1,eTPU B Channel 1 Status Control Register"
  eventfld.long  0x00 31.                  "CIS ,Channel interrupt (w1c)" "0,1"
  eventfld.long  0x00 30.                  "  CIOS ,Channel interrupt overflow status (w1c)" "0,1"
  eventfld.long  0x00 23.                  "  DTRS ,Data transfer request status (w1c)" "0,1"
  eventfld.long  0x00 22.                  "    DTROS ,Data transfer request overflow status (w1c)" "0,1"
  bitfld.long  0x00 15.                  "    IPS  ,Channel input pin state" "0,1"
  bitfld.long  0x00 14.                  "    OPS ,Channel output pin state" "0,1"
  bitfld.long  0x00 00.--01.             "   FM   ,Channel function mode" "0,1,2,3"

group.long (0xC3FC0408+0x100*4.+0x10*1.)++0x03
  line.long    0x00 "HSRR1,eTPU B Channel 1 Host Service Request Register"
  bitfld.long  0x00 00.--02.             "HSR ,Host service request" "0,1,2,3,4,5,6,7"


TEXTLINE ""


group.long (0xC3FC0400+0x100*4.+0x10*2.)++0x03
  line.long    0x00 "CR2,eTPU B Channel 2 Configuration Register"
  bitfld.long  0x00 31.                  "CIE ,Channel interrupt enable" "0,1"
  bitfld.long  0x00 30.                  "  DTRE ,Channel data transfer request enable" "0,1"
  bitfld.long  0x00 28.--29.             "  CPR ,Channel priority" "dis,low,mid,high"
  bitfld.long  0x00 25.                  "  ETPD ,This bit selects which channel signal, input or output, is used in the entry point selection" "PSTI,PSTO"
  bitfld.long  0x00 24.                  "  ETCS ,Entry table condition select" "std,alt"
  bitfld.long  0x00 16.--20.             "  CFS ,Channel function select" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
  bitfld.long  0x00 15.                  "  ODIS ,Output disable" "0,1"
TEXTLINE "                "  
  bitfld.long  0x00 14.                  "  OPOL ,Output polarity" "act. low,act. high"
  hexmask.long.word 0x00 00.--10. 2.     " CPBA_eTPU ,channel parameter base address - eTPU addressing"
  hexmask.long.word 0x00 00.--10. 8.     "       CPBA_host ,channel parameter base address - host (byte) addressing"
  textfld "    "   
  button "Data.dump CHBASE" "Data.Dump ANC:(0xC3FC8000+((Data.Long(ANC:0xC3FC0400+0x100*4.+0x10*2.)&0x3FF)*8.)) /DIALOG"

group.long (0xC3FC0404+0x100*4.+0x10*2.)++0x03
  line.long    0x00 "SCR2,eTPU B Channel 2 Status Control Register"
  eventfld.long  0x00 31.                  "CIS ,Channel interrupt (w1c)" "0,1"
  eventfld.long  0x00 30.                  "  CIOS ,Channel interrupt overflow status (w1c)" "0,1"
  eventfld.long  0x00 23.                  "  DTRS ,Data transfer request status (w1c)" "0,1"
  eventfld.long  0x00 22.                  "    DTROS ,Data transfer request overflow status (w1c)" "0,1"
  bitfld.long  0x00 15.                  "    IPS  ,Channel input pin state" "0,1"
  bitfld.long  0x00 14.                  "    OPS ,Channel output pin state" "0,1"
  bitfld.long  0x00 00.--01.             "   FM   ,Channel function mode" "0,1,2,3"

group.long (0xC3FC0408+0x100*4.+0x10*2.)++0x03
  line.long    0x00 "HSRR2,eTPU B Channel 2 Host Service Request Register"
  bitfld.long  0x00 00.--02.             "HSR ,Host service request" "0,1,2,3,4,5,6,7"


TEXTLINE ""


group.long (0xC3FC0400+0x100*4.+0x10*3.)++0x03
  line.long    0x00 "CR3,eTPU B Channel 3 Configuration Register"
  bitfld.long  0x00 31.                  "CIE ,Channel interrupt enable" "0,1"
  bitfld.long  0x00 30.                  "  DTRE ,Channel data transfer request enable" "0,1"
  bitfld.long  0x00 28.--29.             "  CPR ,Channel priority" "dis,low,mid,high"
  bitfld.long  0x00 25.                  "  ETPD ,This bit selects which channel signal, input or output, is used in the entry point selection" "PSTI,PSTO"
  bitfld.long  0x00 24.                  "  ETCS ,Entry table condition select" "std,alt"
  bitfld.long  0x00 16.--20.             "  CFS ,Channel function select" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
  bitfld.long  0x00 15.                  "  ODIS ,Output disable" "0,1"
TEXTLINE "                "  
  bitfld.long  0x00 14.                  "  OPOL ,Output polarity" "act. low,act. high"
  hexmask.long.word 0x00 00.--10. 2.     " CPBA_eTPU ,channel parameter base address - eTPU addressing"
  hexmask.long.word 0x00 00.--10. 8.     "       CPBA_host ,channel parameter base address - host (byte) addressing"
  textfld "    "   
  button "Data.dump CHBASE" "Data.Dump ANC:(0xC3FC8000+((Data.Long(ANC:0xC3FC0400+0x100*4.+0x10*3.)&0x3FF)*8.)) /DIALOG"

group.long (0xC3FC0404+0x100*4.+0x10*3.)++0x03
  line.long    0x00 "SCR3,eTPU B Channel 3 Status Control Register"
  eventfld.long  0x00 31.                  "CIS ,Channel interrupt (w1c)" "0,1"
  eventfld.long  0x00 30.                  "  CIOS ,Channel interrupt overflow status (w1c)" "0,1"
  eventfld.long  0x00 23.                  "  DTRS ,Data transfer request status (w1c)" "0,1"
  eventfld.long  0x00 22.                  "    DTROS ,Data transfer request overflow status (w1c)" "0,1"
  bitfld.long  0x00 15.                  "    IPS  ,Channel input pin state" "0,1"
  bitfld.long  0x00 14.                  "    OPS ,Channel output pin state" "0,1"
  bitfld.long  0x00 00.--01.             "   FM   ,Channel function mode" "0,1,2,3"

group.long (0xC3FC0408+0x100*4.+0x10*3.)++0x03
  line.long    0x00 "HSRR3,eTPU B Channel 3 Host Service Request Register"
  bitfld.long  0x00 00.--02.             "HSR ,Host service request" "0,1,2,3,4,5,6,7"


TEXTLINE ""


group.long (0xC3FC0400+0x100*4.+0x10*4.)++0x03
  line.long    0x00 "CR4,eTPU B Channel 4 Configuration Register"
  bitfld.long  0x00 31.                  "CIE ,Channel interrupt enable" "0,1"
  bitfld.long  0x00 30.                  "  DTRE ,Channel data transfer request enable" "0,1"
  bitfld.long  0x00 28.--29.             "  CPR ,Channel priority" "dis,low,mid,high"
  bitfld.long  0x00 25.                  "  ETPD ,This bit selects which channel signal, input or output, is used in the entry point selection" "PSTI,PSTO"
  bitfld.long  0x00 24.                  "  ETCS ,Entry table condition select" "std,alt"
  bitfld.long  0x00 16.--20.             "  CFS ,Channel function select" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
  bitfld.long  0x00 15.                  "  ODIS ,Output disable" "0,1"
TEXTLINE "                "  
  bitfld.long  0x00 14.                  "  OPOL ,Output polarity" "act. low,act. high"
  hexmask.long.word 0x00 00.--10. 2.     " CPBA_eTPU ,channel parameter base address - eTPU addressing"
  hexmask.long.word 0x00 00.--10. 8.     "       CPBA_host ,channel parameter base address - host (byte) addressing"
  textfld "    "   
  button "Data.dump CHBASE" "Data.Dump ANC:(0xC3FC8000+((Data.Long(ANC:0xC3FC0400+0x100*4.+0x10*4.)&0x3FF)*8.)) /DIALOG"

group.long (0xC3FC0404+0x100*4.+0x10*4.)++0x03
  line.long    0x00 "SCR4,eTPU B Channel 4 Status Control Register"
  eventfld.long  0x00 31.                  "CIS ,Channel interrupt (w1c)" "0,1"
  eventfld.long  0x00 30.                  "  CIOS ,Channel interrupt overflow status (w1c)" "0,1"
  eventfld.long  0x00 23.                  "  DTRS ,Data transfer request status (w1c)" "0,1"
  eventfld.long  0x00 22.                  "    DTROS ,Data transfer request overflow status (w1c)" "0,1"
  bitfld.long  0x00 15.                  "    IPS  ,Channel input pin state" "0,1"
  bitfld.long  0x00 14.                  "    OPS ,Channel output pin state" "0,1"
  bitfld.long  0x00 00.--01.             "   FM   ,Channel function mode" "0,1,2,3"

group.long (0xC3FC0408+0x100*4.+0x10*4.)++0x03
  line.long    0x00 "HSRR4,eTPU B Channel 4 Host Service Request Register"
  bitfld.long  0x00 00.--02.             "HSR ,Host service request" "0,1,2,3,4,5,6,7"


TEXTLINE ""


group.long (0xC3FC0400+0x100*4.+0x10*5.)++0x03
  line.long    0x00 "CR5,eTPU B Channel 5 Configuration Register"
  bitfld.long  0x00 31.                  "CIE ,Channel interrupt enable" "0,1"
  bitfld.long  0x00 30.                  "  DTRE ,Channel data transfer request enable" "0,1"
  bitfld.long  0x00 28.--29.             "  CPR ,Channel priority" "dis,low,mid,high"
  bitfld.long  0x00 25.                  "  ETPD ,This bit selects which channel signal, input or output, is used in the entry point selection" "PSTI,PSTO"
  bitfld.long  0x00 24.                  "  ETCS ,Entry table condition select" "std,alt"
  bitfld.long  0x00 16.--20.             "  CFS ,Channel function select" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
  bitfld.long  0x00 15.                  "  ODIS ,Output disable" "0,1"
TEXTLINE "                "  
  bitfld.long  0x00 14.                  "  OPOL ,Output polarity" "act. low,act. high"
  hexmask.long.word 0x00 00.--10. 2.     " CPBA_eTPU ,channel parameter base address - eTPU addressing"
  hexmask.long.word 0x00 00.--10. 8.     "       CPBA_host ,channel parameter base address - host (byte) addressing"
  textfld "    "   
  button "Data.dump CHBASE" "Data.Dump ANC:(0xC3FC8000+((Data.Long(ANC:0xC3FC0400+0x100*4.+0x10*5.)&0x3FF)*8.)) /DIALOG"

group.long (0xC3FC0404+0x100*4.+0x10*5.)++0x03
  line.long    0x00 "SCR5,eTPU B Channel 5 Status Control Register"
  eventfld.long  0x00 31.                  "CIS ,Channel interrupt (w1c)" "0,1"
  eventfld.long  0x00 30.                  "  CIOS ,Channel interrupt overflow status (w1c)" "0,1"
  eventfld.long  0x00 23.                  "  DTRS ,Data transfer request status (w1c)" "0,1"
  eventfld.long  0x00 22.                  "    DTROS ,Data transfer request overflow status (w1c)" "0,1"
  bitfld.long  0x00 15.                  "    IPS  ,Channel input pin state" "0,1"
  bitfld.long  0x00 14.                  "    OPS ,Channel output pin state" "0,1"
  bitfld.long  0x00 00.--01.             "   FM   ,Channel function mode" "0,1,2,3"

group.long (0xC3FC0408+0x100*4.+0x10*5.)++0x03
  line.long    0x00 "HSRR5,eTPU B Channel 5 Host Service Request Register"
  bitfld.long  0x00 00.--02.             "HSR ,Host service request" "0,1,2,3,4,5,6,7"


TEXTLINE ""


group.long (0xC3FC0400+0x100*4.+0x10*6.)++0x03
  line.long    0x00 "CR6,eTPU B Channel 6 Configuration Register"
  bitfld.long  0x00 31.                  "CIE ,Channel interrupt enable" "0,1"
  bitfld.long  0x00 30.                  "  DTRE ,Channel data transfer request enable" "0,1"
  bitfld.long  0x00 28.--29.             "  CPR ,Channel priority" "dis,low,mid,high"
  bitfld.long  0x00 25.                  "  ETPD ,This bit selects which channel signal, input or output, is used in the entry point selection" "PSTI,PSTO"
  bitfld.long  0x00 24.                  "  ETCS ,Entry table condition select" "std,alt"
  bitfld.long  0x00 16.--20.             "  CFS ,Channel function select" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
  bitfld.long  0x00 15.                  "  ODIS ,Output disable" "0,1"
TEXTLINE "                "  
  bitfld.long  0x00 14.                  "  OPOL ,Output polarity" "act. low,act. high"
  hexmask.long.word 0x00 00.--10. 2.     " CPBA_eTPU ,channel parameter base address - eTPU addressing"
  hexmask.long.word 0x00 00.--10. 8.     "       CPBA_host ,channel parameter base address - host (byte) addressing"
  textfld "    "   
  button "Data.dump CHBASE" "Data.Dump ANC:(0xC3FC8000+((Data.Long(ANC:0xC3FC0400+0x100*4.+0x10*6.)&0x3FF)*8.)) /DIALOG"

group.long (0xC3FC0404+0x100*4.+0x10*6.)++0x03
  line.long    0x00 "SCR6,eTPU B Channel 6 Status Control Register"
  eventfld.long  0x00 31.                  "CIS ,Channel interrupt (w1c)" "0,1"
  eventfld.long  0x00 30.                  "  CIOS ,Channel interrupt overflow status (w1c)" "0,1"
  eventfld.long  0x00 23.                  "  DTRS ,Data transfer request status (w1c)" "0,1"
  eventfld.long  0x00 22.                  "    DTROS ,Data transfer request overflow status (w1c)" "0,1"
  bitfld.long  0x00 15.                  "    IPS  ,Channel input pin state" "0,1"
  bitfld.long  0x00 14.                  "    OPS ,Channel output pin state" "0,1"
  bitfld.long  0x00 00.--01.             "   FM   ,Channel function mode" "0,1,2,3"

group.long (0xC3FC0408+0x100*4.+0x10*6.)++0x03
  line.long    0x00 "HSRR6,eTPU B Channel 6 Host Service Request Register"
  bitfld.long  0x00 00.--02.             "HSR ,Host service request" "0,1,2,3,4,5,6,7"


TEXTLINE ""


group.long (0xC3FC0400+0x100*4.+0x10*7.)++0x03
  line.long    0x00 "CR7,eTPU B Channel 7 Configuration Register"
  bitfld.long  0x00 31.                  "CIE ,Channel interrupt enable" "0,1"
  bitfld.long  0x00 30.                  "  DTRE ,Channel data transfer request enable" "0,1"
  bitfld.long  0x00 28.--29.             "  CPR ,Channel priority" "dis,low,mid,high"
  bitfld.long  0x00 25.                  "  ETPD ,This bit selects which channel signal, input or output, is used in the entry point selection" "PSTI,PSTO"
  bitfld.long  0x00 24.                  "  ETCS ,Entry table condition select" "std,alt"
  bitfld.long  0x00 16.--20.             "  CFS ,Channel function select" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
  bitfld.long  0x00 15.                  "  ODIS ,Output disable" "0,1"
TEXTLINE "                "  
  bitfld.long  0x00 14.                  "  OPOL ,Output polarity" "act. low,act. high"
  hexmask.long.word 0x00 00.--10. 2.     " CPBA_eTPU ,channel parameter base address - eTPU addressing"
  hexmask.long.word 0x00 00.--10. 8.     "       CPBA_host ,channel parameter base address - host (byte) addressing"
  textfld "    "   
  button "Data.dump CHBASE" "Data.Dump ANC:(0xC3FC8000+((Data.Long(ANC:0xC3FC0400+0x100*4.+0x10*7.)&0x3FF)*8.)) /DIALOG"

group.long (0xC3FC0404+0x100*4.+0x10*7.)++0x03
  line.long    0x00 "SCR7,eTPU B Channel 7 Status Control Register"
  eventfld.long  0x00 31.                  "CIS ,Channel interrupt (w1c)" "0,1"
  eventfld.long  0x00 30.                  "  CIOS ,Channel interrupt overflow status (w1c)" "0,1"
  eventfld.long  0x00 23.                  "  DTRS ,Data transfer request status (w1c)" "0,1"
  eventfld.long  0x00 22.                  "    DTROS ,Data transfer request overflow status (w1c)" "0,1"
  bitfld.long  0x00 15.                  "    IPS  ,Channel input pin state" "0,1"
  bitfld.long  0x00 14.                  "    OPS ,Channel output pin state" "0,1"
  bitfld.long  0x00 00.--01.             "   FM   ,Channel function mode" "0,1,2,3"

group.long (0xC3FC0408+0x100*4.+0x10*7.)++0x03
  line.long    0x00 "HSRR7,eTPU B Channel 7 Host Service Request Register"
  bitfld.long  0x00 00.--02.             "HSR ,Host service request" "0,1,2,3,4,5,6,7"


TEXTLINE ""


group.long (0xC3FC0400+0x100*4.+0x10*8.)++0x03
  line.long    0x00 "CR8,eTPU B Channel 8 Configuration Register"
  bitfld.long  0x00 31.                  "CIE ,Channel interrupt enable" "0,1"
  bitfld.long  0x00 30.                  "  DTRE ,Channel data transfer request enable" "0,1"
  bitfld.long  0x00 28.--29.             "  CPR ,Channel priority" "dis,low,mid,high"
  bitfld.long  0x00 25.                  "  ETPD ,This bit selects which channel signal, input or output, is used in the entry point selection" "PSTI,PSTO"
  bitfld.long  0x00 24.                  "  ETCS ,Entry table condition select" "std,alt"
  bitfld.long  0x00 16.--20.             "  CFS ,Channel function select" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
  bitfld.long  0x00 15.                  "  ODIS ,Output disable" "0,1"
TEXTLINE "                "  
  bitfld.long  0x00 14.                  "  OPOL ,Output polarity" "act. low,act. high"
  hexmask.long.word 0x00 00.--10. 2.     " CPBA_eTPU ,channel parameter base address - eTPU addressing"
  hexmask.long.word 0x00 00.--10. 8.     "       CPBA_host ,channel parameter base address - host (byte) addressing"
  textfld "    "   
  button "Data.dump CHBASE" "Data.Dump ANC:(0xC3FC8000+((Data.Long(ANC:0xC3FC0400+0x100*4.+0x10*8.)&0x3FF)*8.)) /DIALOG"

group.long (0xC3FC0404+0x100*4.+0x10*8.)++0x03
  line.long    0x00 "SCR8,eTPU B Channel 8 Status Control Register"
  eventfld.long  0x00 31.                  "CIS ,Channel interrupt (w1c)" "0,1"
  eventfld.long  0x00 30.                  "  CIOS ,Channel interrupt overflow status (w1c)" "0,1"
  eventfld.long  0x00 23.                  "  DTRS ,Data transfer request status (w1c)" "0,1"
  eventfld.long  0x00 22.                  "    DTROS ,Data transfer request overflow status (w1c)" "0,1"
  bitfld.long  0x00 15.                  "    IPS  ,Channel input pin state" "0,1"
  bitfld.long  0x00 14.                  "    OPS ,Channel output pin state" "0,1"
  bitfld.long  0x00 00.--01.             "   FM   ,Channel function mode" "0,1,2,3"

group.long (0xC3FC0408+0x100*4.+0x10*8.)++0x03
  line.long    0x00 "HSRR8,eTPU B Channel 8 Host Service Request Register"
  bitfld.long  0x00 00.--02.             "HSR ,Host service request" "0,1,2,3,4,5,6,7"


TEXTLINE ""


group.long (0xC3FC0400+0x100*4.+0x10*9.)++0x03
  line.long    0x00 "CR9,eTPU B Channel 9 Configuration Register"
  bitfld.long  0x00 31.                  "CIE ,Channel interrupt enable" "0,1"
  bitfld.long  0x00 30.                  "  DTRE ,Channel data transfer request enable" "0,1"
  bitfld.long  0x00 28.--29.             "  CPR ,Channel priority" "dis,low,mid,high"
  bitfld.long  0x00 25.                  "  ETPD ,This bit selects which channel signal, input or output, is used in the entry point selection" "PSTI,PSTO"
  bitfld.long  0x00 24.                  "  ETCS ,Entry table condition select" "std,alt"
  bitfld.long  0x00 16.--20.             "  CFS ,Channel function select" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
  bitfld.long  0x00 15.                  "  ODIS ,Output disable" "0,1"
TEXTLINE "                "  
  bitfld.long  0x00 14.                  "  OPOL ,Output polarity" "act. low,act. high"
  hexmask.long.word 0x00 00.--10. 2.     " CPBA_eTPU ,channel parameter base address - eTPU addressing"
  hexmask.long.word 0x00 00.--10. 8.     "       CPBA_host ,channel parameter base address - host (byte) addressing"
  textfld "    "   
  button "Data.dump CHBASE" "Data.Dump ANC:(0xC3FC8000+((Data.Long(ANC:0xC3FC0400+0x100*4.+0x10*9.)&0x3FF)*8.)) /DIALOG"

group.long (0xC3FC0404+0x100*4.+0x10*9.)++0x03
  line.long    0x00 "SCR9,eTPU B Channel 9 Status Control Register"
  eventfld.long  0x00 31.                  "CIS ,Channel interrupt (w1c)" "0,1"
  eventfld.long  0x00 30.                  "  CIOS ,Channel interrupt overflow status (w1c)" "0,1"
  eventfld.long  0x00 23.                  "  DTRS ,Data transfer request status (w1c)" "0,1"
  eventfld.long  0x00 22.                  "    DTROS ,Data transfer request overflow status (w1c)" "0,1"
  bitfld.long  0x00 15.                  "    IPS  ,Channel input pin state" "0,1"
  bitfld.long  0x00 14.                  "    OPS ,Channel output pin state" "0,1"
  bitfld.long  0x00 00.--01.             "   FM   ,Channel function mode" "0,1,2,3"

group.long (0xC3FC0408+0x100*4.+0x10*9.)++0x03
  line.long    0x00 "HSRR9,eTPU B Channel 9 Host Service Request Register"
  bitfld.long  0x00 00.--02.             "HSR ,Host service request" "0,1,2,3,4,5,6,7"


TEXTLINE ""


group.long (0xC3FC0400+0x100*4.+0x10*10.)++0x03
  line.long    0x00 "CR10,eTPU B Channel 10 Configuration Register"
  bitfld.long  0x00 31.                  "CIE ,Channel interrupt enable" "0,1"
  bitfld.long  0x00 30.                  "  DTRE ,Channel data transfer request enable" "0,1"
  bitfld.long  0x00 28.--29.             "  CPR ,Channel priority" "dis,low,mid,high"
  bitfld.long  0x00 25.                  "  ETPD ,This bit selects which channel signal, input or output, is used in the entry point selection" "PSTI,PSTO"
  bitfld.long  0x00 24.                  "  ETCS ,Entry table condition select" "std,alt"
  bitfld.long  0x00 16.--20.             "  CFS ,Channel function select" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
  bitfld.long  0x00 15.                  "  ODIS ,Output disable" "0,1"
TEXTLINE "                "  
  bitfld.long  0x00 14.                  "  OPOL ,Output polarity" "act. low,act. high"
  hexmask.long.word 0x00 00.--10. 2.     " CPBA_eTPU ,channel parameter base address - eTPU addressing"
  hexmask.long.word 0x00 00.--10. 8.     "       CPBA_host ,channel parameter base address - host (byte) addressing"
  textfld "    "   
  button "Data.dump CHBASE" "Data.Dump ANC:(0xC3FC8000+((Data.Long(ANC:0xC3FC0400+0x100*4.+0x10*10.)&0x3FF)*8.)) /DIALOG"

group.long (0xC3FC0404+0x100*4.+0x10*10.)++0x03
  line.long    0x00 "SCR10,eTPU B Channel 10 Status Control Register"
  eventfld.long  0x00 31.                  "CIS ,Channel interrupt (w1c)" "0,1"
  eventfld.long  0x00 30.                  "  CIOS ,Channel interrupt overflow status (w1c)" "0,1"
  eventfld.long  0x00 23.                  "  DTRS ,Data transfer request status (w1c)" "0,1"
  eventfld.long  0x00 22.                  "    DTROS ,Data transfer request overflow status (w1c)" "0,1"
  bitfld.long  0x00 15.                  "    IPS  ,Channel input pin state" "0,1"
  bitfld.long  0x00 14.                  "    OPS ,Channel output pin state" "0,1"
  bitfld.long  0x00 00.--01.             "   FM   ,Channel function mode" "0,1,2,3"

group.long (0xC3FC0408+0x100*4.+0x10*10.)++0x03
  line.long    0x00 "HSRR10,eTPU B Channel 10 Host Service Request Register"
  bitfld.long  0x00 00.--02.             "HSR ,Host service request" "0,1,2,3,4,5,6,7"


TEXTLINE ""


group.long (0xC3FC0400+0x100*4.+0x10*11.)++0x03
  line.long    0x00 "CR11,eTPU B Channel 11 Configuration Register"
  bitfld.long  0x00 31.                  "CIE ,Channel interrupt enable" "0,1"
  bitfld.long  0x00 30.                  "  DTRE ,Channel data transfer request enable" "0,1"
  bitfld.long  0x00 28.--29.             "  CPR ,Channel priority" "dis,low,mid,high"
  bitfld.long  0x00 25.                  "  ETPD ,This bit selects which channel signal, input or output, is used in the entry point selection" "PSTI,PSTO"
  bitfld.long  0x00 24.                  "  ETCS ,Entry table condition select" "std,alt"
  bitfld.long  0x00 16.--20.             "  CFS ,Channel function select" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
  bitfld.long  0x00 15.                  "  ODIS ,Output disable" "0,1"
TEXTLINE "                "  
  bitfld.long  0x00 14.                  "  OPOL ,Output polarity" "act. low,act. high"
  hexmask.long.word 0x00 00.--10. 2.     " CPBA_eTPU ,channel parameter base address - eTPU addressing"
  hexmask.long.word 0x00 00.--10. 8.     "       CPBA_host ,channel parameter base address - host (byte) addressing"
  textfld "    "   
  button "Data.dump CHBASE" "Data.Dump ANC:(0xC3FC8000+((Data.Long(ANC:0xC3FC0400+0x100*4.+0x10*11.)&0x3FF)*8.)) /DIALOG"

group.long (0xC3FC0404+0x100*4.+0x10*11.)++0x03
  line.long    0x00 "SCR11,eTPU B Channel 11 Status Control Register"
  eventfld.long  0x00 31.                  "CIS ,Channel interrupt (w1c)" "0,1"
  eventfld.long  0x00 30.                  "  CIOS ,Channel interrupt overflow status (w1c)" "0,1"
  eventfld.long  0x00 23.                  "  DTRS ,Data transfer request status (w1c)" "0,1"
  eventfld.long  0x00 22.                  "    DTROS ,Data transfer request overflow status (w1c)" "0,1"
  bitfld.long  0x00 15.                  "    IPS  ,Channel input pin state" "0,1"
  bitfld.long  0x00 14.                  "    OPS ,Channel output pin state" "0,1"
  bitfld.long  0x00 00.--01.             "   FM   ,Channel function mode" "0,1,2,3"

group.long (0xC3FC0408+0x100*4.+0x10*11.)++0x03
  line.long    0x00 "HSRR11,eTPU B Channel 11 Host Service Request Register"
  bitfld.long  0x00 00.--02.             "HSR ,Host service request" "0,1,2,3,4,5,6,7"


TEXTLINE ""


group.long (0xC3FC0400+0x100*4.+0x10*12.)++0x03
  line.long    0x00 "CR12,eTPU B Channel 12 Configuration Register"
  bitfld.long  0x00 31.                  "CIE ,Channel interrupt enable" "0,1"
  bitfld.long  0x00 30.                  "  DTRE ,Channel data transfer request enable" "0,1"
  bitfld.long  0x00 28.--29.             "  CPR ,Channel priority" "dis,low,mid,high"
  bitfld.long  0x00 25.                  "  ETPD ,This bit selects which channel signal, input or output, is used in the entry point selection" "PSTI,PSTO"
  bitfld.long  0x00 24.                  "  ETCS ,Entry table condition select" "std,alt"
  bitfld.long  0x00 16.--20.             "  CFS ,Channel function select" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
  bitfld.long  0x00 15.                  "  ODIS ,Output disable" "0,1"
TEXTLINE "                "  
  bitfld.long  0x00 14.                  "  OPOL ,Output polarity" "act. low,act. high"
  hexmask.long.word 0x00 00.--10. 2.     " CPBA_eTPU ,channel parameter base address - eTPU addressing"
  hexmask.long.word 0x00 00.--10. 8.     "       CPBA_host ,channel parameter base address - host (byte) addressing"
  textfld "    "   
  button "Data.dump CHBASE" "Data.Dump ANC:(0xC3FC8000+((Data.Long(ANC:0xC3FC0400+0x100*4.+0x10*12.)&0x3FF)*8.)) /DIALOG"

group.long (0xC3FC0404+0x100*4.+0x10*12.)++0x03
  line.long    0x00 "SCR12,eTPU B Channel 12 Status Control Register"
  eventfld.long  0x00 31.                  "CIS ,Channel interrupt (w1c)" "0,1"
  eventfld.long  0x00 30.                  "  CIOS ,Channel interrupt overflow status (w1c)" "0,1"
  eventfld.long  0x00 23.                  "  DTRS ,Data transfer request status (w1c)" "0,1"
  eventfld.long  0x00 22.                  "    DTROS ,Data transfer request overflow status (w1c)" "0,1"
  bitfld.long  0x00 15.                  "    IPS  ,Channel input pin state" "0,1"
  bitfld.long  0x00 14.                  "    OPS ,Channel output pin state" "0,1"
  bitfld.long  0x00 00.--01.             "   FM   ,Channel function mode" "0,1,2,3"

group.long (0xC3FC0408+0x100*4.+0x10*12.)++0x03
  line.long    0x00 "HSRR12,eTPU B Channel 12 Host Service Request Register"
  bitfld.long  0x00 00.--02.             "HSR ,Host service request" "0,1,2,3,4,5,6,7"


TEXTLINE ""


group.long (0xC3FC0400+0x100*4.+0x10*13.)++0x03
  line.long    0x00 "CR13,eTPU B Channel 13 Configuration Register"
  bitfld.long  0x00 31.                  "CIE ,Channel interrupt enable" "0,1"
  bitfld.long  0x00 30.                  "  DTRE ,Channel data transfer request enable" "0,1"
  bitfld.long  0x00 28.--29.             "  CPR ,Channel priority" "dis,low,mid,high"
  bitfld.long  0x00 25.                  "  ETPD ,This bit selects which channel signal, input or output, is used in the entry point selection" "PSTI,PSTO"
  bitfld.long  0x00 24.                  "  ETCS ,Entry table condition select" "std,alt"
  bitfld.long  0x00 16.--20.             "  CFS ,Channel function select" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
  bitfld.long  0x00 15.                  "  ODIS ,Output disable" "0,1"
TEXTLINE "                "  
  bitfld.long  0x00 14.                  "  OPOL ,Output polarity" "act. low,act. high"
  hexmask.long.word 0x00 00.--10. 2.     " CPBA_eTPU ,channel parameter base address - eTPU addressing"
  hexmask.long.word 0x00 00.--10. 8.     "       CPBA_host ,channel parameter base address - host (byte) addressing"
  textfld "    "   
  button "Data.dump CHBASE" "Data.Dump ANC:(0xC3FC8000+((Data.Long(ANC:0xC3FC0400+0x100*4.+0x10*13.)&0x3FF)*8.)) /DIALOG"

group.long (0xC3FC0404+0x100*4.+0x10*13.)++0x03
  line.long    0x00 "SCR13,eTPU B Channel 13 Status Control Register"
  eventfld.long  0x00 31.                  "CIS ,Channel interrupt (w1c)" "0,1"
  eventfld.long  0x00 30.                  "  CIOS ,Channel interrupt overflow status (w1c)" "0,1"
  eventfld.long  0x00 23.                  "  DTRS ,Data transfer request status (w1c)" "0,1"
  eventfld.long  0x00 22.                  "    DTROS ,Data transfer request overflow status (w1c)" "0,1"
  bitfld.long  0x00 15.                  "    IPS  ,Channel input pin state" "0,1"
  bitfld.long  0x00 14.                  "    OPS ,Channel output pin state" "0,1"
  bitfld.long  0x00 00.--01.             "   FM   ,Channel function mode" "0,1,2,3"

group.long (0xC3FC0408+0x100*4.+0x10*13.)++0x03
  line.long    0x00 "HSRR13,eTPU B Channel 13 Host Service Request Register"
  bitfld.long  0x00 00.--02.             "HSR ,Host service request" "0,1,2,3,4,5,6,7"


TEXTLINE ""


group.long (0xC3FC0400+0x100*4.+0x10*14.)++0x03
  line.long    0x00 "CR14,eTPU B Channel 14 Configuration Register"
  bitfld.long  0x00 31.                  "CIE ,Channel interrupt enable" "0,1"
  bitfld.long  0x00 30.                  "  DTRE ,Channel data transfer request enable" "0,1"
  bitfld.long  0x00 28.--29.             "  CPR ,Channel priority" "dis,low,mid,high"
  bitfld.long  0x00 25.                  "  ETPD ,This bit selects which channel signal, input or output, is used in the entry point selection" "PSTI,PSTO"
  bitfld.long  0x00 24.                  "  ETCS ,Entry table condition select" "std,alt"
  bitfld.long  0x00 16.--20.             "  CFS ,Channel function select" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
  bitfld.long  0x00 15.                  "  ODIS ,Output disable" "0,1"
TEXTLINE "                "  
  bitfld.long  0x00 14.                  "  OPOL ,Output polarity" "act. low,act. high"
  hexmask.long.word 0x00 00.--10. 2.     " CPBA_eTPU ,channel parameter base address - eTPU addressing"
  hexmask.long.word 0x00 00.--10. 8.     "       CPBA_host ,channel parameter base address - host (byte) addressing"
  textfld "    "   
  button "Data.dump CHBASE" "Data.Dump ANC:(0xC3FC8000+((Data.Long(ANC:0xC3FC0400+0x100*4.+0x10*14.)&0x3FF)*8.)) /DIALOG"

group.long (0xC3FC0404+0x100*4.+0x10*14.)++0x03
  line.long    0x00 "SCR14,eTPU B Channel 14 Status Control Register"
  eventfld.long  0x00 31.                  "CIS ,Channel interrupt (w1c)" "0,1"
  eventfld.long  0x00 30.                  "  CIOS ,Channel interrupt overflow status (w1c)" "0,1"
  eventfld.long  0x00 23.                  "  DTRS ,Data transfer request status (w1c)" "0,1"
  eventfld.long  0x00 22.                  "    DTROS ,Data transfer request overflow status (w1c)" "0,1"
  bitfld.long  0x00 15.                  "    IPS  ,Channel input pin state" "0,1"
  bitfld.long  0x00 14.                  "    OPS ,Channel output pin state" "0,1"
  bitfld.long  0x00 00.--01.             "   FM   ,Channel function mode" "0,1,2,3"

group.long (0xC3FC0408+0x100*4.+0x10*14.)++0x03
  line.long    0x00 "HSRR14,eTPU B Channel 14 Host Service Request Register"
  bitfld.long  0x00 00.--02.             "HSR ,Host service request" "0,1,2,3,4,5,6,7"


TEXTLINE ""


group.long (0xC3FC0400+0x100*4.+0x10*15.)++0x03
  line.long    0x00 "CR15,eTPU B Channel 15 Configuration Register"
  bitfld.long  0x00 31.                  "CIE ,Channel interrupt enable" "0,1"
  bitfld.long  0x00 30.                  "  DTRE ,Channel data transfer request enable" "0,1"
  bitfld.long  0x00 28.--29.             "  CPR ,Channel priority" "dis,low,mid,high"
  bitfld.long  0x00 25.                  "  ETPD ,This bit selects which channel signal, input or output, is used in the entry point selection" "PSTI,PSTO"
  bitfld.long  0x00 24.                  "  ETCS ,Entry table condition select" "std,alt"
  bitfld.long  0x00 16.--20.             "  CFS ,Channel function select" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
  bitfld.long  0x00 15.                  "  ODIS ,Output disable" "0,1"
TEXTLINE "                "  
  bitfld.long  0x00 14.                  "  OPOL ,Output polarity" "act. low,act. high"
  hexmask.long.word 0x00 00.--10. 2.     " CPBA_eTPU ,channel parameter base address - eTPU addressing"
  hexmask.long.word 0x00 00.--10. 8.     "       CPBA_host ,channel parameter base address - host (byte) addressing"
  textfld "    "   
  button "Data.dump CHBASE" "Data.Dump ANC:(0xC3FC8000+((Data.Long(ANC:0xC3FC0400+0x100*4.+0x10*15.)&0x3FF)*8.)) /DIALOG"

group.long (0xC3FC0404+0x100*4.+0x10*15.)++0x03
  line.long    0x00 "SCR15,eTPU B Channel 15 Status Control Register"
  eventfld.long  0x00 31.                  "CIS ,Channel interrupt (w1c)" "0,1"
  eventfld.long  0x00 30.                  "  CIOS ,Channel interrupt overflow status (w1c)" "0,1"
  eventfld.long  0x00 23.                  "  DTRS ,Data transfer request status (w1c)" "0,1"
  eventfld.long  0x00 22.                  "    DTROS ,Data transfer request overflow status (w1c)" "0,1"
  bitfld.long  0x00 15.                  "    IPS  ,Channel input pin state" "0,1"
  bitfld.long  0x00 14.                  "    OPS ,Channel output pin state" "0,1"
  bitfld.long  0x00 00.--01.             "   FM   ,Channel function mode" "0,1,2,3"

group.long (0xC3FC0408+0x100*4.+0x10*15.)++0x03
  line.long    0x00 "HSRR15,eTPU B Channel 15 Host Service Request Register"
  bitfld.long  0x00 00.--02.             "HSR ,Host service request" "0,1,2,3,4,5,6,7"


TEXTLINE ""


group.long (0xC3FC0400+0x100*4.+0x10*16.)++0x03
  line.long    0x00 "CR16,eTPU B Channel 16 Configuration Register"
  bitfld.long  0x00 31.                  "CIE ,Channel interrupt enable" "0,1"
  bitfld.long  0x00 30.                  "  DTRE ,Channel data transfer request enable" "0,1"
  bitfld.long  0x00 28.--29.             "  CPR ,Channel priority" "dis,low,mid,high"
  bitfld.long  0x00 25.                  "  ETPD ,This bit selects which channel signal, input or output, is used in the entry point selection" "PSTI,PSTO"
  bitfld.long  0x00 24.                  "  ETCS ,Entry table condition select" "std,alt"
  bitfld.long  0x00 16.--20.             "  CFS ,Channel function select" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
  bitfld.long  0x00 15.                  "  ODIS ,Output disable" "0,1"
TEXTLINE "                "  
  bitfld.long  0x00 14.                  "  OPOL ,Output polarity" "act. low,act. high"
  hexmask.long.word 0x00 00.--10. 2.     " CPBA_eTPU ,channel parameter base address - eTPU addressing"
  hexmask.long.word 0x00 00.--10. 8.     "       CPBA_host ,channel parameter base address - host (byte) addressing"
  textfld "    "   
  button "Data.dump CHBASE" "Data.Dump ANC:(0xC3FC8000+((Data.Long(ANC:0xC3FC0400+0x100*4.+0x10*16.)&0x3FF)*8.)) /DIALOG"

group.long (0xC3FC0404+0x100*4.+0x10*16.)++0x03
  line.long    0x00 "SCR16,eTPU B Channel 16 Status Control Register"
  eventfld.long  0x00 31.                  "CIS ,Channel interrupt (w1c)" "0,1"
  eventfld.long  0x00 30.                  "  CIOS ,Channel interrupt overflow status (w1c)" "0,1"
  eventfld.long  0x00 23.                  "  DTRS ,Data transfer request status (w1c)" "0,1"
  eventfld.long  0x00 22.                  "    DTROS ,Data transfer request overflow status (w1c)" "0,1"
  bitfld.long  0x00 15.                  "    IPS  ,Channel input pin state" "0,1"
  bitfld.long  0x00 14.                  "    OPS ,Channel output pin state" "0,1"
  bitfld.long  0x00 00.--01.             "   FM   ,Channel function mode" "0,1,2,3"

group.long (0xC3FC0408+0x100*4.+0x10*16.)++0x03
  line.long    0x00 "HSRR16,eTPU B Channel 16 Host Service Request Register"
  bitfld.long  0x00 00.--02.             "HSR ,Host service request" "0,1,2,3,4,5,6,7"


TEXTLINE ""


group.long (0xC3FC0400+0x100*4.+0x10*17.)++0x03
  line.long    0x00 "CR17,eTPU B Channel 17 Configuration Register"
  bitfld.long  0x00 31.                  "CIE ,Channel interrupt enable" "0,1"
  bitfld.long  0x00 30.                  "  DTRE ,Channel data transfer request enable" "0,1"
  bitfld.long  0x00 28.--29.             "  CPR ,Channel priority" "dis,low,mid,high"
  bitfld.long  0x00 25.                  "  ETPD ,This bit selects which channel signal, input or output, is used in the entry point selection" "PSTI,PSTO"
  bitfld.long  0x00 24.                  "  ETCS ,Entry table condition select" "std,alt"
  bitfld.long  0x00 16.--20.             "  CFS ,Channel function select" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
  bitfld.long  0x00 15.                  "  ODIS ,Output disable" "0,1"
TEXTLINE "                "  
  bitfld.long  0x00 14.                  "  OPOL ,Output polarity" "act. low,act. high"
  hexmask.long.word 0x00 00.--10. 2.     " CPBA_eTPU ,channel parameter base address - eTPU addressing"
  hexmask.long.word 0x00 00.--10. 8.     "       CPBA_host ,channel parameter base address - host (byte) addressing"
  textfld "    "   
  button "Data.dump CHBASE" "Data.Dump ANC:(0xC3FC8000+((Data.Long(ANC:0xC3FC0400+0x100*4.+0x10*17.)&0x3FF)*8.)) /DIALOG"

group.long (0xC3FC0404+0x100*4.+0x10*17.)++0x03
  line.long    0x00 "SCR17,eTPU B Channel 17 Status Control Register"
  eventfld.long  0x00 31.                  "CIS ,Channel interrupt (w1c)" "0,1"
  eventfld.long  0x00 30.                  "  CIOS ,Channel interrupt overflow status (w1c)" "0,1"
  eventfld.long  0x00 23.                  "  DTRS ,Data transfer request status (w1c)" "0,1"
  eventfld.long  0x00 22.                  "    DTROS ,Data transfer request overflow status (w1c)" "0,1"
  bitfld.long  0x00 15.                  "    IPS  ,Channel input pin state" "0,1"
  bitfld.long  0x00 14.                  "    OPS ,Channel output pin state" "0,1"
  bitfld.long  0x00 00.--01.             "   FM   ,Channel function mode" "0,1,2,3"

group.long (0xC3FC0408+0x100*4.+0x10*17.)++0x03
  line.long    0x00 "HSRR17,eTPU B Channel 17 Host Service Request Register"
  bitfld.long  0x00 00.--02.             "HSR ,Host service request" "0,1,2,3,4,5,6,7"


TEXTLINE ""


group.long (0xC3FC0400+0x100*4.+0x10*18.)++0x03
  line.long    0x00 "CR18,eTPU B Channel 18 Configuration Register"
  bitfld.long  0x00 31.                  "CIE ,Channel interrupt enable" "0,1"
  bitfld.long  0x00 30.                  "  DTRE ,Channel data transfer request enable" "0,1"
  bitfld.long  0x00 28.--29.             "  CPR ,Channel priority" "dis,low,mid,high"
  bitfld.long  0x00 25.                  "  ETPD ,This bit selects which channel signal, input or output, is used in the entry point selection" "PSTI,PSTO"
  bitfld.long  0x00 24.                  "  ETCS ,Entry table condition select" "std,alt"
  bitfld.long  0x00 16.--20.             "  CFS ,Channel function select" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
  bitfld.long  0x00 15.                  "  ODIS ,Output disable" "0,1"
TEXTLINE "                "  
  bitfld.long  0x00 14.                  "  OPOL ,Output polarity" "act. low,act. high"
  hexmask.long.word 0x00 00.--10. 2.     " CPBA_eTPU ,channel parameter base address - eTPU addressing"
  hexmask.long.word 0x00 00.--10. 8.     "       CPBA_host ,channel parameter base address - host (byte) addressing"
  textfld "    "   
  button "Data.dump CHBASE" "Data.Dump ANC:(0xC3FC8000+((Data.Long(ANC:0xC3FC0400+0x100*4.+0x10*18.)&0x3FF)*8.)) /DIALOG"

group.long (0xC3FC0404+0x100*4.+0x10*18.)++0x03
  line.long    0x00 "SCR18,eTPU B Channel 18 Status Control Register"
  eventfld.long  0x00 31.                  "CIS ,Channel interrupt (w1c)" "0,1"
  eventfld.long  0x00 30.                  "  CIOS ,Channel interrupt overflow status (w1c)" "0,1"
  eventfld.long  0x00 23.                  "  DTRS ,Data transfer request status (w1c)" "0,1"
  eventfld.long  0x00 22.                  "    DTROS ,Data transfer request overflow status (w1c)" "0,1"
  bitfld.long  0x00 15.                  "    IPS  ,Channel input pin state" "0,1"
  bitfld.long  0x00 14.                  "    OPS ,Channel output pin state" "0,1"
  bitfld.long  0x00 00.--01.             "   FM   ,Channel function mode" "0,1,2,3"

group.long (0xC3FC0408+0x100*4.+0x10*18.)++0x03
  line.long    0x00 "HSRR18,eTPU B Channel 18 Host Service Request Register"
  bitfld.long  0x00 00.--02.             "HSR ,Host service request" "0,1,2,3,4,5,6,7"


TEXTLINE ""


group.long (0xC3FC0400+0x100*4.+0x10*19.)++0x03
  line.long    0x00 "CR19,eTPU B Channel 19 Configuration Register"
  bitfld.long  0x00 31.                  "CIE ,Channel interrupt enable" "0,1"
  bitfld.long  0x00 30.                  "  DTRE ,Channel data transfer request enable" "0,1"
  bitfld.long  0x00 28.--29.             "  CPR ,Channel priority" "dis,low,mid,high"
  bitfld.long  0x00 25.                  "  ETPD ,This bit selects which channel signal, input or output, is used in the entry point selection" "PSTI,PSTO"
  bitfld.long  0x00 24.                  "  ETCS ,Entry table condition select" "std,alt"
  bitfld.long  0x00 16.--20.             "  CFS ,Channel function select" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
  bitfld.long  0x00 15.                  "  ODIS ,Output disable" "0,1"
TEXTLINE "                "  
  bitfld.long  0x00 14.                  "  OPOL ,Output polarity" "act. low,act. high"
  hexmask.long.word 0x00 00.--10. 2.     " CPBA_eTPU ,channel parameter base address - eTPU addressing"
  hexmask.long.word 0x00 00.--10. 8.     "       CPBA_host ,channel parameter base address - host (byte) addressing"
  textfld "    "   
  button "Data.dump CHBASE" "Data.Dump ANC:(0xC3FC8000+((Data.Long(ANC:0xC3FC0400+0x100*4.+0x10*19.)&0x3FF)*8.)) /DIALOG"

group.long (0xC3FC0404+0x100*4.+0x10*19.)++0x03
  line.long    0x00 "SCR19,eTPU B Channel 19 Status Control Register"
  eventfld.long  0x00 31.                  "CIS ,Channel interrupt (w1c)" "0,1"
  eventfld.long  0x00 30.                  "  CIOS ,Channel interrupt overflow status (w1c)" "0,1"
  eventfld.long  0x00 23.                  "  DTRS ,Data transfer request status (w1c)" "0,1"
  eventfld.long  0x00 22.                  "    DTROS ,Data transfer request overflow status (w1c)" "0,1"
  bitfld.long  0x00 15.                  "    IPS  ,Channel input pin state" "0,1"
  bitfld.long  0x00 14.                  "    OPS ,Channel output pin state" "0,1"
  bitfld.long  0x00 00.--01.             "   FM   ,Channel function mode" "0,1,2,3"

group.long (0xC3FC0408+0x100*4.+0x10*19.)++0x03
  line.long    0x00 "HSRR19,eTPU B Channel 19 Host Service Request Register"
  bitfld.long  0x00 00.--02.             "HSR ,Host service request" "0,1,2,3,4,5,6,7"


TEXTLINE ""


group.long (0xC3FC0400+0x100*4.+0x10*20.)++0x03
  line.long    0x00 "CR20,eTPU B Channel 20 Configuration Register"
  bitfld.long  0x00 31.                  "CIE ,Channel interrupt enable" "0,1"
  bitfld.long  0x00 30.                  "  DTRE ,Channel data transfer request enable" "0,1"
  bitfld.long  0x00 28.--29.             "  CPR ,Channel priority" "dis,low,mid,high"
  bitfld.long  0x00 25.                  "  ETPD ,This bit selects which channel signal, input or output, is used in the entry point selection" "PSTI,PSTO"
  bitfld.long  0x00 24.                  "  ETCS ,Entry table condition select" "std,alt"
  bitfld.long  0x00 16.--20.             "  CFS ,Channel function select" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
  bitfld.long  0x00 15.                  "  ODIS ,Output disable" "0,1"
TEXTLINE "                "  
  bitfld.long  0x00 14.                  "  OPOL ,Output polarity" "act. low,act. high"
  hexmask.long.word 0x00 00.--10. 2.     " CPBA_eTPU ,channel parameter base address - eTPU addressing"
  hexmask.long.word 0x00 00.--10. 8.     "       CPBA_host ,channel parameter base address - host (byte) addressing"
  textfld "    "   
  button "Data.dump CHBASE" "Data.Dump ANC:(0xC3FC8000+((Data.Long(ANC:0xC3FC0400+0x100*4.+0x10*20.)&0x3FF)*8.)) /DIALOG"

group.long (0xC3FC0404+0x100*4.+0x10*20.)++0x03
  line.long    0x00 "SCR20,eTPU B Channel 20 Status Control Register"
  eventfld.long  0x00 31.                  "CIS ,Channel interrupt (w1c)" "0,1"
  eventfld.long  0x00 30.                  "  CIOS ,Channel interrupt overflow status (w1c)" "0,1"
  eventfld.long  0x00 23.                  "  DTRS ,Data transfer request status (w1c)" "0,1"
  eventfld.long  0x00 22.                  "    DTROS ,Data transfer request overflow status (w1c)" "0,1"
  bitfld.long  0x00 15.                  "    IPS  ,Channel input pin state" "0,1"
  bitfld.long  0x00 14.                  "    OPS ,Channel output pin state" "0,1"
  bitfld.long  0x00 00.--01.             "   FM   ,Channel function mode" "0,1,2,3"

group.long (0xC3FC0408+0x100*4.+0x10*20.)++0x03
  line.long    0x00 "HSRR20,eTPU B Channel 20 Host Service Request Register"
  bitfld.long  0x00 00.--02.             "HSR ,Host service request" "0,1,2,3,4,5,6,7"


TEXTLINE ""


group.long (0xC3FC0400+0x100*4.+0x10*21.)++0x03
  line.long    0x00 "CR21,eTPU B Channel 21 Configuration Register"
  bitfld.long  0x00 31.                  "CIE ,Channel interrupt enable" "0,1"
  bitfld.long  0x00 30.                  "  DTRE ,Channel data transfer request enable" "0,1"
  bitfld.long  0x00 28.--29.             "  CPR ,Channel priority" "dis,low,mid,high"
  bitfld.long  0x00 25.                  "  ETPD ,This bit selects which channel signal, input or output, is used in the entry point selection" "PSTI,PSTO"
  bitfld.long  0x00 24.                  "  ETCS ,Entry table condition select" "std,alt"
  bitfld.long  0x00 16.--20.             "  CFS ,Channel function select" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
  bitfld.long  0x00 15.                  "  ODIS ,Output disable" "0,1"
TEXTLINE "                "  
  bitfld.long  0x00 14.                  "  OPOL ,Output polarity" "act. low,act. high"
  hexmask.long.word 0x00 00.--10. 2.     " CPBA_eTPU ,channel parameter base address - eTPU addressing"
  hexmask.long.word 0x00 00.--10. 8.     "       CPBA_host ,channel parameter base address - host (byte) addressing"
  textfld "    "   
  button "Data.dump CHBASE" "Data.Dump ANC:(0xC3FC8000+((Data.Long(ANC:0xC3FC0400+0x100*4.+0x10*21.)&0x3FF)*8.)) /DIALOG"

group.long (0xC3FC0404+0x100*4.+0x10*21.)++0x03
  line.long    0x00 "SCR21,eTPU B Channel 21 Status Control Register"
  eventfld.long  0x00 31.                  "CIS ,Channel interrupt (w1c)" "0,1"
  eventfld.long  0x00 30.                  "  CIOS ,Channel interrupt overflow status (w1c)" "0,1"
  eventfld.long  0x00 23.                  "  DTRS ,Data transfer request status (w1c)" "0,1"
  eventfld.long  0x00 22.                  "    DTROS ,Data transfer request overflow status (w1c)" "0,1"
  bitfld.long  0x00 15.                  "    IPS  ,Channel input pin state" "0,1"
  bitfld.long  0x00 14.                  "    OPS ,Channel output pin state" "0,1"
  bitfld.long  0x00 00.--01.             "   FM   ,Channel function mode" "0,1,2,3"

group.long (0xC3FC0408+0x100*4.+0x10*21.)++0x03
  line.long    0x00 "HSRR21,eTPU B Channel 21 Host Service Request Register"
  bitfld.long  0x00 00.--02.             "HSR ,Host service request" "0,1,2,3,4,5,6,7"


TEXTLINE ""


group.long (0xC3FC0400+0x100*4.+0x10*22.)++0x03
  line.long    0x00 "CR22,eTPU B Channel 22 Configuration Register"
  bitfld.long  0x00 31.                  "CIE ,Channel interrupt enable" "0,1"
  bitfld.long  0x00 30.                  "  DTRE ,Channel data transfer request enable" "0,1"
  bitfld.long  0x00 28.--29.             "  CPR ,Channel priority" "dis,low,mid,high"
  bitfld.long  0x00 25.                  "  ETPD ,This bit selects which channel signal, input or output, is used in the entry point selection" "PSTI,PSTO"
  bitfld.long  0x00 24.                  "  ETCS ,Entry table condition select" "std,alt"
  bitfld.long  0x00 16.--20.             "  CFS ,Channel function select" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
  bitfld.long  0x00 15.                  "  ODIS ,Output disable" "0,1"
TEXTLINE "                "  
  bitfld.long  0x00 14.                  "  OPOL ,Output polarity" "act. low,act. high"
  hexmask.long.word 0x00 00.--10. 2.     " CPBA_eTPU ,channel parameter base address - eTPU addressing"
  hexmask.long.word 0x00 00.--10. 8.     "       CPBA_host ,channel parameter base address - host (byte) addressing"
  textfld "    "   
  button "Data.dump CHBASE" "Data.Dump ANC:(0xC3FC8000+((Data.Long(ANC:0xC3FC0400+0x100*4.+0x10*22.)&0x3FF)*8.)) /DIALOG"

group.long (0xC3FC0404+0x100*4.+0x10*22.)++0x03
  line.long    0x00 "SCR22,eTPU B Channel 22 Status Control Register"
  eventfld.long  0x00 31.                  "CIS ,Channel interrupt (w1c)" "0,1"
  eventfld.long  0x00 30.                  "  CIOS ,Channel interrupt overflow status (w1c)" "0,1"
  eventfld.long  0x00 23.                  "  DTRS ,Data transfer request status (w1c)" "0,1"
  eventfld.long  0x00 22.                  "    DTROS ,Data transfer request overflow status (w1c)" "0,1"
  bitfld.long  0x00 15.                  "    IPS  ,Channel input pin state" "0,1"
  bitfld.long  0x00 14.                  "    OPS ,Channel output pin state" "0,1"
  bitfld.long  0x00 00.--01.             "   FM   ,Channel function mode" "0,1,2,3"

group.long (0xC3FC0408+0x100*4.+0x10*22.)++0x03
  line.long    0x00 "HSRR22,eTPU B Channel 22 Host Service Request Register"
  bitfld.long  0x00 00.--02.             "HSR ,Host service request" "0,1,2,3,4,5,6,7"


TEXTLINE ""


group.long (0xC3FC0400+0x100*4.+0x10*23.)++0x03
  line.long    0x00 "CR23,eTPU B Channel 23 Configuration Register"
  bitfld.long  0x00 31.                  "CIE ,Channel interrupt enable" "0,1"
  bitfld.long  0x00 30.                  "  DTRE ,Channel data transfer request enable" "0,1"
  bitfld.long  0x00 28.--29.             "  CPR ,Channel priority" "dis,low,mid,high"
  bitfld.long  0x00 25.                  "  ETPD ,This bit selects which channel signal, input or output, is used in the entry point selection" "PSTI,PSTO"
  bitfld.long  0x00 24.                  "  ETCS ,Entry table condition select" "std,alt"
  bitfld.long  0x00 16.--20.             "  CFS ,Channel function select" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
  bitfld.long  0x00 15.                  "  ODIS ,Output disable" "0,1"
TEXTLINE "                "  
  bitfld.long  0x00 14.                  "  OPOL ,Output polarity" "act. low,act. high"
  hexmask.long.word 0x00 00.--10. 2.     " CPBA_eTPU ,channel parameter base address - eTPU addressing"
  hexmask.long.word 0x00 00.--10. 8.     "       CPBA_host ,channel parameter base address - host (byte) addressing"
  textfld "    "   
  button "Data.dump CHBASE" "Data.Dump ANC:(0xC3FC8000+((Data.Long(ANC:0xC3FC0400+0x100*4.+0x10*23.)&0x3FF)*8.)) /DIALOG"

group.long (0xC3FC0404+0x100*4.+0x10*23.)++0x03
  line.long    0x00 "SCR23,eTPU B Channel 23 Status Control Register"
  eventfld.long  0x00 31.                  "CIS ,Channel interrupt (w1c)" "0,1"
  eventfld.long  0x00 30.                  "  CIOS ,Channel interrupt overflow status (w1c)" "0,1"
  eventfld.long  0x00 23.                  "  DTRS ,Data transfer request status (w1c)" "0,1"
  eventfld.long  0x00 22.                  "    DTROS ,Data transfer request overflow status (w1c)" "0,1"
  bitfld.long  0x00 15.                  "    IPS  ,Channel input pin state" "0,1"
  bitfld.long  0x00 14.                  "    OPS ,Channel output pin state" "0,1"
  bitfld.long  0x00 00.--01.             "   FM   ,Channel function mode" "0,1,2,3"

group.long (0xC3FC0408+0x100*4.+0x10*23.)++0x03
  line.long    0x00 "HSRR23,eTPU B Channel 23 Host Service Request Register"
  bitfld.long  0x00 00.--02.             "HSR ,Host service request" "0,1,2,3,4,5,6,7"


TEXTLINE ""


group.long (0xC3FC0400+0x100*4.+0x10*24.)++0x03
  line.long    0x00 "CR24,eTPU B Channel 24 Configuration Register"
  bitfld.long  0x00 31.                  "CIE ,Channel interrupt enable" "0,1"
  bitfld.long  0x00 30.                  "  DTRE ,Channel data transfer request enable" "0,1"
  bitfld.long  0x00 28.--29.             "  CPR ,Channel priority" "dis,low,mid,high"
  bitfld.long  0x00 25.                  "  ETPD ,This bit selects which channel signal, input or output, is used in the entry point selection" "PSTI,PSTO"
  bitfld.long  0x00 24.                  "  ETCS ,Entry table condition select" "std,alt"
  bitfld.long  0x00 16.--20.             "  CFS ,Channel function select" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
  bitfld.long  0x00 15.                  "  ODIS ,Output disable" "0,1"
TEXTLINE "                "  
  bitfld.long  0x00 14.                  "  OPOL ,Output polarity" "act. low,act. high"
  hexmask.long.word 0x00 00.--10. 2.     " CPBA_eTPU ,channel parameter base address - eTPU addressing"
  hexmask.long.word 0x00 00.--10. 8.     "       CPBA_host ,channel parameter base address - host (byte) addressing"
  textfld "    "   
  button "Data.dump CHBASE" "Data.Dump ANC:(0xC3FC8000+((Data.Long(ANC:0xC3FC0400+0x100*4.+0x10*24.)&0x3FF)*8.)) /DIALOG"

group.long (0xC3FC0404+0x100*4.+0x10*24.)++0x03
  line.long    0x00 "SCR24,eTPU B Channel 24 Status Control Register"
  eventfld.long  0x00 31.                  "CIS ,Channel interrupt (w1c)" "0,1"
  eventfld.long  0x00 30.                  "  CIOS ,Channel interrupt overflow status (w1c)" "0,1"
  eventfld.long  0x00 23.                  "  DTRS ,Data transfer request status (w1c)" "0,1"
  eventfld.long  0x00 22.                  "    DTROS ,Data transfer request overflow status (w1c)" "0,1"
  bitfld.long  0x00 15.                  "    IPS  ,Channel input pin state" "0,1"
  bitfld.long  0x00 14.                  "    OPS ,Channel output pin state" "0,1"
  bitfld.long  0x00 00.--01.             "   FM   ,Channel function mode" "0,1,2,3"

group.long (0xC3FC0408+0x100*4.+0x10*24.)++0x03
  line.long    0x00 "HSRR24,eTPU B Channel 24 Host Service Request Register"
  bitfld.long  0x00 00.--02.             "HSR ,Host service request" "0,1,2,3,4,5,6,7"


TEXTLINE ""


group.long (0xC3FC0400+0x100*4.+0x10*25.)++0x03
  line.long    0x00 "CR25,eTPU B Channel 25 Configuration Register"
  bitfld.long  0x00 31.                  "CIE ,Channel interrupt enable" "0,1"
  bitfld.long  0x00 30.                  "  DTRE ,Channel data transfer request enable" "0,1"
  bitfld.long  0x00 28.--29.             "  CPR ,Channel priority" "dis,low,mid,high"
  bitfld.long  0x00 25.                  "  ETPD ,This bit selects which channel signal, input or output, is used in the entry point selection" "PSTI,PSTO"
  bitfld.long  0x00 24.                  "  ETCS ,Entry table condition select" "std,alt"
  bitfld.long  0x00 16.--20.             "  CFS ,Channel function select" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
  bitfld.long  0x00 15.                  "  ODIS ,Output disable" "0,1"
TEXTLINE "                "  
  bitfld.long  0x00 14.                  "  OPOL ,Output polarity" "act. low,act. high"
  hexmask.long.word 0x00 00.--10. 2.     " CPBA_eTPU ,channel parameter base address - eTPU addressing"
  hexmask.long.word 0x00 00.--10. 8.     "       CPBA_host ,channel parameter base address - host (byte) addressing"
  textfld "    "   
  button "Data.dump CHBASE" "Data.Dump ANC:(0xC3FC8000+((Data.Long(ANC:0xC3FC0400+0x100*4.+0x10*25.)&0x3FF)*8.)) /DIALOG"

group.long (0xC3FC0404+0x100*4.+0x10*25.)++0x03
  line.long    0x00 "SCR25,eTPU B Channel 25 Status Control Register"
  eventfld.long  0x00 31.                  "CIS ,Channel interrupt (w1c)" "0,1"
  eventfld.long  0x00 30.                  "  CIOS ,Channel interrupt overflow status (w1c)" "0,1"
  eventfld.long  0x00 23.                  "  DTRS ,Data transfer request status (w1c)" "0,1"
  eventfld.long  0x00 22.                  "    DTROS ,Data transfer request overflow status (w1c)" "0,1"
  bitfld.long  0x00 15.                  "    IPS  ,Channel input pin state" "0,1"
  bitfld.long  0x00 14.                  "    OPS ,Channel output pin state" "0,1"
  bitfld.long  0x00 00.--01.             "   FM   ,Channel function mode" "0,1,2,3"

group.long (0xC3FC0408+0x100*4.+0x10*25.)++0x03
  line.long    0x00 "HSRR25,eTPU B Channel 25 Host Service Request Register"
  bitfld.long  0x00 00.--02.             "HSR ,Host service request" "0,1,2,3,4,5,6,7"


TEXTLINE ""


group.long (0xC3FC0400+0x100*4.+0x10*26.)++0x03
  line.long    0x00 "CR26,eTPU B Channel 26 Configuration Register"
  bitfld.long  0x00 31.                  "CIE ,Channel interrupt enable" "0,1"
  bitfld.long  0x00 30.                  "  DTRE ,Channel data transfer request enable" "0,1"
  bitfld.long  0x00 28.--29.             "  CPR ,Channel priority" "dis,low,mid,high"
  bitfld.long  0x00 25.                  "  ETPD ,This bit selects which channel signal, input or output, is used in the entry point selection" "PSTI,PSTO"
  bitfld.long  0x00 24.                  "  ETCS ,Entry table condition select" "std,alt"
  bitfld.long  0x00 16.--20.             "  CFS ,Channel function select" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
  bitfld.long  0x00 15.                  "  ODIS ,Output disable" "0,1"
TEXTLINE "                "  
  bitfld.long  0x00 14.                  "  OPOL ,Output polarity" "act. low,act. high"
  hexmask.long.word 0x00 00.--10. 2.     " CPBA_eTPU ,channel parameter base address - eTPU addressing"
  hexmask.long.word 0x00 00.--10. 8.     "       CPBA_host ,channel parameter base address - host (byte) addressing"
  textfld "    "   
  button "Data.dump CHBASE" "Data.Dump ANC:(0xC3FC8000+((Data.Long(ANC:0xC3FC0400+0x100*4.+0x10*26.)&0x3FF)*8.)) /DIALOG"

group.long (0xC3FC0404+0x100*4.+0x10*26.)++0x03
  line.long    0x00 "SCR26,eTPU B Channel 26 Status Control Register"
  eventfld.long  0x00 31.                  "CIS ,Channel interrupt (w1c)" "0,1"
  eventfld.long  0x00 30.                  "  CIOS ,Channel interrupt overflow status (w1c)" "0,1"
  eventfld.long  0x00 23.                  "  DTRS ,Data transfer request status (w1c)" "0,1"
  eventfld.long  0x00 22.                  "    DTROS ,Data transfer request overflow status (w1c)" "0,1"
  bitfld.long  0x00 15.                  "    IPS  ,Channel input pin state" "0,1"
  bitfld.long  0x00 14.                  "    OPS ,Channel output pin state" "0,1"
  bitfld.long  0x00 00.--01.             "   FM   ,Channel function mode" "0,1,2,3"

group.long (0xC3FC0408+0x100*4.+0x10*26.)++0x03
  line.long    0x00 "HSRR26,eTPU B Channel 26 Host Service Request Register"
  bitfld.long  0x00 00.--02.             "HSR ,Host service request" "0,1,2,3,4,5,6,7"


TEXTLINE ""


group.long (0xC3FC0400+0x100*4.+0x10*27.)++0x03
  line.long    0x00 "CR27,eTPU B Channel 27 Configuration Register"
  bitfld.long  0x00 31.                  "CIE ,Channel interrupt enable" "0,1"
  bitfld.long  0x00 30.                  "  DTRE ,Channel data transfer request enable" "0,1"
  bitfld.long  0x00 28.--29.             "  CPR ,Channel priority" "dis,low,mid,high"
  bitfld.long  0x00 25.                  "  ETPD ,This bit selects which channel signal, input or output, is used in the entry point selection" "PSTI,PSTO"
  bitfld.long  0x00 24.                  "  ETCS ,Entry table condition select" "std,alt"
  bitfld.long  0x00 16.--20.             "  CFS ,Channel function select" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
  bitfld.long  0x00 15.                  "  ODIS ,Output disable" "0,1"
TEXTLINE "                "  
  bitfld.long  0x00 14.                  "  OPOL ,Output polarity" "act. low,act. high"
  hexmask.long.word 0x00 00.--10. 2.     " CPBA_eTPU ,channel parameter base address - eTPU addressing"
  hexmask.long.word 0x00 00.--10. 8.     "       CPBA_host ,channel parameter base address - host (byte) addressing"
  textfld "    "   
  button "Data.dump CHBASE" "Data.Dump ANC:(0xC3FC8000+((Data.Long(ANC:0xC3FC0400+0x100*4.+0x10*27.)&0x3FF)*8.)) /DIALOG"

group.long (0xC3FC0404+0x100*4.+0x10*27.)++0x03
  line.long    0x00 "SCR27,eTPU B Channel 27 Status Control Register"
  eventfld.long  0x00 31.                  "CIS ,Channel interrupt (w1c)" "0,1"
  eventfld.long  0x00 30.                  "  CIOS ,Channel interrupt overflow status (w1c)" "0,1"
  eventfld.long  0x00 23.                  "  DTRS ,Data transfer request status (w1c)" "0,1"
  eventfld.long  0x00 22.                  "    DTROS ,Data transfer request overflow status (w1c)" "0,1"
  bitfld.long  0x00 15.                  "    IPS  ,Channel input pin state" "0,1"
  bitfld.long  0x00 14.                  "    OPS ,Channel output pin state" "0,1"
  bitfld.long  0x00 00.--01.             "   FM   ,Channel function mode" "0,1,2,3"

group.long (0xC3FC0408+0x100*4.+0x10*27.)++0x03
  line.long    0x00 "HSRR27,eTPU B Channel 27 Host Service Request Register"
  bitfld.long  0x00 00.--02.             "HSR ,Host service request" "0,1,2,3,4,5,6,7"


TEXTLINE ""


group.long (0xC3FC0400+0x100*4.+0x10*28.)++0x03
  line.long    0x00 "CR28,eTPU B Channel 28 Configuration Register"
  bitfld.long  0x00 31.                  "CIE ,Channel interrupt enable" "0,1"
  bitfld.long  0x00 30.                  "  DTRE ,Channel data transfer request enable" "0,1"
  bitfld.long  0x00 28.--29.             "  CPR ,Channel priority" "dis,low,mid,high"
  bitfld.long  0x00 25.                  "  ETPD ,This bit selects which channel signal, input or output, is used in the entry point selection" "PSTI,PSTO"
  bitfld.long  0x00 24.                  "  ETCS ,Entry table condition select" "std,alt"
  bitfld.long  0x00 16.--20.             "  CFS ,Channel function select" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
  bitfld.long  0x00 15.                  "  ODIS ,Output disable" "0,1"
TEXTLINE "                "  
  bitfld.long  0x00 14.                  "  OPOL ,Output polarity" "act. low,act. high"
  hexmask.long.word 0x00 00.--10. 2.     " CPBA_eTPU ,channel parameter base address - eTPU addressing"
  hexmask.long.word 0x00 00.--10. 8.     "       CPBA_host ,channel parameter base address - host (byte) addressing"
  textfld "    "   
  button "Data.dump CHBASE" "Data.Dump ANC:(0xC3FC8000+((Data.Long(ANC:0xC3FC0400+0x100*4.+0x10*28.)&0x3FF)*8.)) /DIALOG"

group.long (0xC3FC0404+0x100*4.+0x10*28.)++0x03
  line.long    0x00 "SCR28,eTPU B Channel 28 Status Control Register"
  eventfld.long  0x00 31.                  "CIS ,Channel interrupt (w1c)" "0,1"
  eventfld.long  0x00 30.                  "  CIOS ,Channel interrupt overflow status (w1c)" "0,1"
  eventfld.long  0x00 23.                  "  DTRS ,Data transfer request status (w1c)" "0,1"
  eventfld.long  0x00 22.                  "    DTROS ,Data transfer request overflow status (w1c)" "0,1"
  bitfld.long  0x00 15.                  "    IPS  ,Channel input pin state" "0,1"
  bitfld.long  0x00 14.                  "    OPS ,Channel output pin state" "0,1"
  bitfld.long  0x00 00.--01.             "   FM   ,Channel function mode" "0,1,2,3"

group.long (0xC3FC0408+0x100*4.+0x10*28.)++0x03
  line.long    0x00 "HSRR28,eTPU B Channel 28 Host Service Request Register"
  bitfld.long  0x00 00.--02.             "HSR ,Host service request" "0,1,2,3,4,5,6,7"


TEXTLINE ""


group.long (0xC3FC0400+0x100*4.+0x10*29.)++0x03
  line.long    0x00 "CR29,eTPU B Channel 29 Configuration Register"
  bitfld.long  0x00 31.                  "CIE ,Channel interrupt enable" "0,1"
  bitfld.long  0x00 30.                  "  DTRE ,Channel data transfer request enable" "0,1"
  bitfld.long  0x00 28.--29.             "  CPR ,Channel priority" "dis,low,mid,high"
  bitfld.long  0x00 25.                  "  ETPD ,This bit selects which channel signal, input or output, is used in the entry point selection" "PSTI,PSTO"
  bitfld.long  0x00 24.                  "  ETCS ,Entry table condition select" "std,alt"
  bitfld.long  0x00 16.--20.             "  CFS ,Channel function select" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
  bitfld.long  0x00 15.                  "  ODIS ,Output disable" "0,1"
TEXTLINE "                "  
  bitfld.long  0x00 14.                  "  OPOL ,Output polarity" "act. low,act. high"
  hexmask.long.word 0x00 00.--10. 2.     " CPBA_eTPU ,channel parameter base address - eTPU addressing"
  hexmask.long.word 0x00 00.--10. 8.     "       CPBA_host ,channel parameter base address - host (byte) addressing"
  textfld "    "   
  button "Data.dump CHBASE" "Data.Dump ANC:(0xC3FC8000+((Data.Long(ANC:0xC3FC0400+0x100*4.+0x10*29.)&0x3FF)*8.)) /DIALOG"

group.long (0xC3FC0404+0x100*4.+0x10*29.)++0x03
  line.long    0x00 "SCR29,eTPU B Channel 29 Status Control Register"
  eventfld.long  0x00 31.                  "CIS ,Channel interrupt (w1c)" "0,1"
  eventfld.long  0x00 30.                  "  CIOS ,Channel interrupt overflow status (w1c)" "0,1"
  eventfld.long  0x00 23.                  "  DTRS ,Data transfer request status (w1c)" "0,1"
  eventfld.long  0x00 22.                  "    DTROS ,Data transfer request overflow status (w1c)" "0,1"
  bitfld.long  0x00 15.                  "    IPS  ,Channel input pin state" "0,1"
  bitfld.long  0x00 14.                  "    OPS ,Channel output pin state" "0,1"
  bitfld.long  0x00 00.--01.             "   FM   ,Channel function mode" "0,1,2,3"

group.long (0xC3FC0408+0x100*4.+0x10*29.)++0x03
  line.long    0x00 "HSRR29,eTPU B Channel 29 Host Service Request Register"
  bitfld.long  0x00 00.--02.             "HSR ,Host service request" "0,1,2,3,4,5,6,7"


TEXTLINE ""


group.long (0xC3FC0400+0x100*4.+0x10*30.)++0x03
  line.long    0x00 "CR30,eTPU B Channel 30 Configuration Register"
  bitfld.long  0x00 31.                  "CIE ,Channel interrupt enable" "0,1"
  bitfld.long  0x00 30.                  "  DTRE ,Channel data transfer request enable" "0,1"
  bitfld.long  0x00 28.--29.             "  CPR ,Channel priority" "dis,low,mid,high"
  bitfld.long  0x00 25.                  "  ETPD ,This bit selects which channel signal, input or output, is used in the entry point selection" "PSTI,PSTO"
  bitfld.long  0x00 24.                  "  ETCS ,Entry table condition select" "std,alt"
  bitfld.long  0x00 16.--20.             "  CFS ,Channel function select" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
  bitfld.long  0x00 15.                  "  ODIS ,Output disable" "0,1"
TEXTLINE "                "  
  bitfld.long  0x00 14.                  "  OPOL ,Output polarity" "act. low,act. high"
  hexmask.long.word 0x00 00.--10. 2.     " CPBA_eTPU ,channel parameter base address - eTPU addressing"
  hexmask.long.word 0x00 00.--10. 8.     "       CPBA_host ,channel parameter base address - host (byte) addressing"
  textfld "    "   
  button "Data.dump CHBASE" "Data.Dump ANC:(0xC3FC8000+((Data.Long(ANC:0xC3FC0400+0x100*4.+0x10*30.)&0x3FF)*8.)) /DIALOG"

group.long (0xC3FC0404+0x100*4.+0x10*30.)++0x03
  line.long    0x00 "SCR30,eTPU B Channel 30 Status Control Register"
  eventfld.long  0x00 31.                  "CIS ,Channel interrupt (w1c)" "0,1"
  eventfld.long  0x00 30.                  "  CIOS ,Channel interrupt overflow status (w1c)" "0,1"
  eventfld.long  0x00 23.                  "  DTRS ,Data transfer request status (w1c)" "0,1"
  eventfld.long  0x00 22.                  "    DTROS ,Data transfer request overflow status (w1c)" "0,1"
  bitfld.long  0x00 15.                  "    IPS  ,Channel input pin state" "0,1"
  bitfld.long  0x00 14.                  "    OPS ,Channel output pin state" "0,1"
  bitfld.long  0x00 00.--01.             "   FM   ,Channel function mode" "0,1,2,3"

group.long (0xC3FC0408+0x100*4.+0x10*30.)++0x03
  line.long    0x00 "HSRR30,eTPU B Channel 30 Host Service Request Register"
  bitfld.long  0x00 00.--02.             "HSR ,Host service request" "0,1,2,3,4,5,6,7"


TEXTLINE ""


group.long (0xC3FC0400+0x100*4.+0x10*31.)++0x03
  line.long    0x00 "CR31,eTPU B Channel 31 Configuration Register"
  bitfld.long  0x00 31.                  "CIE ,Channel interrupt enable" "0,1"
  bitfld.long  0x00 30.                  "  DTRE ,Channel data transfer request enable" "0,1"
  bitfld.long  0x00 28.--29.             "  CPR ,Channel priority" "dis,low,mid,high"
  bitfld.long  0x00 25.                  "  ETPD ,This bit selects which channel signal, input or output, is used in the entry point selection" "PSTI,PSTO"
  bitfld.long  0x00 24.                  "  ETCS ,Entry table condition select" "std,alt"
  bitfld.long  0x00 16.--20.             "  CFS ,Channel function select" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
  bitfld.long  0x00 15.                  "  ODIS ,Output disable" "0,1"
TEXTLINE "                "  
  bitfld.long  0x00 14.                  "  OPOL ,Output polarity" "act. low,act. high"
  hexmask.long.word 0x00 00.--10. 2.     " CPBA_eTPU ,channel parameter base address - eTPU addressing"
  hexmask.long.word 0x00 00.--10. 8.     "       CPBA_host ,channel parameter base address - host (byte) addressing"
  textfld "    "   
  button "Data.dump CHBASE" "Data.Dump ANC:(0xC3FC8000+((Data.Long(ANC:0xC3FC0400+0x100*4.+0x10*31.)&0x3FF)*8.)) /DIALOG"

group.long (0xC3FC0404+0x100*4.+0x10*31.)++0x03
  line.long    0x00 "SCR31,eTPU B Channel 31 Status Control Register"
  eventfld.long  0x00 31.                  "CIS ,Channel interrupt (w1c)" "0,1"
  eventfld.long  0x00 30.                  "  CIOS ,Channel interrupt overflow status (w1c)" "0,1"
  eventfld.long  0x00 23.                  "  DTRS ,Data transfer request status (w1c)" "0,1"
  eventfld.long  0x00 22.                  "    DTROS ,Data transfer request overflow status (w1c)" "0,1"
  bitfld.long  0x00 15.                  "    IPS  ,Channel input pin state" "0,1"
  bitfld.long  0x00 14.                  "    OPS ,Channel output pin state" "0,1"
  bitfld.long  0x00 00.--01.             "   FM   ,Channel function mode" "0,1,2,3"

group.long (0xC3FC0408+0x100*4.+0x10*31.)++0x03
  line.long    0x00 "HSRR31,eTPU B Channel 31 Host Service Request Register"
  bitfld.long  0x00 00.--02.             "HSR ,Host service request" "0,1,2,3,4,5,6,7"


TEXTLINE ""


tree.end 


tree.end

    endif
    tree.end
endif

sif (cpu()=="MPC5533")||(cpu()=="MPC5534")||(cpu()=="MPC5553")||(cpu()=="MPC5554")||(cpu()=="MPC5561")||(cpu()=="MPC5565")||(cpu()=="MPC5566")||(cpu()=="MPC5567")||(cpu()=="MPC5633M")||(cpu()=="MPC5634M")||(cpu()=="SPC563M60")||(cpu()=="SPC563M64")
tree "Enhanced Queued Analog-to-Digital Converter (eQADC)"

group.long (0xFFF80000+0x00000000)++0x03
  line.long    0x00 "MCR,Module Configuration Register"
  bitfld.long  0x00 03.--04.              "ESSIE ,eQADC synchronous serial interface enable" "SSI dis,reserved,SSI ena & SER dis,SSI ena & SER ena"
  bitfld.long  0x00 00.--01.              "  DBG ,Debug enable" "disabled,reserved,FCK stopped,FCK running"

group.long (0xFFF80000+0x00000008)++0x03
  line.long    0x00 "NMSFR,eQADC Null Message Send Format Register"

group.long (0xFFF80000+0x0000000C)++0x03
  line.long    0x00 "ETDFR,eQADC External Trigger Digital Filter Register"

tree "FIFO 0"

group.long ((0xFFF80000)+0x0010+0*0x04)++0x03
  line.long    0x00 "CFPR0,eQADC CFIFO Push Register"
  hide.long    0x20 "RFPR0,eQADC Result FIFO Pop Register"
  in
TEXTLINE ""

group.word ((0xFFF80000)+0x0050+0*0x02)++0x01
  line.word    0x00 "CFCR0,eQADC Command FIFO Control Register"
  bitfld.word  0x00 10.            "    SSE     ,CFIFO single-scan enable bit" "0,1"
  bitfld.word  0x00 09.              "  CFINV   ,CFIFO invalidate bit" "0,1"
  bitfld.word  0x00 04.--07.         "  MODE    ,CFIFO operation mode" "Disabled,Software trigger/single scan,Low level gated external trigger/single scan,High level gated external trigger/single scan,Falling edge external trigger/single scan,Rising edge external trigger/single scan,Falling or rising edge external trigger/single scan,Reserved,Reserved,Software trigger/continuous scan,Low level gated external trigger/continuous scan,High level gated external trigger/continuous scan,Falling edge external trigger/continuous scan,Rising edge external trigger/continuous scan,Falling or rising edge external trigger/continuous scan,Reserved"
TEXTLINE ""

group.word ((0xFFF80000)+0x0060+0*0x02)++0x01
  line.word    0x00 "IDCR0,eQADC Interrupt and eDMA Control Register"
  bitfld.word  0x00 15.              "    NCIE    ,Non-coherency interrupt enable" "0,1"
  bitfld.word  0x00 14.                "  TORIE   ,Trigger overrun interrupt enable" "0,1"
  bitfld.word  0x00 13.                "  PIE     ,Pause interrupt enable" "0,1"
  bitfld.word  0x00 12.                "  EOQIE   ,End-of-queue interrupt enable" "0,1"
  bitfld.word  0x00 11.                "  CFUIE   ,CFIFO underflow interrupt enable" "0,1"
TEXTLINE "                "
  bitfld.word  0x00 09.                "  CFFE    ,CFIFO fill enable" "0,1"
  bitfld.word  0x00 08.                "  CFFS    ,CFIFO fill select" "0,1"
  bitfld.word  0x00 03.                "  RFOIE   ,RFIFO overflow interrupt enable" "0,1"
  bitfld.word  0x00 01.                "  RFDE    ,RFIFO drain enable" "0,1"
  bitfld.word  0x00 00.                "  RFDS    ,RFIFO drain select" "0,1"
TEXTLINE ""


group.long ((0xFFF80000)+0x0070+0*0x04)++0x03
  line.long    0x00 "FISR0,eQADC FIFO and Interrupt Status Register"
  eventfld.long  0x00 31.                "NCF     ,Non-coherency flag" "0,1"
  eventfld.long  0x00 30.              "  TORF    ,Trigger overrun flag" "0,1"
  eventfld.long  0x00 29.              "  PF      ,Pause flag" "0,1"
  eventfld.long  0x00 28.              "  EOQF    ,End-of-queue flag" "0,1"
  eventfld.long  0x00 27.              "  CFUF    ,CFIFO underflow flag" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 26.                "  SSS     ,CFIFO single-scan status bit" "0,1"
  eventfld.long  0x00 25.              "  CFFF    ,CFIFO fill flag" "0,1"
  eventfld.long  0x00 19.              "  RFOF    ,RFIFO overflow flag" "0,1"
  eventfld.long  0x00 17.              "  RFDF    ,RFIFO drain flag" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 12.--15.           "  CFCTR  ,CFIFO entry counter" " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.           "  TNXPTR ,CFIFO transfer next pointer" " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long  0x00 04.--07.           "  RFCTR  ,RFIFO entry counter" " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.           "  POPNXTPTR ,RFIFO pop next pointer" " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
TEXTLINE ""

group.word ((0xFFF80000)+0x0090+0*0x02)++0x01
  line.word    0x00 "CFTCR0,eQADC CFIFO Transfer Counter Register"
TEXTLINE ""

group.long ((0xFFF80000)+0x0100+0*0x40)++0x0f
  line.long    0x00         "CF0R0,CFIFO Data"
  hexmask.long 0x04 0.--31. 1. 0. "CF0R1  ,CFIFO Data"
  hexmask.long 0x08 0.--31. 1. 0. "  CF0R2  ,CFIFO Data"
  hexmask.long 0x0C 0.--31. 1. 0. "  CF0R3  ,CFIFO Data"
TEXTLINE ""

group.long ((0xFFF80000)+0x0300+0*0x40)++0x0f
  line.long    0x00         "RF0R0,RFIFO Data"
  hexmask.long 0x04 0.--31. 1. 0. "RF0R1  ,RFIFO Data"
  hexmask.long 0x08 0.--31. 1. 0. "  RF0R2  ,RFIFO Data"
  hexmask.long 0x0C 0.--31. 1. 0. "  RF0R3  ,RFIFO Data"

tree.end
tree "FIFO 1"

group.long ((0xFFF80000)+0x0010+1*0x04)++0x03
  line.long    0x00 "CFPR1,eQADC CFIFO Push Register"
  hide.long    0x20 "RFPR1,eQADC Result FIFO Pop Register"
  in
TEXTLINE ""

group.word ((0xFFF80000)+0x0050+1*0x02)++0x01
  line.word    0x00 "CFCR1,eQADC Command FIFO Control Register"
  bitfld.word  0x00 10.            "    SSE     ,CFIFO single-scan enable bit" "0,1"
  bitfld.word  0x00 09.              "  CFINV   ,CFIFO invalidate bit" "0,1"
  bitfld.word  0x00 04.--07.         "  MODE    ,CFIFO operation mode" "Disabled,Software trigger/single scan,Low level gated external trigger/single scan,High level gated external trigger/single scan,Falling edge external trigger/single scan,Rising edge external trigger/single scan,Falling or rising edge external trigger/single scan,Reserved,Reserved,Software trigger/continuous scan,Low level gated external trigger/continuous scan,High level gated external trigger/continuous scan,Falling edge external trigger/continuous scan,Rising edge external trigger/continuous scan,Falling or rising edge external trigger/continuous scan,Reserved"
TEXTLINE ""

group.word ((0xFFF80000)+0x0060+1*0x02)++0x01
  line.word    0x00 "IDCR1,eQADC Interrupt and eDMA Control Register"
  bitfld.word  0x00 15.              "    NCIE    ,Non-coherency interrupt enable" "0,1"
  bitfld.word  0x00 14.                "  TORIE   ,Trigger overrun interrupt enable" "0,1"
  bitfld.word  0x00 13.                "  PIE     ,Pause interrupt enable" "0,1"
  bitfld.word  0x00 12.                "  EOQIE   ,End-of-queue interrupt enable" "0,1"
  bitfld.word  0x00 11.                "  CFUIE   ,CFIFO underflow interrupt enable" "0,1"
TEXTLINE "                "
  bitfld.word  0x00 09.                "  CFFE    ,CFIFO fill enable" "0,1"
  bitfld.word  0x00 08.                "  CFFS    ,CFIFO fill select" "0,1"
  bitfld.word  0x00 03.                "  RFOIE   ,RFIFO overflow interrupt enable" "0,1"
  bitfld.word  0x00 01.                "  RFDE    ,RFIFO drain enable" "0,1"
  bitfld.word  0x00 00.                "  RFDS    ,RFIFO drain select" "0,1"
TEXTLINE ""


group.long ((0xFFF80000)+0x0070+1*0x04)++0x03
  line.long    0x00 "FISR1,eQADC FIFO and Interrupt Status Register"
  eventfld.long  0x00 31.                "NCF     ,Non-coherency flag" "0,1"
  eventfld.long  0x00 30.              "  TORF    ,Trigger overrun flag" "0,1"
  eventfld.long  0x00 29.              "  PF      ,Pause flag" "0,1"
  eventfld.long  0x00 28.              "  EOQF    ,End-of-queue flag" "0,1"
  eventfld.long  0x00 27.              "  CFUF    ,CFIFO underflow flag" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 26.                "  SSS     ,CFIFO single-scan status bit" "0,1"
  eventfld.long  0x00 25.              "  CFFF    ,CFIFO fill flag" "0,1"
  eventfld.long  0x00 19.              "  RFOF    ,RFIFO overflow flag" "0,1"
  eventfld.long  0x00 17.              "  RFDF    ,RFIFO drain flag" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 12.--15.           "  CFCTR  ,CFIFO entry counter" " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.           "  TNXPTR ,CFIFO transfer next pointer" " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long  0x00 04.--07.           "  RFCTR  ,RFIFO entry counter" " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.           "  POPNXTPTR ,RFIFO pop next pointer" " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
TEXTLINE ""

group.word ((0xFFF80000)+0x0090+1*0x02)++0x01
  line.word    0x00 "CFTCR1,eQADC CFIFO Transfer Counter Register"
TEXTLINE ""

group.long ((0xFFF80000)+0x0100+1*0x40)++0x0f
  line.long    0x00         "CF1R0,CFIFO Data"
  hexmask.long 0x04 0.--31. 1. 0. "CF1R1  ,CFIFO Data"
  hexmask.long 0x08 0.--31. 1. 0. "  CF1R2  ,CFIFO Data"
  hexmask.long 0x0C 0.--31. 1. 0. "  CF1R3  ,CFIFO Data"
TEXTLINE ""

group.long ((0xFFF80000)+0x0300+1*0x40)++0x0f
  line.long    0x00         "RF1R0,RFIFO Data"
  hexmask.long 0x04 0.--31. 1. 0. "RF1R1  ,RFIFO Data"
  hexmask.long 0x08 0.--31. 1. 0. "  RF1R2  ,RFIFO Data"
  hexmask.long 0x0C 0.--31. 1. 0. "  RF1R3  ,RFIFO Data"

tree.end
tree "FIFO 2"

group.long ((0xFFF80000)+0x0010+2*0x04)++0x03
  line.long    0x00 "CFPR2,eQADC CFIFO Push Register"
  hide.long    0x20 "RFPR2,eQADC Result FIFO Pop Register"
  in
TEXTLINE ""

group.word ((0xFFF80000)+0x0050+2*0x02)++0x01
  line.word    0x00 "CFCR2,eQADC Command FIFO Control Register"
  bitfld.word  0x00 10.            "    SSE     ,CFIFO single-scan enable bit" "0,1"
  bitfld.word  0x00 09.              "  CFINV   ,CFIFO invalidate bit" "0,1"
  bitfld.word  0x00 04.--07.         "  MODE    ,CFIFO operation mode" "Disabled,Software trigger/single scan,Low level gated external trigger/single scan,High level gated external trigger/single scan,Falling edge external trigger/single scan,Rising edge external trigger/single scan,Falling or rising edge external trigger/single scan,Reserved,Reserved,Software trigger/continuous scan,Low level gated external trigger/continuous scan,High level gated external trigger/continuous scan,Falling edge external trigger/continuous scan,Rising edge external trigger/continuous scan,Falling or rising edge external trigger/continuous scan,Reserved"
TEXTLINE ""

group.word ((0xFFF80000)+0x0060+2*0x02)++0x01
  line.word    0x00 "IDCR2,eQADC Interrupt and eDMA Control Register"
  bitfld.word  0x00 15.              "    NCIE    ,Non-coherency interrupt enable" "0,1"
  bitfld.word  0x00 14.                "  TORIE   ,Trigger overrun interrupt enable" "0,1"
  bitfld.word  0x00 13.                "  PIE     ,Pause interrupt enable" "0,1"
  bitfld.word  0x00 12.                "  EOQIE   ,End-of-queue interrupt enable" "0,1"
  bitfld.word  0x00 11.                "  CFUIE   ,CFIFO underflow interrupt enable" "0,1"
TEXTLINE "                "
  bitfld.word  0x00 09.                "  CFFE    ,CFIFO fill enable" "0,1"
  bitfld.word  0x00 08.                "  CFFS    ,CFIFO fill select" "0,1"
  bitfld.word  0x00 03.                "  RFOIE   ,RFIFO overflow interrupt enable" "0,1"
  bitfld.word  0x00 01.                "  RFDE    ,RFIFO drain enable" "0,1"
  bitfld.word  0x00 00.                "  RFDS    ,RFIFO drain select" "0,1"
TEXTLINE ""


group.long ((0xFFF80000)+0x0070+2*0x04)++0x03
  line.long    0x00 "FISR2,eQADC FIFO and Interrupt Status Register"
  eventfld.long  0x00 31.                "NCF     ,Non-coherency flag" "0,1"
  eventfld.long  0x00 30.              "  TORF    ,Trigger overrun flag" "0,1"
  eventfld.long  0x00 29.              "  PF      ,Pause flag" "0,1"
  eventfld.long  0x00 28.              "  EOQF    ,End-of-queue flag" "0,1"
  eventfld.long  0x00 27.              "  CFUF    ,CFIFO underflow flag" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 26.                "  SSS     ,CFIFO single-scan status bit" "0,1"
  eventfld.long  0x00 25.              "  CFFF    ,CFIFO fill flag" "0,1"
  eventfld.long  0x00 19.              "  RFOF    ,RFIFO overflow flag" "0,1"
  eventfld.long  0x00 17.              "  RFDF    ,RFIFO drain flag" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 12.--15.           "  CFCTR  ,CFIFO entry counter" " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.           "  TNXPTR ,CFIFO transfer next pointer" " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long  0x00 04.--07.           "  RFCTR  ,RFIFO entry counter" " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.           "  POPNXTPTR ,RFIFO pop next pointer" " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
TEXTLINE ""

group.word ((0xFFF80000)+0x0090+2*0x02)++0x01
  line.word    0x00 "CFTCR2,eQADC CFIFO Transfer Counter Register"
TEXTLINE ""

group.long ((0xFFF80000)+0x0100+2*0x40)++0x0f
  line.long    0x00         "CF2R0,CFIFO Data"
  hexmask.long 0x04 0.--31. 1. 0. "CF2R1  ,CFIFO Data"
  hexmask.long 0x08 0.--31. 1. 0. "  CF2R2  ,CFIFO Data"
  hexmask.long 0x0C 0.--31. 1. 0. "  CF2R3  ,CFIFO Data"
TEXTLINE ""

group.long ((0xFFF80000)+0x0300+2*0x40)++0x0f
  line.long    0x00         "RF2R0,RFIFO Data"
  hexmask.long 0x04 0.--31. 1. 0. "RF2R1  ,RFIFO Data"
  hexmask.long 0x08 0.--31. 1. 0. "  RF2R2  ,RFIFO Data"
  hexmask.long 0x0C 0.--31. 1. 0. "  RF2R3  ,RFIFO Data"

tree.end
tree "FIFO 3"

group.long ((0xFFF80000)+0x0010+3*0x04)++0x03
  line.long    0x00 "CFPR3,eQADC CFIFO Push Register"
  hide.long    0x20 "RFPR3,eQADC Result FIFO Pop Register"
  in
TEXTLINE ""

group.word ((0xFFF80000)+0x0050+3*0x02)++0x01
  line.word    0x00 "CFCR3,eQADC Command FIFO Control Register"
  bitfld.word  0x00 10.            "    SSE     ,CFIFO single-scan enable bit" "0,1"
  bitfld.word  0x00 09.              "  CFINV   ,CFIFO invalidate bit" "0,1"
  bitfld.word  0x00 04.--07.         "  MODE    ,CFIFO operation mode" "Disabled,Software trigger/single scan,Low level gated external trigger/single scan,High level gated external trigger/single scan,Falling edge external trigger/single scan,Rising edge external trigger/single scan,Falling or rising edge external trigger/single scan,Reserved,Reserved,Software trigger/continuous scan,Low level gated external trigger/continuous scan,High level gated external trigger/continuous scan,Falling edge external trigger/continuous scan,Rising edge external trigger/continuous scan,Falling or rising edge external trigger/continuous scan,Reserved"
TEXTLINE ""

group.word ((0xFFF80000)+0x0060+3*0x02)++0x01
  line.word    0x00 "IDCR3,eQADC Interrupt and eDMA Control Register"
  bitfld.word  0x00 15.              "    NCIE    ,Non-coherency interrupt enable" "0,1"
  bitfld.word  0x00 14.                "  TORIE   ,Trigger overrun interrupt enable" "0,1"
  bitfld.word  0x00 13.                "  PIE     ,Pause interrupt enable" "0,1"
  bitfld.word  0x00 12.                "  EOQIE   ,End-of-queue interrupt enable" "0,1"
  bitfld.word  0x00 11.                "  CFUIE   ,CFIFO underflow interrupt enable" "0,1"
TEXTLINE "                "
  bitfld.word  0x00 09.                "  CFFE    ,CFIFO fill enable" "0,1"
  bitfld.word  0x00 08.                "  CFFS    ,CFIFO fill select" "0,1"
  bitfld.word  0x00 03.                "  RFOIE   ,RFIFO overflow interrupt enable" "0,1"
  bitfld.word  0x00 01.                "  RFDE    ,RFIFO drain enable" "0,1"
  bitfld.word  0x00 00.                "  RFDS    ,RFIFO drain select" "0,1"
TEXTLINE ""


group.long ((0xFFF80000)+0x0070+3*0x04)++0x03
  line.long    0x00 "FISR3,eQADC FIFO and Interrupt Status Register"
  eventfld.long  0x00 31.                "NCF     ,Non-coherency flag" "0,1"
  eventfld.long  0x00 30.              "  TORF    ,Trigger overrun flag" "0,1"
  eventfld.long  0x00 29.              "  PF      ,Pause flag" "0,1"
  eventfld.long  0x00 28.              "  EOQF    ,End-of-queue flag" "0,1"
  eventfld.long  0x00 27.              "  CFUF    ,CFIFO underflow flag" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 26.                "  SSS     ,CFIFO single-scan status bit" "0,1"
  eventfld.long  0x00 25.              "  CFFF    ,CFIFO fill flag" "0,1"
  eventfld.long  0x00 19.              "  RFOF    ,RFIFO overflow flag" "0,1"
  eventfld.long  0x00 17.              "  RFDF    ,RFIFO drain flag" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 12.--15.           "  CFCTR  ,CFIFO entry counter" " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.           "  TNXPTR ,CFIFO transfer next pointer" " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long  0x00 04.--07.           "  RFCTR  ,RFIFO entry counter" " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.           "  POPNXTPTR ,RFIFO pop next pointer" " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
TEXTLINE ""

group.word ((0xFFF80000)+0x0090+3*0x02)++0x01
  line.word    0x00 "CFTCR3,eQADC CFIFO Transfer Counter Register"
TEXTLINE ""

group.long ((0xFFF80000)+0x0100+3*0x40)++0x0f
  line.long    0x00         "CF3R0,CFIFO Data"
  hexmask.long 0x04 0.--31. 1. 0. "CF3R1  ,CFIFO Data"
  hexmask.long 0x08 0.--31. 1. 0. "  CF3R2  ,CFIFO Data"
  hexmask.long 0x0C 0.--31. 1. 0. "  CF3R3  ,CFIFO Data"
TEXTLINE ""

group.long ((0xFFF80000)+0x0300+3*0x40)++0x0f
  line.long    0x00         "RF3R0,RFIFO Data"
  hexmask.long 0x04 0.--31. 1. 0. "RF3R1  ,RFIFO Data"
  hexmask.long 0x08 0.--31. 1. 0. "  RF3R2  ,RFIFO Data"
  hexmask.long 0x0C 0.--31. 1. 0. "  RF3R3  ,RFIFO Data"

tree.end
tree "FIFO 4"

group.long ((0xFFF80000)+0x0010+4*0x04)++0x03
  line.long    0x00 "CFPR4,eQADC CFIFO Push Register"
  hide.long    0x20 "RFPR4,eQADC Result FIFO Pop Register"
  in
TEXTLINE ""

group.word ((0xFFF80000)+0x0050+4*0x02)++0x01
  line.word    0x00 "CFCR4,eQADC Command FIFO Control Register"
  bitfld.word  0x00 10.            "    SSE     ,CFIFO single-scan enable bit" "0,1"
  bitfld.word  0x00 09.              "  CFINV   ,CFIFO invalidate bit" "0,1"
  bitfld.word  0x00 04.--07.         "  MODE    ,CFIFO operation mode" "Disabled,Software trigger/single scan,Low level gated external trigger/single scan,High level gated external trigger/single scan,Falling edge external trigger/single scan,Rising edge external trigger/single scan,Falling or rising edge external trigger/single scan,Reserved,Reserved,Software trigger/continuous scan,Low level gated external trigger/continuous scan,High level gated external trigger/continuous scan,Falling edge external trigger/continuous scan,Rising edge external trigger/continuous scan,Falling or rising edge external trigger/continuous scan,Reserved"
TEXTLINE ""

group.word ((0xFFF80000)+0x0060+4*0x02)++0x01
  line.word    0x00 "IDCR4,eQADC Interrupt and eDMA Control Register"
  bitfld.word  0x00 15.              "    NCIE    ,Non-coherency interrupt enable" "0,1"
  bitfld.word  0x00 14.                "  TORIE   ,Trigger overrun interrupt enable" "0,1"
  bitfld.word  0x00 13.                "  PIE     ,Pause interrupt enable" "0,1"
  bitfld.word  0x00 12.                "  EOQIE   ,End-of-queue interrupt enable" "0,1"
  bitfld.word  0x00 11.                "  CFUIE   ,CFIFO underflow interrupt enable" "0,1"
TEXTLINE "                "
  bitfld.word  0x00 09.                "  CFFE    ,CFIFO fill enable" "0,1"
  bitfld.word  0x00 08.                "  CFFS    ,CFIFO fill select" "0,1"
  bitfld.word  0x00 03.                "  RFOIE   ,RFIFO overflow interrupt enable" "0,1"
  bitfld.word  0x00 01.                "  RFDE    ,RFIFO drain enable" "0,1"
  bitfld.word  0x00 00.                "  RFDS    ,RFIFO drain select" "0,1"
TEXTLINE ""


group.long ((0xFFF80000)+0x0070+4*0x04)++0x03
  line.long    0x00 "FISR4,eQADC FIFO and Interrupt Status Register"
  eventfld.long  0x00 31.                "NCF     ,Non-coherency flag" "0,1"
  eventfld.long  0x00 30.              "  TORF    ,Trigger overrun flag" "0,1"
  eventfld.long  0x00 29.              "  PF      ,Pause flag" "0,1"
  eventfld.long  0x00 28.              "  EOQF    ,End-of-queue flag" "0,1"
  eventfld.long  0x00 27.              "  CFUF    ,CFIFO underflow flag" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 26.                "  SSS     ,CFIFO single-scan status bit" "0,1"
  eventfld.long  0x00 25.              "  CFFF    ,CFIFO fill flag" "0,1"
  eventfld.long  0x00 19.              "  RFOF    ,RFIFO overflow flag" "0,1"
  eventfld.long  0x00 17.              "  RFDF    ,RFIFO drain flag" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 12.--15.           "  CFCTR  ,CFIFO entry counter" " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.           "  TNXPTR ,CFIFO transfer next pointer" " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long  0x00 04.--07.           "  RFCTR  ,RFIFO entry counter" " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.           "  POPNXTPTR ,RFIFO pop next pointer" " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
TEXTLINE ""

group.word ((0xFFF80000)+0x0090+4*0x02)++0x01
  line.word    0x00 "CFTCR4,eQADC CFIFO Transfer Counter Register"
TEXTLINE ""

group.long ((0xFFF80000)+0x0100+4*0x40)++0x0f
  line.long    0x00         "CF4R0,CFIFO Data"
  hexmask.long 0x04 0.--31. 1. 0. "CF4R1  ,CFIFO Data"
  hexmask.long 0x08 0.--31. 1. 0. "  CF4R2  ,CFIFO Data"
  hexmask.long 0x0C 0.--31. 1. 0. "  CF4R3  ,CFIFO Data"
TEXTLINE ""

group.long ((0xFFF80000)+0x0300+4*0x40)++0x0f
  line.long    0x00         "RF4R0,RFIFO Data"
  hexmask.long 0x04 0.--31. 1. 0. "RF4R1  ,RFIFO Data"
  hexmask.long 0x08 0.--31. 1. 0. "  RF4R2  ,RFIFO Data"
  hexmask.long 0x0C 0.--31. 1. 0. "  RF4R3  ,RFIFO Data"

tree.end
tree "FIFO 5"

group.long ((0xFFF80000)+0x0010+5*0x04)++0x03
  line.long    0x00 "CFPR5,eQADC CFIFO Push Register"
  hide.long    0x20 "RFPR5,eQADC Result FIFO Pop Register"
  in
TEXTLINE ""

group.word ((0xFFF80000)+0x0050+5*0x02)++0x01
  line.word    0x00 "CFCR5,eQADC Command FIFO Control Register"
  bitfld.word  0x00 10.            "    SSE     ,CFIFO single-scan enable bit" "0,1"
  bitfld.word  0x00 09.              "  CFINV   ,CFIFO invalidate bit" "0,1"
  bitfld.word  0x00 04.--07.         "  MODE    ,CFIFO operation mode" "Disabled,Software trigger/single scan,Low level gated external trigger/single scan,High level gated external trigger/single scan,Falling edge external trigger/single scan,Rising edge external trigger/single scan,Falling or rising edge external trigger/single scan,Reserved,Reserved,Software trigger/continuous scan,Low level gated external trigger/continuous scan,High level gated external trigger/continuous scan,Falling edge external trigger/continuous scan,Rising edge external trigger/continuous scan,Falling or rising edge external trigger/continuous scan,Reserved"
TEXTLINE ""

group.word ((0xFFF80000)+0x0060+5*0x02)++0x01
  line.word    0x00 "IDCR5,eQADC Interrupt and eDMA Control Register"
  bitfld.word  0x00 15.              "    NCIE    ,Non-coherency interrupt enable" "0,1"
  bitfld.word  0x00 14.                "  TORIE   ,Trigger overrun interrupt enable" "0,1"
  bitfld.word  0x00 13.                "  PIE     ,Pause interrupt enable" "0,1"
  bitfld.word  0x00 12.                "  EOQIE   ,End-of-queue interrupt enable" "0,1"
  bitfld.word  0x00 11.                "  CFUIE   ,CFIFO underflow interrupt enable" "0,1"
TEXTLINE "                "
  bitfld.word  0x00 09.                "  CFFE    ,CFIFO fill enable" "0,1"
  bitfld.word  0x00 08.                "  CFFS    ,CFIFO fill select" "0,1"
  bitfld.word  0x00 03.                "  RFOIE   ,RFIFO overflow interrupt enable" "0,1"
  bitfld.word  0x00 01.                "  RFDE    ,RFIFO drain enable" "0,1"
  bitfld.word  0x00 00.                "  RFDS    ,RFIFO drain select" "0,1"
TEXTLINE ""


group.long ((0xFFF80000)+0x0070+5*0x04)++0x03
  line.long    0x00 "FISR5,eQADC FIFO and Interrupt Status Register"
  eventfld.long  0x00 31.                "NCF     ,Non-coherency flag" "0,1"
  eventfld.long  0x00 30.              "  TORF    ,Trigger overrun flag" "0,1"
  eventfld.long  0x00 29.              "  PF      ,Pause flag" "0,1"
  eventfld.long  0x00 28.              "  EOQF    ,End-of-queue flag" "0,1"
  eventfld.long  0x00 27.              "  CFUF    ,CFIFO underflow flag" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 26.                "  SSS     ,CFIFO single-scan status bit" "0,1"
  eventfld.long  0x00 25.              "  CFFF    ,CFIFO fill flag" "0,1"
  eventfld.long  0x00 19.              "  RFOF    ,RFIFO overflow flag" "0,1"
  eventfld.long  0x00 17.              "  RFDF    ,RFIFO drain flag" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 12.--15.           "  CFCTR  ,CFIFO entry counter" " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.           "  TNXPTR ,CFIFO transfer next pointer" " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long  0x00 04.--07.           "  RFCTR  ,RFIFO entry counter" " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.           "  POPNXTPTR ,RFIFO pop next pointer" " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
TEXTLINE ""

group.word ((0xFFF80000)+0x0090+5*0x02)++0x01
  line.word    0x00 "CFTCR5,eQADC CFIFO Transfer Counter Register"
TEXTLINE ""

group.long ((0xFFF80000)+0x0100+5*0x40)++0x0f
  line.long    0x00         "CF5R0,CFIFO Data"
  hexmask.long 0x04 0.--31. 1. 0. "CF5R1  ,CFIFO Data"
  hexmask.long 0x08 0.--31. 1. 0. "  CF5R2  ,CFIFO Data"
  hexmask.long 0x0C 0.--31. 1. 0. "  CF5R3  ,CFIFO Data"
TEXTLINE ""

group.long ((0xFFF80000)+0x0300+5*0x40)++0x0f
  line.long    0x00         "RF5R0,RFIFO Data"
  hexmask.long 0x04 0.--31. 1. 0. "RF5R1  ,RFIFO Data"
  hexmask.long 0x08 0.--31. 1. 0. "  RF5R2  ,RFIFO Data"
  hexmask.long 0x0C 0.--31. 1. 0. "  RF5R3  ,RFIFO Data"

tree.end

TEXTLINE ""

tree "CFIFO Status Registers"

group.long (0xFFF80000+0x000000A0)++0x03
  line.long    0x00 "CFSSR0,eQADC CFIFO Status Snapshot Register 0"
  bitfld.long  0x00 30.--31.           "CFS0_T0    ,CFIFO status at transfer to ADC0 command buffer" "IDLE,RES.,WAIT,TRIG"
  bitfld.long  0x00 28.--29.         "  CFS1_T0    ,CFIFO status at transfer to ADC0 command buffer" "IDLE,RES.,WAIT,TRIG"
  bitfld.long  0x00 26.--27.         "  CFS2_T0    ,CFIFO status at transfer to ADC0 command buffer" "IDLE,RES.,WAIT,TRIG"
  bitfld.long  0x00 24.--25.         "  CFS3_T0    ,CFIFO status at transfer to ADC0 command buffer" "IDLE,RES.,WAIT,TRIG"
TEXTLINE "                "
  bitfld.long  0x00 22.--23.         "  CFS4_T0    ,CFIFO status at transfer to ADC0 command buffer" "IDLE,RES.,WAIT,TRIG"
  bitfld.long  0x00 20.--21.         "  CFS5_T0    ,CFIFO status at transfer to ADC0 command buffer" "IDLE,RES.,WAIT,TRIG"
TEXTLINE "                "
  bitfld.long  0x00 11.--14.         "  LCFT0      ,Last CFIFO to transfer to ADC0 command buffer" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--10. 1. "    TC_LCFT0   ,Transfer counter for last CFIFO to transfer commands to ADC0 command buffer"
TEXTLINE ""

group.long (0xFFF80000+0x000000A4)++0x03
  line.long    0x00 "CFSSR1,eQADC CFIFO Status Snapshot Register 1"
  bitfld.long  0x00 30.--31.           "CFS0_T1    ,CFIFO status at transfer to ADC1 command buffer" "IDLE,RES.,WAIT,TRIG"
  bitfld.long  0x00 28.--29.         "  CFS1_T1    ,CFIFO status at transfer to ADC1 command buffer" "IDLE,RES.,WAIT,TRIG"
  bitfld.long  0x00 26.--27.         "  CFS2_T1    ,CFIFO status at transfer to ADC1 command buffer" "IDLE,RES.,WAIT,TRIG"
  bitfld.long  0x00 24.--25.         "  CFS3_T1    ,CFIFO status at transfer to ADC1 command buffer" "IDLE,RES.,WAIT,TRIG"
TEXTLINE "                "
  bitfld.long  0x00 22.--23.         "  CFS4_T1    ,CFIFO status at transfer to ADC1 command buffer" "IDLE,RES.,WAIT,TRIG"
  bitfld.long  0x00 20.--21.         "  CFS5_T1    ,CFIFO status at transfer to ADC1 command buffer" "IDLE,RES.,WAIT,TRIG"
TEXTLINE "                "
  bitfld.long  0x00 11.--14.         "  LCFT1      ,Last CFIFO to transfer to ADC1 command buffer" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--10. 1. "    TC_LCFT1   ,Transfer counter for last CFIFO to transfer commands to ADC1 command buffer"
TEXTLINE ""

group.long (0xFFF80000+0x000000A8)++0x03
  line.long    0x00 "CFSSR2,eQADC CFIFO Status Snapshot Register 2"
  bitfld.long  0x00 30.--31.           "CFS0_TSSI  ,CFIFO Status at Transfer through the eQADC SSI" "IDLE,RES.,WAIT,TRIG"
  bitfld.long  0x00 28.--29.         "  CFS1_TSSI  ,CFIFO Status at Transfer through the eQADC SSI" "IDLE,RES.,WAIT,TRIG"
  bitfld.long  0x00 26.--27.         "  CFS2_TSSI  ,CFIFO Status at Transfer through the eQADC SSI" "IDLE,RES.,WAIT,TRIG"
  bitfld.long  0x00 24.--25.         "  CFS3_TSSI  ,CFIFO Status at Transfer through the eQADC SSI" "IDLE,RES.,WAIT,TRIG"
TEXTLINE "                "
  bitfld.long  0x00 22.--23.         "  CFS4_TSSI  ,CFIFO Status at Transfer through the eQADC SSI" "IDLE,RES.,WAIT,TRIG"
  bitfld.long  0x00 20.--21.         "  CFS5_TSSI  ,CFIFO Status at Transfer through the eQADC SSI" "IDLE,RES.,WAIT,TRIG"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  ENI        ,External Command Buffer Number Indicator" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 11.--14.         "  LCFTSSI    ,Last CFIFO to transfer commands through the eQADC SSI" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.word 0x02 00.--10. 1.      "    TC_LCFTSSI ,Transfer counter for last CFIFO to transfer commands through eQADC SSI"
TEXTLINE ""

group.long (0xFFF80000+0x000000AC)++0x03
  line.long    0x00 "CFSR,eQADC CFIFO Status Register"
  bitfld.long  0x00 30.--31.           "CFS0       ,CFIFO status" "IDLE,RES.,WAIT,TRIG"
  bitfld.long  0x00 28.--29.         "  CFS1       ,CFIFO status" "IDLE,RES.,WAIT,TRIG"
  bitfld.long  0x00 26.--27.         "  CFS2       ,CFIFO status" "IDLE,RES.,WAIT,TRIG"
  bitfld.long  0x00 24.--25.         "  CFS3       ,CFIFO status" "IDLE,RES.,WAIT,TRIG"
TEXTLINE "                "
  bitfld.long  0x00 22.--23.         "  CFS4       ,CFIFO status" "IDLE,RES.,WAIT,TRIG"
  bitfld.long  0x00 20.--21.         "  CFS5       ,CFIFO status" "IDLE,RES.,WAIT,TRIG"

tree.end

tree "Serial Interface Registers"

group.long (0xFFF80000+0x000000B4)++0x03
  line.long    0x00 "SSICR,eQADC Synchronous Serial Interface Control Register"
  bitfld.long  0x00 08.--10.           "MDT ,Minimum Delay After Transmission" "1 FCK,2 FCK,3 FCK,4 FCK,5 FCK,6 FCK,7 FCK,8 FCK"
  bitfld.long  0x00 00.--03.         "  BR     ,Baud rate" "1/2,1/3,1/4,1/5,1/6,1/7,1/8,1/9,1/10,1/11,1/12,1/13,1/14,1/15,1/16,1/17"

group.long (0xFFF80000+0x000000B8)++0x03
  line.long    0x00 "SSIRDR,eQADC Synchronous Serial Interface Receive Data Register"
  bitfld.long  0x00 31.           "RDV ,Receive data valid" "0,1"
  hexmask.long 0x00 00.--25. 1. "      R_DATA ,eQADC receive DATA"

tree.end

tree.end

endif

sif (CPUIS("MPC5674*"))
 tree "Enhanced Queued Analog-to-Digital Converter (eQADC)"
tree "eQADC A"

group.long (0xFFF80000+0x00000000)++0x03
  line.long    0x00 "MCR,Module Configuration Register"
  bitfld.long  0x00 03.--04.              "ESSIE ,eQADC synchronous serial interface enable" "SSI dis,reserved,SSI ena & SER dis,SSI ena & SER ena"
  bitfld.long  0x00 00.--01.              "  DBG ,Debug enable" "disabled,reserved,FCK stopped,FCK running"

group.long (0xFFF80000+0x00000008)++0x03
  line.long    0x00 "NMSFR,eQADC Null Message Send Format Register"

group.long (0xFFF80000+0x0000000C)++0x03
  line.long    0x00 "ETDFR,eQADC External Trigger Digital Filter Register"

tree "FIFO 0"

group.long ((0xFFF80000)+0x0010+0*0x04)++0x03
  line.long    0x00 "CFPR0,eQADC CFIFO Push Register"
  hide.long    0x20 "RFPR0,eQADC Result FIFO Pop Register"
  in
TEXTLINE ""

group.word ((0xFFF80000)+0x0050+0*0x02)++0x01
  line.word    0x00 "CFCR0,eQADC Command FIFO Control Register"
  bitfld.word  0x00 10.            "    SSE     ,CFIFO single-scan enable bit" "0,1"
  bitfld.word  0x00 09.              "  CFINV   ,CFIFO invalidate bit" "0,1"
  bitfld.word  0x00 04.--07.         "  MODE    ,CFIFO operation mode" "Disabled,Software trigger/single scan,Low level gated external trigger/single scan,High level gated external trigger/single scan,Falling edge external trigger/single scan,Rising edge external trigger/single scan,Falling or rising edge external trigger/single scan,Reserved,Reserved,Software trigger/continuous scan,Low level gated external trigger/continuous scan,High level gated external trigger/continuous scan,Falling edge external trigger/continuous scan,Rising edge external trigger/continuous scan,Falling or rising edge external trigger/continuous scan,Reserved"
TEXTLINE ""

group.word ((0xFFF80000)+0x0060+0*0x02)++0x01
  line.word    0x00 "IDCR0,eQADC Interrupt and eDMA Control Register"
  bitfld.word  0x00 15.              "    NCIE    ,Non-coherency interrupt enable" "0,1"
  bitfld.word  0x00 14.                "  TORIE   ,Trigger overrun interrupt enable" "0,1"
  bitfld.word  0x00 13.                "  PIE     ,Pause interrupt enable" "0,1"
  bitfld.word  0x00 12.                "  EOQIE   ,End-of-queue interrupt enable" "0,1"
  bitfld.word  0x00 11.                "  CFUIE   ,CFIFO underflow interrupt enable" "0,1"
TEXTLINE "                "
  bitfld.word  0x00 09.                "  CFFE    ,CFIFO fill enable" "0,1"
  bitfld.word  0x00 08.                "  CFFS    ,CFIFO fill select" "0,1"
  bitfld.word  0x00 03.                "  RFOIE   ,RFIFO overflow interrupt enable" "0,1"
  bitfld.word  0x00 01.                "  RFDE    ,RFIFO drain enable" "0,1"
  bitfld.word  0x00 00.                "  RFDS    ,RFIFO drain select" "0,1"
TEXTLINE ""


group.long ((0xFFF80000)+0x0070+0*0x04)++0x03
  line.long    0x00 "FISR0,eQADC FIFO and Interrupt Status Register"
  eventfld.long  0x00 31.                "NCF     ,Non-coherency flag" "0,1"
  eventfld.long  0x00 30.              "  TORF    ,Trigger overrun flag" "0,1"
  eventfld.long  0x00 29.              "  PF      ,Pause flag" "0,1"
  eventfld.long  0x00 28.              "  EOQF    ,End-of-queue flag" "0,1"
  eventfld.long  0x00 27.              "  CFUF    ,CFIFO underflow flag" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 26.                "  SSS     ,CFIFO single-scan status bit" "0,1"
  eventfld.long  0x00 25.              "  CFFF    ,CFIFO fill flag" "0,1"
  eventfld.long  0x00 19.              "  RFOF    ,RFIFO overflow flag" "0,1"
  eventfld.long  0x00 17.              "  RFDF    ,RFIFO drain flag" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 12.--15.           "  CFCTR  ,CFIFO entry counter" " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.           "  TNXPTR ,CFIFO transfer next pointer" " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long  0x00 04.--07.           "  RFCTR  ,RFIFO entry counter" " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.           "  POPNXTPTR ,RFIFO pop next pointer" " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
TEXTLINE ""

group.word ((0xFFF80000)+0x0090+0*0x02)++0x01
  line.word    0x00 "CFTCR0,eQADC CFIFO Transfer Counter Register"
TEXTLINE ""

group.long ((0xFFF80000)+0x0100+0*0x40)++0x0f
  line.long    0x00         "CF0R0,CFIFO Data"
  hexmask.long 0x04 0.--31. 1. 0. "CF0R1  ,CFIFO Data"
  hexmask.long 0x08 0.--31. 1. 0. "  CF0R2  ,CFIFO Data"
  hexmask.long 0x0C 0.--31. 1. 0. "  CF0R3  ,CFIFO Data"
TEXTLINE ""

group.long ((0xFFF80000)+0x0300+0*0x40)++0x0f
  line.long    0x00         "RF0R0,RFIFO Data"
  hexmask.long 0x04 0.--31. 1. 0. "RF0R1  ,RFIFO Data"
  hexmask.long 0x08 0.--31. 1. 0. "  RF0R2  ,RFIFO Data"
  hexmask.long 0x0C 0.--31. 1. 0. "  RF0R3  ,RFIFO Data"

tree.end
tree "FIFO 1"

group.long ((0xFFF80000)+0x0010+1*0x04)++0x03
  line.long    0x00 "CFPR1,eQADC CFIFO Push Register"
  hide.long    0x20 "RFPR1,eQADC Result FIFO Pop Register"
  in
TEXTLINE ""

group.word ((0xFFF80000)+0x0050+1*0x02)++0x01
  line.word    0x00 "CFCR1,eQADC Command FIFO Control Register"
  bitfld.word  0x00 10.            "    SSE     ,CFIFO single-scan enable bit" "0,1"
  bitfld.word  0x00 09.              "  CFINV   ,CFIFO invalidate bit" "0,1"
  bitfld.word  0x00 04.--07.         "  MODE    ,CFIFO operation mode" "Disabled,Software trigger/single scan,Low level gated external trigger/single scan,High level gated external trigger/single scan,Falling edge external trigger/single scan,Rising edge external trigger/single scan,Falling or rising edge external trigger/single scan,Reserved,Reserved,Software trigger/continuous scan,Low level gated external trigger/continuous scan,High level gated external trigger/continuous scan,Falling edge external trigger/continuous scan,Rising edge external trigger/continuous scan,Falling or rising edge external trigger/continuous scan,Reserved"
TEXTLINE ""

group.word ((0xFFF80000)+0x0060+1*0x02)++0x01
  line.word    0x00 "IDCR1,eQADC Interrupt and eDMA Control Register"
  bitfld.word  0x00 15.              "    NCIE    ,Non-coherency interrupt enable" "0,1"
  bitfld.word  0x00 14.                "  TORIE   ,Trigger overrun interrupt enable" "0,1"
  bitfld.word  0x00 13.                "  PIE     ,Pause interrupt enable" "0,1"
  bitfld.word  0x00 12.                "  EOQIE   ,End-of-queue interrupt enable" "0,1"
  bitfld.word  0x00 11.                "  CFUIE   ,CFIFO underflow interrupt enable" "0,1"
TEXTLINE "                "
  bitfld.word  0x00 09.                "  CFFE    ,CFIFO fill enable" "0,1"
  bitfld.word  0x00 08.                "  CFFS    ,CFIFO fill select" "0,1"
  bitfld.word  0x00 03.                "  RFOIE   ,RFIFO overflow interrupt enable" "0,1"
  bitfld.word  0x00 01.                "  RFDE    ,RFIFO drain enable" "0,1"
  bitfld.word  0x00 00.                "  RFDS    ,RFIFO drain select" "0,1"
TEXTLINE ""


group.long ((0xFFF80000)+0x0070+1*0x04)++0x03
  line.long    0x00 "FISR1,eQADC FIFO and Interrupt Status Register"
  eventfld.long  0x00 31.                "NCF     ,Non-coherency flag" "0,1"
  eventfld.long  0x00 30.              "  TORF    ,Trigger overrun flag" "0,1"
  eventfld.long  0x00 29.              "  PF      ,Pause flag" "0,1"
  eventfld.long  0x00 28.              "  EOQF    ,End-of-queue flag" "0,1"
  eventfld.long  0x00 27.              "  CFUF    ,CFIFO underflow flag" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 26.                "  SSS     ,CFIFO single-scan status bit" "0,1"
  eventfld.long  0x00 25.              "  CFFF    ,CFIFO fill flag" "0,1"
  eventfld.long  0x00 19.              "  RFOF    ,RFIFO overflow flag" "0,1"
  eventfld.long  0x00 17.              "  RFDF    ,RFIFO drain flag" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 12.--15.           "  CFCTR  ,CFIFO entry counter" " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.           "  TNXPTR ,CFIFO transfer next pointer" " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long  0x00 04.--07.           "  RFCTR  ,RFIFO entry counter" " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.           "  POPNXTPTR ,RFIFO pop next pointer" " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
TEXTLINE ""

group.word ((0xFFF80000)+0x0090+1*0x02)++0x01
  line.word    0x00 "CFTCR1,eQADC CFIFO Transfer Counter Register"
TEXTLINE ""

group.long ((0xFFF80000)+0x0100+1*0x40)++0x0f
  line.long    0x00         "CF1R0,CFIFO Data"
  hexmask.long 0x04 0.--31. 1. 0. "CF1R1  ,CFIFO Data"
  hexmask.long 0x08 0.--31. 1. 0. "  CF1R2  ,CFIFO Data"
  hexmask.long 0x0C 0.--31. 1. 0. "  CF1R3  ,CFIFO Data"
TEXTLINE ""

group.long ((0xFFF80000)+0x0300+1*0x40)++0x0f
  line.long    0x00         "RF1R0,RFIFO Data"
  hexmask.long 0x04 0.--31. 1. 0. "RF1R1  ,RFIFO Data"
  hexmask.long 0x08 0.--31. 1. 0. "  RF1R2  ,RFIFO Data"
  hexmask.long 0x0C 0.--31. 1. 0. "  RF1R3  ,RFIFO Data"

tree.end
tree "FIFO 2"

group.long ((0xFFF80000)+0x0010+2*0x04)++0x03
  line.long    0x00 "CFPR2,eQADC CFIFO Push Register"
  hide.long    0x20 "RFPR2,eQADC Result FIFO Pop Register"
  in
TEXTLINE ""

group.word ((0xFFF80000)+0x0050+2*0x02)++0x01
  line.word    0x00 "CFCR2,eQADC Command FIFO Control Register"
  bitfld.word  0x00 10.            "    SSE     ,CFIFO single-scan enable bit" "0,1"
  bitfld.word  0x00 09.              "  CFINV   ,CFIFO invalidate bit" "0,1"
  bitfld.word  0x00 04.--07.         "  MODE    ,CFIFO operation mode" "Disabled,Software trigger/single scan,Low level gated external trigger/single scan,High level gated external trigger/single scan,Falling edge external trigger/single scan,Rising edge external trigger/single scan,Falling or rising edge external trigger/single scan,Reserved,Reserved,Software trigger/continuous scan,Low level gated external trigger/continuous scan,High level gated external trigger/continuous scan,Falling edge external trigger/continuous scan,Rising edge external trigger/continuous scan,Falling or rising edge external trigger/continuous scan,Reserved"
TEXTLINE ""

group.word ((0xFFF80000)+0x0060+2*0x02)++0x01
  line.word    0x00 "IDCR2,eQADC Interrupt and eDMA Control Register"
  bitfld.word  0x00 15.              "    NCIE    ,Non-coherency interrupt enable" "0,1"
  bitfld.word  0x00 14.                "  TORIE   ,Trigger overrun interrupt enable" "0,1"
  bitfld.word  0x00 13.                "  PIE     ,Pause interrupt enable" "0,1"
  bitfld.word  0x00 12.                "  EOQIE   ,End-of-queue interrupt enable" "0,1"
  bitfld.word  0x00 11.                "  CFUIE   ,CFIFO underflow interrupt enable" "0,1"
TEXTLINE "                "
  bitfld.word  0x00 09.                "  CFFE    ,CFIFO fill enable" "0,1"
  bitfld.word  0x00 08.                "  CFFS    ,CFIFO fill select" "0,1"
  bitfld.word  0x00 03.                "  RFOIE   ,RFIFO overflow interrupt enable" "0,1"
  bitfld.word  0x00 01.                "  RFDE    ,RFIFO drain enable" "0,1"
  bitfld.word  0x00 00.                "  RFDS    ,RFIFO drain select" "0,1"
TEXTLINE ""


group.long ((0xFFF80000)+0x0070+2*0x04)++0x03
  line.long    0x00 "FISR2,eQADC FIFO and Interrupt Status Register"
  eventfld.long  0x00 31.                "NCF     ,Non-coherency flag" "0,1"
  eventfld.long  0x00 30.              "  TORF    ,Trigger overrun flag" "0,1"
  eventfld.long  0x00 29.              "  PF      ,Pause flag" "0,1"
  eventfld.long  0x00 28.              "  EOQF    ,End-of-queue flag" "0,1"
  eventfld.long  0x00 27.              "  CFUF    ,CFIFO underflow flag" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 26.                "  SSS     ,CFIFO single-scan status bit" "0,1"
  eventfld.long  0x00 25.              "  CFFF    ,CFIFO fill flag" "0,1"
  eventfld.long  0x00 19.              "  RFOF    ,RFIFO overflow flag" "0,1"
  eventfld.long  0x00 17.              "  RFDF    ,RFIFO drain flag" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 12.--15.           "  CFCTR  ,CFIFO entry counter" " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.           "  TNXPTR ,CFIFO transfer next pointer" " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long  0x00 04.--07.           "  RFCTR  ,RFIFO entry counter" " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.           "  POPNXTPTR ,RFIFO pop next pointer" " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
TEXTLINE ""

group.word ((0xFFF80000)+0x0090+2*0x02)++0x01
  line.word    0x00 "CFTCR2,eQADC CFIFO Transfer Counter Register"
TEXTLINE ""

group.long ((0xFFF80000)+0x0100+2*0x40)++0x0f
  line.long    0x00         "CF2R0,CFIFO Data"
  hexmask.long 0x04 0.--31. 1. 0. "CF2R1  ,CFIFO Data"
  hexmask.long 0x08 0.--31. 1. 0. "  CF2R2  ,CFIFO Data"
  hexmask.long 0x0C 0.--31. 1. 0. "  CF2R3  ,CFIFO Data"
TEXTLINE ""

group.long ((0xFFF80000)+0x0300+2*0x40)++0x0f
  line.long    0x00         "RF2R0,RFIFO Data"
  hexmask.long 0x04 0.--31. 1. 0. "RF2R1  ,RFIFO Data"
  hexmask.long 0x08 0.--31. 1. 0. "  RF2R2  ,RFIFO Data"
  hexmask.long 0x0C 0.--31. 1. 0. "  RF2R3  ,RFIFO Data"

tree.end
tree "FIFO 3"

group.long ((0xFFF80000)+0x0010+3*0x04)++0x03
  line.long    0x00 "CFPR3,eQADC CFIFO Push Register"
  hide.long    0x20 "RFPR3,eQADC Result FIFO Pop Register"
  in
TEXTLINE ""

group.word ((0xFFF80000)+0x0050+3*0x02)++0x01
  line.word    0x00 "CFCR3,eQADC Command FIFO Control Register"
  bitfld.word  0x00 10.            "    SSE     ,CFIFO single-scan enable bit" "0,1"
  bitfld.word  0x00 09.              "  CFINV   ,CFIFO invalidate bit" "0,1"
  bitfld.word  0x00 04.--07.         "  MODE    ,CFIFO operation mode" "Disabled,Software trigger/single scan,Low level gated external trigger/single scan,High level gated external trigger/single scan,Falling edge external trigger/single scan,Rising edge external trigger/single scan,Falling or rising edge external trigger/single scan,Reserved,Reserved,Software trigger/continuous scan,Low level gated external trigger/continuous scan,High level gated external trigger/continuous scan,Falling edge external trigger/continuous scan,Rising edge external trigger/continuous scan,Falling or rising edge external trigger/continuous scan,Reserved"
TEXTLINE ""

group.word ((0xFFF80000)+0x0060+3*0x02)++0x01
  line.word    0x00 "IDCR3,eQADC Interrupt and eDMA Control Register"
  bitfld.word  0x00 15.              "    NCIE    ,Non-coherency interrupt enable" "0,1"
  bitfld.word  0x00 14.                "  TORIE   ,Trigger overrun interrupt enable" "0,1"
  bitfld.word  0x00 13.                "  PIE     ,Pause interrupt enable" "0,1"
  bitfld.word  0x00 12.                "  EOQIE   ,End-of-queue interrupt enable" "0,1"
  bitfld.word  0x00 11.                "  CFUIE   ,CFIFO underflow interrupt enable" "0,1"
TEXTLINE "                "
  bitfld.word  0x00 09.                "  CFFE    ,CFIFO fill enable" "0,1"
  bitfld.word  0x00 08.                "  CFFS    ,CFIFO fill select" "0,1"
  bitfld.word  0x00 03.                "  RFOIE   ,RFIFO overflow interrupt enable" "0,1"
  bitfld.word  0x00 01.                "  RFDE    ,RFIFO drain enable" "0,1"
  bitfld.word  0x00 00.                "  RFDS    ,RFIFO drain select" "0,1"
TEXTLINE ""


group.long ((0xFFF80000)+0x0070+3*0x04)++0x03
  line.long    0x00 "FISR3,eQADC FIFO and Interrupt Status Register"
  eventfld.long  0x00 31.                "NCF     ,Non-coherency flag" "0,1"
  eventfld.long  0x00 30.              "  TORF    ,Trigger overrun flag" "0,1"
  eventfld.long  0x00 29.              "  PF      ,Pause flag" "0,1"
  eventfld.long  0x00 28.              "  EOQF    ,End-of-queue flag" "0,1"
  eventfld.long  0x00 27.              "  CFUF    ,CFIFO underflow flag" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 26.                "  SSS     ,CFIFO single-scan status bit" "0,1"
  eventfld.long  0x00 25.              "  CFFF    ,CFIFO fill flag" "0,1"
  eventfld.long  0x00 19.              "  RFOF    ,RFIFO overflow flag" "0,1"
  eventfld.long  0x00 17.              "  RFDF    ,RFIFO drain flag" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 12.--15.           "  CFCTR  ,CFIFO entry counter" " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.           "  TNXPTR ,CFIFO transfer next pointer" " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long  0x00 04.--07.           "  RFCTR  ,RFIFO entry counter" " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.           "  POPNXTPTR ,RFIFO pop next pointer" " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
TEXTLINE ""

group.word ((0xFFF80000)+0x0090+3*0x02)++0x01
  line.word    0x00 "CFTCR3,eQADC CFIFO Transfer Counter Register"
TEXTLINE ""

group.long ((0xFFF80000)+0x0100+3*0x40)++0x0f
  line.long    0x00         "CF3R0,CFIFO Data"
  hexmask.long 0x04 0.--31. 1. 0. "CF3R1  ,CFIFO Data"
  hexmask.long 0x08 0.--31. 1. 0. "  CF3R2  ,CFIFO Data"
  hexmask.long 0x0C 0.--31. 1. 0. "  CF3R3  ,CFIFO Data"
TEXTLINE ""

group.long ((0xFFF80000)+0x0300+3*0x40)++0x0f
  line.long    0x00         "RF3R0,RFIFO Data"
  hexmask.long 0x04 0.--31. 1. 0. "RF3R1  ,RFIFO Data"
  hexmask.long 0x08 0.--31. 1. 0. "  RF3R2  ,RFIFO Data"
  hexmask.long 0x0C 0.--31. 1. 0. "  RF3R3  ,RFIFO Data"

tree.end
tree "FIFO 4"

group.long ((0xFFF80000)+0x0010+4*0x04)++0x03
  line.long    0x00 "CFPR4,eQADC CFIFO Push Register"
  hide.long    0x20 "RFPR4,eQADC Result FIFO Pop Register"
  in
TEXTLINE ""

group.word ((0xFFF80000)+0x0050+4*0x02)++0x01
  line.word    0x00 "CFCR4,eQADC Command FIFO Control Register"
  bitfld.word  0x00 10.            "    SSE     ,CFIFO single-scan enable bit" "0,1"
  bitfld.word  0x00 09.              "  CFINV   ,CFIFO invalidate bit" "0,1"
  bitfld.word  0x00 04.--07.         "  MODE    ,CFIFO operation mode" "Disabled,Software trigger/single scan,Low level gated external trigger/single scan,High level gated external trigger/single scan,Falling edge external trigger/single scan,Rising edge external trigger/single scan,Falling or rising edge external trigger/single scan,Reserved,Reserved,Software trigger/continuous scan,Low level gated external trigger/continuous scan,High level gated external trigger/continuous scan,Falling edge external trigger/continuous scan,Rising edge external trigger/continuous scan,Falling or rising edge external trigger/continuous scan,Reserved"
TEXTLINE ""

group.word ((0xFFF80000)+0x0060+4*0x02)++0x01
  line.word    0x00 "IDCR4,eQADC Interrupt and eDMA Control Register"
  bitfld.word  0x00 15.              "    NCIE    ,Non-coherency interrupt enable" "0,1"
  bitfld.word  0x00 14.                "  TORIE   ,Trigger overrun interrupt enable" "0,1"
  bitfld.word  0x00 13.                "  PIE     ,Pause interrupt enable" "0,1"
  bitfld.word  0x00 12.                "  EOQIE   ,End-of-queue interrupt enable" "0,1"
  bitfld.word  0x00 11.                "  CFUIE   ,CFIFO underflow interrupt enable" "0,1"
TEXTLINE "                "
  bitfld.word  0x00 09.                "  CFFE    ,CFIFO fill enable" "0,1"
  bitfld.word  0x00 08.                "  CFFS    ,CFIFO fill select" "0,1"
  bitfld.word  0x00 03.                "  RFOIE   ,RFIFO overflow interrupt enable" "0,1"
  bitfld.word  0x00 01.                "  RFDE    ,RFIFO drain enable" "0,1"
  bitfld.word  0x00 00.                "  RFDS    ,RFIFO drain select" "0,1"
TEXTLINE ""


group.long ((0xFFF80000)+0x0070+4*0x04)++0x03
  line.long    0x00 "FISR4,eQADC FIFO and Interrupt Status Register"
  eventfld.long  0x00 31.                "NCF     ,Non-coherency flag" "0,1"
  eventfld.long  0x00 30.              "  TORF    ,Trigger overrun flag" "0,1"
  eventfld.long  0x00 29.              "  PF      ,Pause flag" "0,1"
  eventfld.long  0x00 28.              "  EOQF    ,End-of-queue flag" "0,1"
  eventfld.long  0x00 27.              "  CFUF    ,CFIFO underflow flag" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 26.                "  SSS     ,CFIFO single-scan status bit" "0,1"
  eventfld.long  0x00 25.              "  CFFF    ,CFIFO fill flag" "0,1"
  eventfld.long  0x00 19.              "  RFOF    ,RFIFO overflow flag" "0,1"
  eventfld.long  0x00 17.              "  RFDF    ,RFIFO drain flag" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 12.--15.           "  CFCTR  ,CFIFO entry counter" " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.           "  TNXPTR ,CFIFO transfer next pointer" " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long  0x00 04.--07.           "  RFCTR  ,RFIFO entry counter" " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.           "  POPNXTPTR ,RFIFO pop next pointer" " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
TEXTLINE ""

group.word ((0xFFF80000)+0x0090+4*0x02)++0x01
  line.word    0x00 "CFTCR4,eQADC CFIFO Transfer Counter Register"
TEXTLINE ""

group.long ((0xFFF80000)+0x0100+4*0x40)++0x0f
  line.long    0x00         "CF4R0,CFIFO Data"
  hexmask.long 0x04 0.--31. 1. 0. "CF4R1  ,CFIFO Data"
  hexmask.long 0x08 0.--31. 1. 0. "  CF4R2  ,CFIFO Data"
  hexmask.long 0x0C 0.--31. 1. 0. "  CF4R3  ,CFIFO Data"
TEXTLINE ""

group.long ((0xFFF80000)+0x0300+4*0x40)++0x0f
  line.long    0x00         "RF4R0,RFIFO Data"
  hexmask.long 0x04 0.--31. 1. 0. "RF4R1  ,RFIFO Data"
  hexmask.long 0x08 0.--31. 1. 0. "  RF4R2  ,RFIFO Data"
  hexmask.long 0x0C 0.--31. 1. 0. "  RF4R3  ,RFIFO Data"

tree.end
tree "FIFO 5"

group.long ((0xFFF80000)+0x0010+5*0x04)++0x03
  line.long    0x00 "CFPR5,eQADC CFIFO Push Register"
  hide.long    0x20 "RFPR5,eQADC Result FIFO Pop Register"
  in
TEXTLINE ""

group.word ((0xFFF80000)+0x0050+5*0x02)++0x01
  line.word    0x00 "CFCR5,eQADC Command FIFO Control Register"
  bitfld.word  0x00 10.            "    SSE     ,CFIFO single-scan enable bit" "0,1"
  bitfld.word  0x00 09.              "  CFINV   ,CFIFO invalidate bit" "0,1"
  bitfld.word  0x00 04.--07.         "  MODE    ,CFIFO operation mode" "Disabled,Software trigger/single scan,Low level gated external trigger/single scan,High level gated external trigger/single scan,Falling edge external trigger/single scan,Rising edge external trigger/single scan,Falling or rising edge external trigger/single scan,Reserved,Reserved,Software trigger/continuous scan,Low level gated external trigger/continuous scan,High level gated external trigger/continuous scan,Falling edge external trigger/continuous scan,Rising edge external trigger/continuous scan,Falling or rising edge external trigger/continuous scan,Reserved"
TEXTLINE ""

group.word ((0xFFF80000)+0x0060+5*0x02)++0x01
  line.word    0x00 "IDCR5,eQADC Interrupt and eDMA Control Register"
  bitfld.word  0x00 15.              "    NCIE    ,Non-coherency interrupt enable" "0,1"
  bitfld.word  0x00 14.                "  TORIE   ,Trigger overrun interrupt enable" "0,1"
  bitfld.word  0x00 13.                "  PIE     ,Pause interrupt enable" "0,1"
  bitfld.word  0x00 12.                "  EOQIE   ,End-of-queue interrupt enable" "0,1"
  bitfld.word  0x00 11.                "  CFUIE   ,CFIFO underflow interrupt enable" "0,1"
TEXTLINE "                "
  bitfld.word  0x00 09.                "  CFFE    ,CFIFO fill enable" "0,1"
  bitfld.word  0x00 08.                "  CFFS    ,CFIFO fill select" "0,1"
  bitfld.word  0x00 03.                "  RFOIE   ,RFIFO overflow interrupt enable" "0,1"
  bitfld.word  0x00 01.                "  RFDE    ,RFIFO drain enable" "0,1"
  bitfld.word  0x00 00.                "  RFDS    ,RFIFO drain select" "0,1"
TEXTLINE ""


group.long ((0xFFF80000)+0x0070+5*0x04)++0x03
  line.long    0x00 "FISR5,eQADC FIFO and Interrupt Status Register"
  eventfld.long  0x00 31.                "NCF     ,Non-coherency flag" "0,1"
  eventfld.long  0x00 30.              "  TORF    ,Trigger overrun flag" "0,1"
  eventfld.long  0x00 29.              "  PF      ,Pause flag" "0,1"
  eventfld.long  0x00 28.              "  EOQF    ,End-of-queue flag" "0,1"
  eventfld.long  0x00 27.              "  CFUF    ,CFIFO underflow flag" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 26.                "  SSS     ,CFIFO single-scan status bit" "0,1"
  eventfld.long  0x00 25.              "  CFFF    ,CFIFO fill flag" "0,1"
  eventfld.long  0x00 19.              "  RFOF    ,RFIFO overflow flag" "0,1"
  eventfld.long  0x00 17.              "  RFDF    ,RFIFO drain flag" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 12.--15.           "  CFCTR  ,CFIFO entry counter" " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.           "  TNXPTR ,CFIFO transfer next pointer" " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long  0x00 04.--07.           "  RFCTR  ,RFIFO entry counter" " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.           "  POPNXTPTR ,RFIFO pop next pointer" " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
TEXTLINE ""

group.word ((0xFFF80000)+0x0090+5*0x02)++0x01
  line.word    0x00 "CFTCR5,eQADC CFIFO Transfer Counter Register"
TEXTLINE ""

group.long ((0xFFF80000)+0x0100+5*0x40)++0x0f
  line.long    0x00         "CF5R0,CFIFO Data"
  hexmask.long 0x04 0.--31. 1. 0. "CF5R1  ,CFIFO Data"
  hexmask.long 0x08 0.--31. 1. 0. "  CF5R2  ,CFIFO Data"
  hexmask.long 0x0C 0.--31. 1. 0. "  CF5R3  ,CFIFO Data"
TEXTLINE ""

group.long ((0xFFF80000)+0x0300+5*0x40)++0x0f
  line.long    0x00         "RF5R0,RFIFO Data"
  hexmask.long 0x04 0.--31. 1. 0. "RF5R1  ,RFIFO Data"
  hexmask.long 0x08 0.--31. 1. 0. "  RF5R2  ,RFIFO Data"
  hexmask.long 0x0C 0.--31. 1. 0. "  RF5R3  ,RFIFO Data"

tree.end

TEXTLINE ""

tree "CFIFO Status Registers"

group.long (0xFFF80000+0x000000A0)++0x03
  line.long    0x00 "CFSSR0,eQADC CFIFO Status Snapshot Register 0"
  bitfld.long  0x00 30.--31.           "CFS0_T0    ,CFIFO status at transfer to ADC0 command buffer" "IDLE,RES.,WAIT,TRIG"
  bitfld.long  0x00 28.--29.         "  CFS1_T0    ,CFIFO status at transfer to ADC0 command buffer" "IDLE,RES.,WAIT,TRIG"
  bitfld.long  0x00 26.--27.         "  CFS2_T0    ,CFIFO status at transfer to ADC0 command buffer" "IDLE,RES.,WAIT,TRIG"
  bitfld.long  0x00 24.--25.         "  CFS3_T0    ,CFIFO status at transfer to ADC0 command buffer" "IDLE,RES.,WAIT,TRIG"
TEXTLINE "                "
  bitfld.long  0x00 22.--23.         "  CFS4_T0    ,CFIFO status at transfer to ADC0 command buffer" "IDLE,RES.,WAIT,TRIG"
  bitfld.long  0x00 20.--21.         "  CFS5_T0    ,CFIFO status at transfer to ADC0 command buffer" "IDLE,RES.,WAIT,TRIG"
TEXTLINE "                "
  bitfld.long  0x00 11.--14.         "  LCFT0      ,Last CFIFO to transfer to ADC0 command buffer" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--10. 1. "    TC_LCFT0   ,Transfer counter for last CFIFO to transfer commands to ADC0 command buffer"
TEXTLINE ""

group.long (0xFFF80000+0x000000A4)++0x03
  line.long    0x00 "CFSSR1,eQADC CFIFO Status Snapshot Register 1"
  bitfld.long  0x00 30.--31.           "CFS0_T1    ,CFIFO status at transfer to ADC1 command buffer" "IDLE,RES.,WAIT,TRIG"
  bitfld.long  0x00 28.--29.         "  CFS1_T1    ,CFIFO status at transfer to ADC1 command buffer" "IDLE,RES.,WAIT,TRIG"
  bitfld.long  0x00 26.--27.         "  CFS2_T1    ,CFIFO status at transfer to ADC1 command buffer" "IDLE,RES.,WAIT,TRIG"
  bitfld.long  0x00 24.--25.         "  CFS3_T1    ,CFIFO status at transfer to ADC1 command buffer" "IDLE,RES.,WAIT,TRIG"
TEXTLINE "                "
  bitfld.long  0x00 22.--23.         "  CFS4_T1    ,CFIFO status at transfer to ADC1 command buffer" "IDLE,RES.,WAIT,TRIG"
  bitfld.long  0x00 20.--21.         "  CFS5_T1    ,CFIFO status at transfer to ADC1 command buffer" "IDLE,RES.,WAIT,TRIG"
TEXTLINE "                "
  bitfld.long  0x00 11.--14.         "  LCFT1      ,Last CFIFO to transfer to ADC1 command buffer" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--10. 1. "    TC_LCFT1   ,Transfer counter for last CFIFO to transfer commands to ADC1 command buffer"
TEXTLINE ""

group.long (0xFFF80000+0x000000A8)++0x03
  line.long    0x00 "CFSSR2,eQADC CFIFO Status Snapshot Register 2"
  bitfld.long  0x00 30.--31.           "CFS0_TSSI  ,CFIFO Status at Transfer through the eQADC SSI" "IDLE,RES.,WAIT,TRIG"
  bitfld.long  0x00 28.--29.         "  CFS1_TSSI  ,CFIFO Status at Transfer through the eQADC SSI" "IDLE,RES.,WAIT,TRIG"
  bitfld.long  0x00 26.--27.         "  CFS2_TSSI  ,CFIFO Status at Transfer through the eQADC SSI" "IDLE,RES.,WAIT,TRIG"
  bitfld.long  0x00 24.--25.         "  CFS3_TSSI  ,CFIFO Status at Transfer through the eQADC SSI" "IDLE,RES.,WAIT,TRIG"
TEXTLINE "                "
  bitfld.long  0x00 22.--23.         "  CFS4_TSSI  ,CFIFO Status at Transfer through the eQADC SSI" "IDLE,RES.,WAIT,TRIG"
  bitfld.long  0x00 20.--21.         "  CFS5_TSSI  ,CFIFO Status at Transfer through the eQADC SSI" "IDLE,RES.,WAIT,TRIG"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  ENI        ,External Command Buffer Number Indicator" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 11.--14.         "  LCFTSSI    ,Last CFIFO to transfer commands through the eQADC SSI" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.word 0x02 00.--10. 1.      "    TC_LCFTSSI ,Transfer counter for last CFIFO to transfer commands through eQADC SSI"
TEXTLINE ""

group.long (0xFFF80000+0x000000AC)++0x03
  line.long    0x00 "CFSR,eQADC CFIFO Status Register"
  bitfld.long  0x00 30.--31.           "CFS0       ,CFIFO status" "IDLE,RES.,WAIT,TRIG"
  bitfld.long  0x00 28.--29.         "  CFS1       ,CFIFO status" "IDLE,RES.,WAIT,TRIG"
  bitfld.long  0x00 26.--27.         "  CFS2       ,CFIFO status" "IDLE,RES.,WAIT,TRIG"
  bitfld.long  0x00 24.--25.         "  CFS3       ,CFIFO status" "IDLE,RES.,WAIT,TRIG"
TEXTLINE "                "
  bitfld.long  0x00 22.--23.         "  CFS4       ,CFIFO status" "IDLE,RES.,WAIT,TRIG"
  bitfld.long  0x00 20.--21.         "  CFS5       ,CFIFO status" "IDLE,RES.,WAIT,TRIG"

tree.end

tree "Serial Interface Registers"

group.long (0xFFF80000+0x000000B4)++0x03
  line.long    0x00 "SSICR,eQADC Synchronous Serial Interface Control Register"
  bitfld.long  0x00 08.--10.           "MDT ,Minimum Delay After Transmission" "1 FCK,2 FCK,3 FCK,4 FCK,5 FCK,6 FCK,7 FCK,8 FCK"
  bitfld.long  0x00 00.--03.         "  BR     ,Baud rate" "1/2,1/3,1/4,1/5,1/6,1/7,1/8,1/9,1/10,1/11,1/12,1/13,1/14,1/15,1/16,1/17"

group.long (0xFFF80000+0x000000B8)++0x03
  line.long    0x00 "SSIRDR,eQADC Synchronous Serial Interface Receive Data Register"
  bitfld.long  0x00 31.           "RDV ,Receive data valid" "0,1"
  hexmask.long 0x00 00.--25. 1. "      R_DATA ,eQADC receive DATA"

tree.end

tree.end

tree "eQADC B"

group.long (0xFFF84000+0x00000000)++0x03
  line.long    0x00 "MCR,Module Configuration Register"
  bitfld.long  0x00 03.--04.              "ESSIE ,eQADC synchronous serial interface enable" "SSI dis,reserved,SSI ena & SER dis,SSI ena & SER ena"
  bitfld.long  0x00 00.--01.              "  DBG ,Debug enable" "disabled,reserved,FCK stopped,FCK running"

group.long (0xFFF84000+0x00000008)++0x03
  line.long    0x00 "NMSFR,eQADC Null Message Send Format Register"

group.long (0xFFF84000+0x0000000C)++0x03
  line.long    0x00 "ETDFR,eQADC External Trigger Digital Filter Register"

tree "FIFO 0"

group.long ((0xFFF84000)+0x0010+0*0x04)++0x03
  line.long    0x00 "CFPR0,eQADC CFIFO Push Register"
  hide.long    0x20 "RFPR0,eQADC Result FIFO Pop Register"
  in
TEXTLINE ""

group.word ((0xFFF84000)+0x0050+0*0x02)++0x01
  line.word    0x00 "CFCR0,eQADC Command FIFO Control Register"
  bitfld.word  0x00 10.            "    SSE     ,CFIFO single-scan enable bit" "0,1"
  bitfld.word  0x00 09.              "  CFINV   ,CFIFO invalidate bit" "0,1"
  bitfld.word  0x00 04.--07.         "  MODE    ,CFIFO operation mode" "Disabled,Software trigger/single scan,Low level gated external trigger/single scan,High level gated external trigger/single scan,Falling edge external trigger/single scan,Rising edge external trigger/single scan,Falling or rising edge external trigger/single scan,Reserved,Reserved,Software trigger/continuous scan,Low level gated external trigger/continuous scan,High level gated external trigger/continuous scan,Falling edge external trigger/continuous scan,Rising edge external trigger/continuous scan,Falling or rising edge external trigger/continuous scan,Reserved"
TEXTLINE ""

group.word ((0xFFF84000)+0x0060+0*0x02)++0x01
  line.word    0x00 "IDCR0,eQADC Interrupt and eDMA Control Register"
  bitfld.word  0x00 15.              "    NCIE    ,Non-coherency interrupt enable" "0,1"
  bitfld.word  0x00 14.                "  TORIE   ,Trigger overrun interrupt enable" "0,1"
  bitfld.word  0x00 13.                "  PIE     ,Pause interrupt enable" "0,1"
  bitfld.word  0x00 12.                "  EOQIE   ,End-of-queue interrupt enable" "0,1"
  bitfld.word  0x00 11.                "  CFUIE   ,CFIFO underflow interrupt enable" "0,1"
TEXTLINE "                "
  bitfld.word  0x00 09.                "  CFFE    ,CFIFO fill enable" "0,1"
  bitfld.word  0x00 08.                "  CFFS    ,CFIFO fill select" "0,1"
  bitfld.word  0x00 03.                "  RFOIE   ,RFIFO overflow interrupt enable" "0,1"
  bitfld.word  0x00 01.                "  RFDE    ,RFIFO drain enable" "0,1"
  bitfld.word  0x00 00.                "  RFDS    ,RFIFO drain select" "0,1"
TEXTLINE ""


group.long ((0xFFF84000)+0x0070+0*0x04)++0x03
  line.long    0x00 "FISR0,eQADC FIFO and Interrupt Status Register"
  eventfld.long  0x00 31.                "NCF     ,Non-coherency flag" "0,1"
  eventfld.long  0x00 30.              "  TORF    ,Trigger overrun flag" "0,1"
  eventfld.long  0x00 29.              "  PF      ,Pause flag" "0,1"
  eventfld.long  0x00 28.              "  EOQF    ,End-of-queue flag" "0,1"
  eventfld.long  0x00 27.              "  CFUF    ,CFIFO underflow flag" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 26.                "  SSS     ,CFIFO single-scan status bit" "0,1"
  eventfld.long  0x00 25.              "  CFFF    ,CFIFO fill flag" "0,1"
  eventfld.long  0x00 19.              "  RFOF    ,RFIFO overflow flag" "0,1"
  eventfld.long  0x00 17.              "  RFDF    ,RFIFO drain flag" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 12.--15.           "  CFCTR  ,CFIFO entry counter" " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.           "  TNXPTR ,CFIFO transfer next pointer" " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long  0x00 04.--07.           "  RFCTR  ,RFIFO entry counter" " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.           "  POPNXTPTR ,RFIFO pop next pointer" " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
TEXTLINE ""

group.word ((0xFFF84000)+0x0090+0*0x02)++0x01
  line.word    0x00 "CFTCR0,eQADC CFIFO Transfer Counter Register"
TEXTLINE ""

group.long ((0xFFF84000)+0x0100+0*0x40)++0x0f
  line.long    0x00         "CF0R0,CFIFO Data"
  hexmask.long 0x04 0.--31. 1. 0. "CF0R1  ,CFIFO Data"
  hexmask.long 0x08 0.--31. 1. 0. "  CF0R2  ,CFIFO Data"
  hexmask.long 0x0C 0.--31. 1. 0. "  CF0R3  ,CFIFO Data"
TEXTLINE ""

group.long ((0xFFF84000)+0x0300+0*0x40)++0x0f
  line.long    0x00         "RF0R0,RFIFO Data"
  hexmask.long 0x04 0.--31. 1. 0. "RF0R1  ,RFIFO Data"
  hexmask.long 0x08 0.--31. 1. 0. "  RF0R2  ,RFIFO Data"
  hexmask.long 0x0C 0.--31. 1. 0. "  RF0R3  ,RFIFO Data"

tree.end
tree "FIFO 1"

group.long ((0xFFF84000)+0x0010+1*0x04)++0x03
  line.long    0x00 "CFPR1,eQADC CFIFO Push Register"
  hide.long    0x20 "RFPR1,eQADC Result FIFO Pop Register"
  in
TEXTLINE ""

group.word ((0xFFF84000)+0x0050+1*0x02)++0x01
  line.word    0x00 "CFCR1,eQADC Command FIFO Control Register"
  bitfld.word  0x00 10.            "    SSE     ,CFIFO single-scan enable bit" "0,1"
  bitfld.word  0x00 09.              "  CFINV   ,CFIFO invalidate bit" "0,1"
  bitfld.word  0x00 04.--07.         "  MODE    ,CFIFO operation mode" "Disabled,Software trigger/single scan,Low level gated external trigger/single scan,High level gated external trigger/single scan,Falling edge external trigger/single scan,Rising edge external trigger/single scan,Falling or rising edge external trigger/single scan,Reserved,Reserved,Software trigger/continuous scan,Low level gated external trigger/continuous scan,High level gated external trigger/continuous scan,Falling edge external trigger/continuous scan,Rising edge external trigger/continuous scan,Falling or rising edge external trigger/continuous scan,Reserved"
TEXTLINE ""

group.word ((0xFFF84000)+0x0060+1*0x02)++0x01
  line.word    0x00 "IDCR1,eQADC Interrupt and eDMA Control Register"
  bitfld.word  0x00 15.              "    NCIE    ,Non-coherency interrupt enable" "0,1"
  bitfld.word  0x00 14.                "  TORIE   ,Trigger overrun interrupt enable" "0,1"
  bitfld.word  0x00 13.                "  PIE     ,Pause interrupt enable" "0,1"
  bitfld.word  0x00 12.                "  EOQIE   ,End-of-queue interrupt enable" "0,1"
  bitfld.word  0x00 11.                "  CFUIE   ,CFIFO underflow interrupt enable" "0,1"
TEXTLINE "                "
  bitfld.word  0x00 09.                "  CFFE    ,CFIFO fill enable" "0,1"
  bitfld.word  0x00 08.                "  CFFS    ,CFIFO fill select" "0,1"
  bitfld.word  0x00 03.                "  RFOIE   ,RFIFO overflow interrupt enable" "0,1"
  bitfld.word  0x00 01.                "  RFDE    ,RFIFO drain enable" "0,1"
  bitfld.word  0x00 00.                "  RFDS    ,RFIFO drain select" "0,1"
TEXTLINE ""


group.long ((0xFFF84000)+0x0070+1*0x04)++0x03
  line.long    0x00 "FISR1,eQADC FIFO and Interrupt Status Register"
  eventfld.long  0x00 31.                "NCF     ,Non-coherency flag" "0,1"
  eventfld.long  0x00 30.              "  TORF    ,Trigger overrun flag" "0,1"
  eventfld.long  0x00 29.              "  PF      ,Pause flag" "0,1"
  eventfld.long  0x00 28.              "  EOQF    ,End-of-queue flag" "0,1"
  eventfld.long  0x00 27.              "  CFUF    ,CFIFO underflow flag" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 26.                "  SSS     ,CFIFO single-scan status bit" "0,1"
  eventfld.long  0x00 25.              "  CFFF    ,CFIFO fill flag" "0,1"
  eventfld.long  0x00 19.              "  RFOF    ,RFIFO overflow flag" "0,1"
  eventfld.long  0x00 17.              "  RFDF    ,RFIFO drain flag" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 12.--15.           "  CFCTR  ,CFIFO entry counter" " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.           "  TNXPTR ,CFIFO transfer next pointer" " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long  0x00 04.--07.           "  RFCTR  ,RFIFO entry counter" " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.           "  POPNXTPTR ,RFIFO pop next pointer" " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
TEXTLINE ""

group.word ((0xFFF84000)+0x0090+1*0x02)++0x01
  line.word    0x00 "CFTCR1,eQADC CFIFO Transfer Counter Register"
TEXTLINE ""

group.long ((0xFFF84000)+0x0100+1*0x40)++0x0f
  line.long    0x00         "CF1R0,CFIFO Data"
  hexmask.long 0x04 0.--31. 1. 0. "CF1R1  ,CFIFO Data"
  hexmask.long 0x08 0.--31. 1. 0. "  CF1R2  ,CFIFO Data"
  hexmask.long 0x0C 0.--31. 1. 0. "  CF1R3  ,CFIFO Data"
TEXTLINE ""

group.long ((0xFFF84000)+0x0300+1*0x40)++0x0f
  line.long    0x00         "RF1R0,RFIFO Data"
  hexmask.long 0x04 0.--31. 1. 0. "RF1R1  ,RFIFO Data"
  hexmask.long 0x08 0.--31. 1. 0. "  RF1R2  ,RFIFO Data"
  hexmask.long 0x0C 0.--31. 1. 0. "  RF1R3  ,RFIFO Data"

tree.end
tree "FIFO 2"

group.long ((0xFFF84000)+0x0010+2*0x04)++0x03
  line.long    0x00 "CFPR2,eQADC CFIFO Push Register"
  hide.long    0x20 "RFPR2,eQADC Result FIFO Pop Register"
  in
TEXTLINE ""

group.word ((0xFFF84000)+0x0050+2*0x02)++0x01
  line.word    0x00 "CFCR2,eQADC Command FIFO Control Register"
  bitfld.word  0x00 10.            "    SSE     ,CFIFO single-scan enable bit" "0,1"
  bitfld.word  0x00 09.              "  CFINV   ,CFIFO invalidate bit" "0,1"
  bitfld.word  0x00 04.--07.         "  MODE    ,CFIFO operation mode" "Disabled,Software trigger/single scan,Low level gated external trigger/single scan,High level gated external trigger/single scan,Falling edge external trigger/single scan,Rising edge external trigger/single scan,Falling or rising edge external trigger/single scan,Reserved,Reserved,Software trigger/continuous scan,Low level gated external trigger/continuous scan,High level gated external trigger/continuous scan,Falling edge external trigger/continuous scan,Rising edge external trigger/continuous scan,Falling or rising edge external trigger/continuous scan,Reserved"
TEXTLINE ""

group.word ((0xFFF84000)+0x0060+2*0x02)++0x01
  line.word    0x00 "IDCR2,eQADC Interrupt and eDMA Control Register"
  bitfld.word  0x00 15.              "    NCIE    ,Non-coherency interrupt enable" "0,1"
  bitfld.word  0x00 14.                "  TORIE   ,Trigger overrun interrupt enable" "0,1"
  bitfld.word  0x00 13.                "  PIE     ,Pause interrupt enable" "0,1"
  bitfld.word  0x00 12.                "  EOQIE   ,End-of-queue interrupt enable" "0,1"
  bitfld.word  0x00 11.                "  CFUIE   ,CFIFO underflow interrupt enable" "0,1"
TEXTLINE "                "
  bitfld.word  0x00 09.                "  CFFE    ,CFIFO fill enable" "0,1"
  bitfld.word  0x00 08.                "  CFFS    ,CFIFO fill select" "0,1"
  bitfld.word  0x00 03.                "  RFOIE   ,RFIFO overflow interrupt enable" "0,1"
  bitfld.word  0x00 01.                "  RFDE    ,RFIFO drain enable" "0,1"
  bitfld.word  0x00 00.                "  RFDS    ,RFIFO drain select" "0,1"
TEXTLINE ""


group.long ((0xFFF84000)+0x0070+2*0x04)++0x03
  line.long    0x00 "FISR2,eQADC FIFO and Interrupt Status Register"
  eventfld.long  0x00 31.                "NCF     ,Non-coherency flag" "0,1"
  eventfld.long  0x00 30.              "  TORF    ,Trigger overrun flag" "0,1"
  eventfld.long  0x00 29.              "  PF      ,Pause flag" "0,1"
  eventfld.long  0x00 28.              "  EOQF    ,End-of-queue flag" "0,1"
  eventfld.long  0x00 27.              "  CFUF    ,CFIFO underflow flag" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 26.                "  SSS     ,CFIFO single-scan status bit" "0,1"
  eventfld.long  0x00 25.              "  CFFF    ,CFIFO fill flag" "0,1"
  eventfld.long  0x00 19.              "  RFOF    ,RFIFO overflow flag" "0,1"
  eventfld.long  0x00 17.              "  RFDF    ,RFIFO drain flag" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 12.--15.           "  CFCTR  ,CFIFO entry counter" " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.           "  TNXPTR ,CFIFO transfer next pointer" " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long  0x00 04.--07.           "  RFCTR  ,RFIFO entry counter" " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.           "  POPNXTPTR ,RFIFO pop next pointer" " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
TEXTLINE ""

group.word ((0xFFF84000)+0x0090+2*0x02)++0x01
  line.word    0x00 "CFTCR2,eQADC CFIFO Transfer Counter Register"
TEXTLINE ""

group.long ((0xFFF84000)+0x0100+2*0x40)++0x0f
  line.long    0x00         "CF2R0,CFIFO Data"
  hexmask.long 0x04 0.--31. 1. 0. "CF2R1  ,CFIFO Data"
  hexmask.long 0x08 0.--31. 1. 0. "  CF2R2  ,CFIFO Data"
  hexmask.long 0x0C 0.--31. 1. 0. "  CF2R3  ,CFIFO Data"
TEXTLINE ""

group.long ((0xFFF84000)+0x0300+2*0x40)++0x0f
  line.long    0x00         "RF2R0,RFIFO Data"
  hexmask.long 0x04 0.--31. 1. 0. "RF2R1  ,RFIFO Data"
  hexmask.long 0x08 0.--31. 1. 0. "  RF2R2  ,RFIFO Data"
  hexmask.long 0x0C 0.--31. 1. 0. "  RF2R3  ,RFIFO Data"

tree.end
tree "FIFO 3"

group.long ((0xFFF84000)+0x0010+3*0x04)++0x03
  line.long    0x00 "CFPR3,eQADC CFIFO Push Register"
  hide.long    0x20 "RFPR3,eQADC Result FIFO Pop Register"
  in
TEXTLINE ""

group.word ((0xFFF84000)+0x0050+3*0x02)++0x01
  line.word    0x00 "CFCR3,eQADC Command FIFO Control Register"
  bitfld.word  0x00 10.            "    SSE     ,CFIFO single-scan enable bit" "0,1"
  bitfld.word  0x00 09.              "  CFINV   ,CFIFO invalidate bit" "0,1"
  bitfld.word  0x00 04.--07.         "  MODE    ,CFIFO operation mode" "Disabled,Software trigger/single scan,Low level gated external trigger/single scan,High level gated external trigger/single scan,Falling edge external trigger/single scan,Rising edge external trigger/single scan,Falling or rising edge external trigger/single scan,Reserved,Reserved,Software trigger/continuous scan,Low level gated external trigger/continuous scan,High level gated external trigger/continuous scan,Falling edge external trigger/continuous scan,Rising edge external trigger/continuous scan,Falling or rising edge external trigger/continuous scan,Reserved"
TEXTLINE ""

group.word ((0xFFF84000)+0x0060+3*0x02)++0x01
  line.word    0x00 "IDCR3,eQADC Interrupt and eDMA Control Register"
  bitfld.word  0x00 15.              "    NCIE    ,Non-coherency interrupt enable" "0,1"
  bitfld.word  0x00 14.                "  TORIE   ,Trigger overrun interrupt enable" "0,1"
  bitfld.word  0x00 13.                "  PIE     ,Pause interrupt enable" "0,1"
  bitfld.word  0x00 12.                "  EOQIE   ,End-of-queue interrupt enable" "0,1"
  bitfld.word  0x00 11.                "  CFUIE   ,CFIFO underflow interrupt enable" "0,1"
TEXTLINE "                "
  bitfld.word  0x00 09.                "  CFFE    ,CFIFO fill enable" "0,1"
  bitfld.word  0x00 08.                "  CFFS    ,CFIFO fill select" "0,1"
  bitfld.word  0x00 03.                "  RFOIE   ,RFIFO overflow interrupt enable" "0,1"
  bitfld.word  0x00 01.                "  RFDE    ,RFIFO drain enable" "0,1"
  bitfld.word  0x00 00.                "  RFDS    ,RFIFO drain select" "0,1"
TEXTLINE ""


group.long ((0xFFF84000)+0x0070+3*0x04)++0x03
  line.long    0x00 "FISR3,eQADC FIFO and Interrupt Status Register"
  eventfld.long  0x00 31.                "NCF     ,Non-coherency flag" "0,1"
  eventfld.long  0x00 30.              "  TORF    ,Trigger overrun flag" "0,1"
  eventfld.long  0x00 29.              "  PF      ,Pause flag" "0,1"
  eventfld.long  0x00 28.              "  EOQF    ,End-of-queue flag" "0,1"
  eventfld.long  0x00 27.              "  CFUF    ,CFIFO underflow flag" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 26.                "  SSS     ,CFIFO single-scan status bit" "0,1"
  eventfld.long  0x00 25.              "  CFFF    ,CFIFO fill flag" "0,1"
  eventfld.long  0x00 19.              "  RFOF    ,RFIFO overflow flag" "0,1"
  eventfld.long  0x00 17.              "  RFDF    ,RFIFO drain flag" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 12.--15.           "  CFCTR  ,CFIFO entry counter" " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.           "  TNXPTR ,CFIFO transfer next pointer" " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long  0x00 04.--07.           "  RFCTR  ,RFIFO entry counter" " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.           "  POPNXTPTR ,RFIFO pop next pointer" " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
TEXTLINE ""

group.word ((0xFFF84000)+0x0090+3*0x02)++0x01
  line.word    0x00 "CFTCR3,eQADC CFIFO Transfer Counter Register"
TEXTLINE ""

group.long ((0xFFF84000)+0x0100+3*0x40)++0x0f
  line.long    0x00         "CF3R0,CFIFO Data"
  hexmask.long 0x04 0.--31. 1. 0. "CF3R1  ,CFIFO Data"
  hexmask.long 0x08 0.--31. 1. 0. "  CF3R2  ,CFIFO Data"
  hexmask.long 0x0C 0.--31. 1. 0. "  CF3R3  ,CFIFO Data"
TEXTLINE ""

group.long ((0xFFF84000)+0x0300+3*0x40)++0x0f
  line.long    0x00         "RF3R0,RFIFO Data"
  hexmask.long 0x04 0.--31. 1. 0. "RF3R1  ,RFIFO Data"
  hexmask.long 0x08 0.--31. 1. 0. "  RF3R2  ,RFIFO Data"
  hexmask.long 0x0C 0.--31. 1. 0. "  RF3R3  ,RFIFO Data"

tree.end
tree "FIFO 4"

group.long ((0xFFF84000)+0x0010+4*0x04)++0x03
  line.long    0x00 "CFPR4,eQADC CFIFO Push Register"
  hide.long    0x20 "RFPR4,eQADC Result FIFO Pop Register"
  in
TEXTLINE ""

group.word ((0xFFF84000)+0x0050+4*0x02)++0x01
  line.word    0x00 "CFCR4,eQADC Command FIFO Control Register"
  bitfld.word  0x00 10.            "    SSE     ,CFIFO single-scan enable bit" "0,1"
  bitfld.word  0x00 09.              "  CFINV   ,CFIFO invalidate bit" "0,1"
  bitfld.word  0x00 04.--07.         "  MODE    ,CFIFO operation mode" "Disabled,Software trigger/single scan,Low level gated external trigger/single scan,High level gated external trigger/single scan,Falling edge external trigger/single scan,Rising edge external trigger/single scan,Falling or rising edge external trigger/single scan,Reserved,Reserved,Software trigger/continuous scan,Low level gated external trigger/continuous scan,High level gated external trigger/continuous scan,Falling edge external trigger/continuous scan,Rising edge external trigger/continuous scan,Falling or rising edge external trigger/continuous scan,Reserved"
TEXTLINE ""

group.word ((0xFFF84000)+0x0060+4*0x02)++0x01
  line.word    0x00 "IDCR4,eQADC Interrupt and eDMA Control Register"
  bitfld.word  0x00 15.              "    NCIE    ,Non-coherency interrupt enable" "0,1"
  bitfld.word  0x00 14.                "  TORIE   ,Trigger overrun interrupt enable" "0,1"
  bitfld.word  0x00 13.                "  PIE     ,Pause interrupt enable" "0,1"
  bitfld.word  0x00 12.                "  EOQIE   ,End-of-queue interrupt enable" "0,1"
  bitfld.word  0x00 11.                "  CFUIE   ,CFIFO underflow interrupt enable" "0,1"
TEXTLINE "                "
  bitfld.word  0x00 09.                "  CFFE    ,CFIFO fill enable" "0,1"
  bitfld.word  0x00 08.                "  CFFS    ,CFIFO fill select" "0,1"
  bitfld.word  0x00 03.                "  RFOIE   ,RFIFO overflow interrupt enable" "0,1"
  bitfld.word  0x00 01.                "  RFDE    ,RFIFO drain enable" "0,1"
  bitfld.word  0x00 00.                "  RFDS    ,RFIFO drain select" "0,1"
TEXTLINE ""


group.long ((0xFFF84000)+0x0070+4*0x04)++0x03
  line.long    0x00 "FISR4,eQADC FIFO and Interrupt Status Register"
  eventfld.long  0x00 31.                "NCF     ,Non-coherency flag" "0,1"
  eventfld.long  0x00 30.              "  TORF    ,Trigger overrun flag" "0,1"
  eventfld.long  0x00 29.              "  PF      ,Pause flag" "0,1"
  eventfld.long  0x00 28.              "  EOQF    ,End-of-queue flag" "0,1"
  eventfld.long  0x00 27.              "  CFUF    ,CFIFO underflow flag" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 26.                "  SSS     ,CFIFO single-scan status bit" "0,1"
  eventfld.long  0x00 25.              "  CFFF    ,CFIFO fill flag" "0,1"
  eventfld.long  0x00 19.              "  RFOF    ,RFIFO overflow flag" "0,1"
  eventfld.long  0x00 17.              "  RFDF    ,RFIFO drain flag" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 12.--15.           "  CFCTR  ,CFIFO entry counter" " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.           "  TNXPTR ,CFIFO transfer next pointer" " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long  0x00 04.--07.           "  RFCTR  ,RFIFO entry counter" " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.           "  POPNXTPTR ,RFIFO pop next pointer" " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
TEXTLINE ""

group.word ((0xFFF84000)+0x0090+4*0x02)++0x01
  line.word    0x00 "CFTCR4,eQADC CFIFO Transfer Counter Register"
TEXTLINE ""

group.long ((0xFFF84000)+0x0100+4*0x40)++0x0f
  line.long    0x00         "CF4R0,CFIFO Data"
  hexmask.long 0x04 0.--31. 1. 0. "CF4R1  ,CFIFO Data"
  hexmask.long 0x08 0.--31. 1. 0. "  CF4R2  ,CFIFO Data"
  hexmask.long 0x0C 0.--31. 1. 0. "  CF4R3  ,CFIFO Data"
TEXTLINE ""

group.long ((0xFFF84000)+0x0300+4*0x40)++0x0f
  line.long    0x00         "RF4R0,RFIFO Data"
  hexmask.long 0x04 0.--31. 1. 0. "RF4R1  ,RFIFO Data"
  hexmask.long 0x08 0.--31. 1. 0. "  RF4R2  ,RFIFO Data"
  hexmask.long 0x0C 0.--31. 1. 0. "  RF4R3  ,RFIFO Data"

tree.end
tree "FIFO 5"

group.long ((0xFFF84000)+0x0010+5*0x04)++0x03
  line.long    0x00 "CFPR5,eQADC CFIFO Push Register"
  hide.long    0x20 "RFPR5,eQADC Result FIFO Pop Register"
  in
TEXTLINE ""

group.word ((0xFFF84000)+0x0050+5*0x02)++0x01
  line.word    0x00 "CFCR5,eQADC Command FIFO Control Register"
  bitfld.word  0x00 10.            "    SSE     ,CFIFO single-scan enable bit" "0,1"
  bitfld.word  0x00 09.              "  CFINV   ,CFIFO invalidate bit" "0,1"
  bitfld.word  0x00 04.--07.         "  MODE    ,CFIFO operation mode" "Disabled,Software trigger/single scan,Low level gated external trigger/single scan,High level gated external trigger/single scan,Falling edge external trigger/single scan,Rising edge external trigger/single scan,Falling or rising edge external trigger/single scan,Reserved,Reserved,Software trigger/continuous scan,Low level gated external trigger/continuous scan,High level gated external trigger/continuous scan,Falling edge external trigger/continuous scan,Rising edge external trigger/continuous scan,Falling or rising edge external trigger/continuous scan,Reserved"
TEXTLINE ""

group.word ((0xFFF84000)+0x0060+5*0x02)++0x01
  line.word    0x00 "IDCR5,eQADC Interrupt and eDMA Control Register"
  bitfld.word  0x00 15.              "    NCIE    ,Non-coherency interrupt enable" "0,1"
  bitfld.word  0x00 14.                "  TORIE   ,Trigger overrun interrupt enable" "0,1"
  bitfld.word  0x00 13.                "  PIE     ,Pause interrupt enable" "0,1"
  bitfld.word  0x00 12.                "  EOQIE   ,End-of-queue interrupt enable" "0,1"
  bitfld.word  0x00 11.                "  CFUIE   ,CFIFO underflow interrupt enable" "0,1"
TEXTLINE "                "
  bitfld.word  0x00 09.                "  CFFE    ,CFIFO fill enable" "0,1"
  bitfld.word  0x00 08.                "  CFFS    ,CFIFO fill select" "0,1"
  bitfld.word  0x00 03.                "  RFOIE   ,RFIFO overflow interrupt enable" "0,1"
  bitfld.word  0x00 01.                "  RFDE    ,RFIFO drain enable" "0,1"
  bitfld.word  0x00 00.                "  RFDS    ,RFIFO drain select" "0,1"
TEXTLINE ""


group.long ((0xFFF84000)+0x0070+5*0x04)++0x03
  line.long    0x00 "FISR5,eQADC FIFO and Interrupt Status Register"
  eventfld.long  0x00 31.                "NCF     ,Non-coherency flag" "0,1"
  eventfld.long  0x00 30.              "  TORF    ,Trigger overrun flag" "0,1"
  eventfld.long  0x00 29.              "  PF      ,Pause flag" "0,1"
  eventfld.long  0x00 28.              "  EOQF    ,End-of-queue flag" "0,1"
  eventfld.long  0x00 27.              "  CFUF    ,CFIFO underflow flag" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 26.                "  SSS     ,CFIFO single-scan status bit" "0,1"
  eventfld.long  0x00 25.              "  CFFF    ,CFIFO fill flag" "0,1"
  eventfld.long  0x00 19.              "  RFOF    ,RFIFO overflow flag" "0,1"
  eventfld.long  0x00 17.              "  RFDF    ,RFIFO drain flag" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 12.--15.           "  CFCTR  ,CFIFO entry counter" " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.           "  TNXPTR ,CFIFO transfer next pointer" " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long  0x00 04.--07.           "  RFCTR  ,RFIFO entry counter" " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.           "  POPNXTPTR ,RFIFO pop next pointer" " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
TEXTLINE ""

group.word ((0xFFF84000)+0x0090+5*0x02)++0x01
  line.word    0x00 "CFTCR5,eQADC CFIFO Transfer Counter Register"
TEXTLINE ""

group.long ((0xFFF84000)+0x0100+5*0x40)++0x0f
  line.long    0x00         "CF5R0,CFIFO Data"
  hexmask.long 0x04 0.--31. 1. 0. "CF5R1  ,CFIFO Data"
  hexmask.long 0x08 0.--31. 1. 0. "  CF5R2  ,CFIFO Data"
  hexmask.long 0x0C 0.--31. 1. 0. "  CF5R3  ,CFIFO Data"
TEXTLINE ""

group.long ((0xFFF84000)+0x0300+5*0x40)++0x0f
  line.long    0x00         "RF5R0,RFIFO Data"
  hexmask.long 0x04 0.--31. 1. 0. "RF5R1  ,RFIFO Data"
  hexmask.long 0x08 0.--31. 1. 0. "  RF5R2  ,RFIFO Data"
  hexmask.long 0x0C 0.--31. 1. 0. "  RF5R3  ,RFIFO Data"

tree.end

TEXTLINE ""

tree "CFIFO Status Registers"

group.long (0xFFF84000+0x000000A0)++0x03
  line.long    0x00 "CFSSR0,eQADC CFIFO Status Snapshot Register 0"
  bitfld.long  0x00 30.--31.           "CFS0_T0    ,CFIFO status at transfer to ADC0 command buffer" "IDLE,RES.,WAIT,TRIG"
  bitfld.long  0x00 28.--29.         "  CFS1_T0    ,CFIFO status at transfer to ADC0 command buffer" "IDLE,RES.,WAIT,TRIG"
  bitfld.long  0x00 26.--27.         "  CFS2_T0    ,CFIFO status at transfer to ADC0 command buffer" "IDLE,RES.,WAIT,TRIG"
  bitfld.long  0x00 24.--25.         "  CFS3_T0    ,CFIFO status at transfer to ADC0 command buffer" "IDLE,RES.,WAIT,TRIG"
TEXTLINE "                "
  bitfld.long  0x00 22.--23.         "  CFS4_T0    ,CFIFO status at transfer to ADC0 command buffer" "IDLE,RES.,WAIT,TRIG"
  bitfld.long  0x00 20.--21.         "  CFS5_T0    ,CFIFO status at transfer to ADC0 command buffer" "IDLE,RES.,WAIT,TRIG"
TEXTLINE "                "
  bitfld.long  0x00 11.--14.         "  LCFT0      ,Last CFIFO to transfer to ADC0 command buffer" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--10. 1. "    TC_LCFT0   ,Transfer counter for last CFIFO to transfer commands to ADC0 command buffer"
TEXTLINE ""

group.long (0xFFF84000+0x000000A4)++0x03
  line.long    0x00 "CFSSR1,eQADC CFIFO Status Snapshot Register 1"
  bitfld.long  0x00 30.--31.           "CFS0_T1    ,CFIFO status at transfer to ADC1 command buffer" "IDLE,RES.,WAIT,TRIG"
  bitfld.long  0x00 28.--29.         "  CFS1_T1    ,CFIFO status at transfer to ADC1 command buffer" "IDLE,RES.,WAIT,TRIG"
  bitfld.long  0x00 26.--27.         "  CFS2_T1    ,CFIFO status at transfer to ADC1 command buffer" "IDLE,RES.,WAIT,TRIG"
  bitfld.long  0x00 24.--25.         "  CFS3_T1    ,CFIFO status at transfer to ADC1 command buffer" "IDLE,RES.,WAIT,TRIG"
TEXTLINE "                "
  bitfld.long  0x00 22.--23.         "  CFS4_T1    ,CFIFO status at transfer to ADC1 command buffer" "IDLE,RES.,WAIT,TRIG"
  bitfld.long  0x00 20.--21.         "  CFS5_T1    ,CFIFO status at transfer to ADC1 command buffer" "IDLE,RES.,WAIT,TRIG"
TEXTLINE "                "
  bitfld.long  0x00 11.--14.         "  LCFT1      ,Last CFIFO to transfer to ADC1 command buffer" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.long.word 0x00 00.--10. 1. "    TC_LCFT1   ,Transfer counter for last CFIFO to transfer commands to ADC1 command buffer"
TEXTLINE ""

group.long (0xFFF84000+0x000000A8)++0x03
  line.long    0x00 "CFSSR2,eQADC CFIFO Status Snapshot Register 2"
  bitfld.long  0x00 30.--31.           "CFS0_TSSI  ,CFIFO Status at Transfer through the eQADC SSI" "IDLE,RES.,WAIT,TRIG"
  bitfld.long  0x00 28.--29.         "  CFS1_TSSI  ,CFIFO Status at Transfer through the eQADC SSI" "IDLE,RES.,WAIT,TRIG"
  bitfld.long  0x00 26.--27.         "  CFS2_TSSI  ,CFIFO Status at Transfer through the eQADC SSI" "IDLE,RES.,WAIT,TRIG"
  bitfld.long  0x00 24.--25.         "  CFS3_TSSI  ,CFIFO Status at Transfer through the eQADC SSI" "IDLE,RES.,WAIT,TRIG"
TEXTLINE "                "
  bitfld.long  0x00 22.--23.         "  CFS4_TSSI  ,CFIFO Status at Transfer through the eQADC SSI" "IDLE,RES.,WAIT,TRIG"
  bitfld.long  0x00 20.--21.         "  CFS5_TSSI  ,CFIFO Status at Transfer through the eQADC SSI" "IDLE,RES.,WAIT,TRIG"
TEXTLINE "                "
  bitfld.long  0x00 15.              "  ENI        ,External Command Buffer Number Indicator" "0,1"
TEXTLINE "                "
  bitfld.long  0x00 11.--14.         "  LCFTSSI    ,Last CFIFO to transfer commands through the eQADC SSI" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
  hexmask.word 0x02 00.--10. 1.      "    TC_LCFTSSI ,Transfer counter for last CFIFO to transfer commands through eQADC SSI"
TEXTLINE ""

group.long (0xFFF84000+0x000000AC)++0x03
  line.long    0x00 "CFSR,eQADC CFIFO Status Register"
  bitfld.long  0x00 30.--31.           "CFS0       ,CFIFO status" "IDLE,RES.,WAIT,TRIG"
  bitfld.long  0x00 28.--29.         "  CFS1       ,CFIFO status" "IDLE,RES.,WAIT,TRIG"
  bitfld.long  0x00 26.--27.         "  CFS2       ,CFIFO status" "IDLE,RES.,WAIT,TRIG"
  bitfld.long  0x00 24.--25.         "  CFS3       ,CFIFO status" "IDLE,RES.,WAIT,TRIG"
TEXTLINE "                "
  bitfld.long  0x00 22.--23.         "  CFS4       ,CFIFO status" "IDLE,RES.,WAIT,TRIG"
  bitfld.long  0x00 20.--21.         "  CFS5       ,CFIFO status" "IDLE,RES.,WAIT,TRIG"

tree.end

tree "Serial Interface Registers"

group.long (0xFFF84000+0x000000B4)++0x03
  line.long    0x00 "SSICR,eQADC Synchronous Serial Interface Control Register"
  bitfld.long  0x00 08.--10.           "MDT ,Minimum Delay After Transmission" "1 FCK,2 FCK,3 FCK,4 FCK,5 FCK,6 FCK,7 FCK,8 FCK"
  bitfld.long  0x00 00.--03.         "  BR     ,Baud rate" "1/2,1/3,1/4,1/5,1/6,1/7,1/8,1/9,1/10,1/11,1/12,1/13,1/14,1/15,1/16,1/17"

group.long (0xFFF84000+0x000000B8)++0x03
  line.long    0x00 "SSIRDR,eQADC Synchronous Serial Interface Receive Data Register"
  bitfld.long  0x00 31.           "RDV ,Receive data valid" "0,1"
  hexmask.long 0x00 00.--25. 1. "      R_DATA ,eQADC receive DATA"

tree.end

tree.end

 tree.end
endif

sif (cpu()=="MPC5633M")||(cpu()=="MPC5634M")||(cpu()=="SPC563M60")||(cpu()=="SPC563M64")||(CPUIS("MPC5674*"))
tree "Decimation filter (DF)"

group.long 0xFFF88000++0x03
  line.long    0 "CR,Configuration Register"

group.long 0xFFF88004++0x03
  line.long    0 "SR,Status Register"

group.long 0xFFF88010++0x03
  line.long    0 "IIB,Interface Input Buffer"

group.long 0xFFF88014++0x03
  line.long    0 "IOB,Interface Output Buffer"

TEXTLINE ""

group.long 0xFFF88020++0x03
  line.long    0 "FC0,Filter Coefficient 0"

group.long 0xFFF88024++0x03
  line.long    0 "FC1,Filter Coefficient 1"

group.long 0xFFF88028++0x03
  line.long    0 "FC2,Filter Coefficient 2"

group.long 0xFFF8802C++0x03
  line.long    0 "FC3,Filter Coefficient 3"

group.long 0xFFF88030++0x034
  line.long    0 "FC4,Filter Coefficient 4"

group.long 0xFFF88034++0x03
  line.long    0 "FC5,Filter Coefficient 5"

group.long 0xFFF88038++0x03
  line.long    0 "FC6,Filter Coefficient 6"

group.long 0xFFF8803C++0x03
  line.long    0 "FC7,Filter Coefficient 7"

group.long 0xFFF88040++0x03
  line.long    0 "FC8,Filter Coefficient 8"

group.long 0xFFF88044++0x03
  line.long    0 "FC9,Filter Coefficient 9"

TEXTLINE ""

group.long 0xFFF88078++0x03
  line.long    0 "FT0,Filter TAP Register 0"

group.long 0xFFF8807C++0x03
  line.long    0 "FT1,Filter TAP Register 1"

group.long 0xFFF88080++0x03
  line.long    0 "FT2,Filter TAP Register 2"

group.long 0xFFF88084++0x03
  line.long    0 "FT3,Filter TAP Register 3"

group.long 0xFFF88088++0x03
  line.long    0 "FT4,Filter TAP Register 4"

group.long 0xFFF8808C++0x03
  line.long    0 "FT5,Filter TAP Register 5"

group.long 0xFFF88090++0x03
  line.long    0 "FT6,Filter TAP Register 6"

group.long 0xFFF88094++0x03
  line.long    0 "FT7,Filter TAP Register 7"

tree.end
endif


tree "Deserial Serial Peripheral Interface (DSPI)"
  sif (cpu()=="MPC5554")||(cpu()=="MPC5566")||(CPUIS("MPC5674*"))
tree "DSPI A"

group.long 0xFFF90000++0x03
  line.long    0x00 "MCR,Module Configuration Register"
  bitfld.long  0x00 31.                "MSTR      ,Master/slave mode select" "S,M"
  bitfld.long  0x00 30.              "  CONT_SCKE ,Continuous SCK enable" "0,1"
  bitfld.long  0x00 28.--29.         "  DCONF   ,DSPI configuration" "SPI,DSI,CSI,res"
  bitfld.long  0x00 27.              "  FRZ       ,Freeze" "0,1"
  TEXTLINE "                "
  bitfld.long  0x00 26.              "  MTFE      ,Modified timing format enable" "0,1"
  bitfld.long  0x00 25.              "  PCSSE     ,Peripheral chip select strobe enable" "0,1"
  bitfld.long  0x00 24.              "  ROOE      ,Receive FIFO overflow overwrite enable" "0,1"
  bitfld.long  0x00 23.              "  PCSIS7-0  ,Peripheral chip select 7 inactive state" "L,H"
  bitfld.long  0x00 22.              ",Peripheral chip select 6 inactive state" "L,H"
  bitfld.long  0x00 21.              ",Peripheral chip select 5 inactive state" "L,H"
  bitfld.long  0x00 20.              ",Peripheral chip select 4 inactive state" "L,H"
  bitfld.long  0x00 19.              " ,Peripheral chip select 3 inactive state" "L,H"
  bitfld.long  0x00 18.              ",Peripheral chip select 2 inactive state" "L,H"
  bitfld.long  0x00 17.              ",Peripheral chip select 1 inactive state" "L,H"
  bitfld.long  0x00 16.              ",Peripheral chip select 0 inactive state" "L,H"
  TEXTLINE "                "
  bitfld.long  0x00 15.              "  DOZE      ,Doze enable" "0,1"
  bitfld.long  0x00 14.              "  MDIS      ,Module disable" "0,1"
  TEXTLINE "                "
  bitfld.long  0x00 13.              "  DIS_TXF   ,Disable transmit FIFO" "0,1"
  bitfld.long  0x00 12.              "  DIS_RXF   ,Disable receive FIFO" "0,1"
  bitfld.long  0x00 11.              "  CLR_TXF   ,Clear TX FIFO" "0,1"
  bitfld.long  0x00 10.              "  CLR_RXF   ,Clear RX FIFO." "0,1"
  TEXTLINE "                "
  bitfld.long  0x00 08.--09.         "  SMPL_PT ,Sample point" "  0,  1,  2,res"
  bitfld.long  0x00 00.              "  HALT      ,Halt" "0,1"
TEXTLINE ""

group.long (0xFFF90000+0x08)++0x03
  line.long    0x00 "TCR,Transfer Count Register"
  hexmask.word 0x00 00.--15. 1. "TCNT , SPI transfer counter"
TEXTLINE ""

group.long (0xFFF90000+0x0C)++0x03
  line.long    0x00 "CTAR0,Clock and Transfer Attributes Register"
  bitfld.long  0x00 31.                "DBR        ,Double baud rate" "0,1"
  bitfld.long  0x00 27.--30.         "  FMSZ     ,Framesize" "res,res,res,  4 bits,  5 bits,  6 bits,  7 bits,  8 bits,  9 bits, 10 bits, 11 bits, 12 bits, 13 bits, 14 bits, 15 bits, 16 bits"
  TEXTLINE "                "
  bitfld.long  0x00 26.              "  CPOL    ,Clock polarity" " low,high"
  bitfld.long  0x00 25.              "  CPHA       ,Clock phase" "0,1"
  bitfld.long  0x00 24.              "  LSBFE      ,LSB first enable" "0,1"
  TEXTLINE "                "
  bitfld.long  0x00 22.--23.         "  PCSSCK    ,PCS to SCK delay prescaler" "1x,3x,5x,7x"
  bitfld.long  0x00 20.--21.         "  PASC      ,After SCK delay prescaler" "1x,3x,5x,7x"
  bitfld.long  0x00 18.--19.         "  PDT       ,Delay after transfer prescaler" "1x,3x,5x,7x"
  bitfld.long  0x00 16.--17.         "  PBR       ,Baud rate prescaler" "2x,3x,5x,7x"
  TEXTLINE "                "
  bitfld.long  0x00 12.--15.         "  CSSCK ,PCS to SCK delay scaler"     "    2x,    4x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x,65536x"
  bitfld.long  0x00 08.--11.         "  ASC   ,After SCK delay scaler"      "    2x,    4x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x,65536x"
  bitfld.long  0x00 04.--07.         "  DT    ,Delay after transfer scaler" "    2x,    4x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x,65536x"
  bitfld.long  0x00 00.--03.         "  BR    ,Baud rate scaler"            "    2x,    4x,    6x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x"
TEXTLINE ""

group.long (0xFFF90000+0x10)++0x03
  line.long    0x00 "CTAR1,Clock and Transfer Attributes Register"
  bitfld.long  0x00 31.                "DBR        ,Double baud rate" "0,1"
  bitfld.long  0x00 27.--30.         "  FMSZ     ,Framesize" "res,res,res,  4 bits,  5 bits,  6 bits,  7 bits,  8 bits,  9 bits, 10 bits, 11 bits, 12 bits, 13 bits, 14 bits, 15 bits, 16 bits"
  TEXTLINE "                "
  bitfld.long  0x00 26.              "  CPOL    ,Clock polarity" " low,high"
  bitfld.long  0x00 25.              "  CPHA       ,Clock phase" "0,1"
  bitfld.long  0x00 24.              "  LSBFE      ,LSB first enable" "0,1"
  TEXTLINE "                "
  bitfld.long  0x00 22.--23.         "  PCSSCK    ,PCS to SCK delay prescaler" "1x,3x,5x,7x"
  bitfld.long  0x00 20.--21.         "  PASC      ,After SCK delay prescaler" "1x,3x,5x,7x"
  bitfld.long  0x00 18.--19.         "  PDT       ,Delay after transfer prescaler" "1x,3x,5x,7x"
  bitfld.long  0x00 16.--17.         "  PBR       ,Baud rate prescaler" "2x,3x,5x,7x"
  TEXTLINE "                "
  bitfld.long  0x00 12.--15.         "  CSSCK ,PCS to SCK delay scaler"     "    2x,    4x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x,65536x"
  bitfld.long  0x00 08.--11.         "  ASC   ,After SCK delay scaler"      "    2x,    4x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x,65536x"
  bitfld.long  0x00 04.--07.         "  DT    ,Delay after transfer scaler" "    2x,    4x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x,65536x"
  bitfld.long  0x00 00.--03.         "  BR    ,Baud rate scaler"            "    2x,    4x,    6x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x"
TEXTLINE ""

group.long (0xFFF90000+0x14)++0x03
  line.long    0x00 "CTAR2,Clock and Transfer Attributes Register"
  bitfld.long  0x00 31.                "DBR        ,Double baud rate" "0,1"
  bitfld.long  0x00 27.--30.         "  FMSZ     ,Framesize" "res,res,res,  4 bits,  5 bits,  6 bits,  7 bits,  8 bits,  9 bits, 10 bits, 11 bits, 12 bits, 13 bits, 14 bits, 15 bits, 16 bits"
  TEXTLINE "                "
  bitfld.long  0x00 26.              "  CPOL    ,Clock polarity" " low,high"
  bitfld.long  0x00 25.              "  CPHA       ,Clock phase" "0,1"
  bitfld.long  0x00 24.              "  LSBFE      ,LSB first enable" "0,1"
  TEXTLINE "                "
  bitfld.long  0x00 22.--23.         "  PCSSCK    ,PCS to SCK delay prescaler" "1x,3x,5x,7x"
  bitfld.long  0x00 20.--21.         "  PASC      ,After SCK delay prescaler" "1x,3x,5x,7x"
  bitfld.long  0x00 18.--19.         "  PDT       ,Delay after transfer prescaler" "1x,3x,5x,7x"
  bitfld.long  0x00 16.--17.         "  PBR       ,Baud rate prescaler" "2x,3x,5x,7x"
  TEXTLINE "                "
  bitfld.long  0x00 12.--15.         "  CSSCK ,PCS to SCK delay scaler"     "    2x,    4x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x,65536x"
  bitfld.long  0x00 08.--11.         "  ASC   ,After SCK delay scaler"      "    2x,    4x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x,65536x"
  bitfld.long  0x00 04.--07.         "  DT    ,Delay after transfer scaler" "    2x,    4x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x,65536x"
  bitfld.long  0x00 00.--03.         "  BR    ,Baud rate scaler"            "    2x,    4x,    6x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x"
TEXTLINE ""

group.long (0xFFF90000+0x18)++0x03
  line.long    0x00 "CTAR3,Clock and Transfer Attributes Register"
  bitfld.long  0x00 31.                "DBR        ,Double baud rate" "0,1"
  bitfld.long  0x00 27.--30.         "  FMSZ     ,Framesize" "res,res,res,  4 bits,  5 bits,  6 bits,  7 bits,  8 bits,  9 bits, 10 bits, 11 bits, 12 bits, 13 bits, 14 bits, 15 bits, 16 bits"
  TEXTLINE "                "
  bitfld.long  0x00 26.              "  CPOL    ,Clock polarity" " low,high"
  bitfld.long  0x00 25.              "  CPHA       ,Clock phase" "0,1"
  bitfld.long  0x00 24.              "  LSBFE      ,LSB first enable" "0,1"
  TEXTLINE "                "
  bitfld.long  0x00 22.--23.         "  PCSSCK    ,PCS to SCK delay prescaler" "1x,3x,5x,7x"
  bitfld.long  0x00 20.--21.         "  PASC      ,After SCK delay prescaler" "1x,3x,5x,7x"
  bitfld.long  0x00 18.--19.         "  PDT       ,Delay after transfer prescaler" "1x,3x,5x,7x"
  bitfld.long  0x00 16.--17.         "  PBR       ,Baud rate prescaler" "2x,3x,5x,7x"
  TEXTLINE "                "
  bitfld.long  0x00 12.--15.         "  CSSCK ,PCS to SCK delay scaler"     "    2x,    4x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x,65536x"
  bitfld.long  0x00 08.--11.         "  ASC   ,After SCK delay scaler"      "    2x,    4x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x,65536x"
  bitfld.long  0x00 04.--07.         "  DT    ,Delay after transfer scaler" "    2x,    4x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x,65536x"
  bitfld.long  0x00 00.--03.         "  BR    ,Baud rate scaler"            "    2x,    4x,    6x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x"
TEXTLINE ""

group.long (0xFFF90000+0x1C)++0x03
  line.long    0x00 "CTAR4,Clock and Transfer Attributes Register"
  bitfld.long  0x00 31.                "DBR        ,Double baud rate" "0,1"
  bitfld.long  0x00 27.--30.         "  FMSZ     ,Framesize" "res,res,res,  4 bits,  5 bits,  6 bits,  7 bits,  8 bits,  9 bits, 10 bits, 11 bits, 12 bits, 13 bits, 14 bits, 15 bits, 16 bits"
  TEXTLINE "                "
  bitfld.long  0x00 26.              "  CPOL    ,Clock polarity" " low,high"
  bitfld.long  0x00 25.              "  CPHA       ,Clock phase" "0,1"
  bitfld.long  0x00 24.              "  LSBFE      ,LSB first enable" "0,1"
  TEXTLINE "                "
  bitfld.long  0x00 22.--23.         "  PCSSCK    ,PCS to SCK delay prescaler" "1x,3x,5x,7x"
  bitfld.long  0x00 20.--21.         "  PASC      ,After SCK delay prescaler" "1x,3x,5x,7x"
  bitfld.long  0x00 18.--19.         "  PDT       ,Delay after transfer prescaler" "1x,3x,5x,7x"
  bitfld.long  0x00 16.--17.         "  PBR       ,Baud rate prescaler" "2x,3x,5x,7x"
  TEXTLINE "                "
  bitfld.long  0x00 12.--15.         "  CSSCK ,PCS to SCK delay scaler"     "    2x,    4x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x,65536x"
  bitfld.long  0x00 08.--11.         "  ASC   ,After SCK delay scaler"      "    2x,    4x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x,65536x"
  bitfld.long  0x00 04.--07.         "  DT    ,Delay after transfer scaler" "    2x,    4x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x,65536x"
  bitfld.long  0x00 00.--03.         "  BR    ,Baud rate scaler"            "    2x,    4x,    6x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x"
TEXTLINE ""

group.long (0xFFF90000+0x20)++0x03
  line.long    0x00 "CTAR5,Clock and Transfer Attributes Register"
  bitfld.long  0x00 31.                "DBR        ,Double baud rate" "0,1"
  bitfld.long  0x00 27.--30.         "  FMSZ     ,Framesize" "res,res,res,  4 bits,  5 bits,  6 bits,  7 bits,  8 bits,  9 bits, 10 bits, 11 bits, 12 bits, 13 bits, 14 bits, 15 bits, 16 bits"
  TEXTLINE "                "
  bitfld.long  0x00 26.              "  CPOL    ,Clock polarity" " low,high"
  bitfld.long  0x00 25.              "  CPHA       ,Clock phase" "0,1"
  bitfld.long  0x00 24.              "  LSBFE      ,LSB first enable" "0,1"
  TEXTLINE "                "
  bitfld.long  0x00 22.--23.         "  PCSSCK    ,PCS to SCK delay prescaler" "1x,3x,5x,7x"
  bitfld.long  0x00 20.--21.         "  PASC      ,After SCK delay prescaler" "1x,3x,5x,7x"
  bitfld.long  0x00 18.--19.         "  PDT       ,Delay after transfer prescaler" "1x,3x,5x,7x"
  bitfld.long  0x00 16.--17.         "  PBR       ,Baud rate prescaler" "2x,3x,5x,7x"
  TEXTLINE "                "
  bitfld.long  0x00 12.--15.         "  CSSCK ,PCS to SCK delay scaler"     "    2x,    4x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x,65536x"
  bitfld.long  0x00 08.--11.         "  ASC   ,After SCK delay scaler"      "    2x,    4x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x,65536x"
  bitfld.long  0x00 04.--07.         "  DT    ,Delay after transfer scaler" "    2x,    4x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x,65536x"
  bitfld.long  0x00 00.--03.         "  BR    ,Baud rate scaler"            "    2x,    4x,    6x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x"
TEXTLINE ""

group.long (0xFFF90000+0x24)++0x03
  line.long    0x00 "CTAR6,Clock and Transfer Attributes Register"
  bitfld.long  0x00 31.                "DBR        ,Double baud rate" "0,1"
  bitfld.long  0x00 27.--30.         "  FMSZ     ,Framesize" "res,res,res,  4 bits,  5 bits,  6 bits,  7 bits,  8 bits,  9 bits, 10 bits, 11 bits, 12 bits, 13 bits, 14 bits, 15 bits, 16 bits"
  TEXTLINE "                "
  bitfld.long  0x00 26.              "  CPOL    ,Clock polarity" " low,high"
  bitfld.long  0x00 25.              "  CPHA       ,Clock phase" "0,1"
  bitfld.long  0x00 24.              "  LSBFE      ,LSB first enable" "0,1"
  TEXTLINE "                "
  bitfld.long  0x00 22.--23.         "  PCSSCK    ,PCS to SCK delay prescaler" "1x,3x,5x,7x"
  bitfld.long  0x00 20.--21.         "  PASC      ,After SCK delay prescaler" "1x,3x,5x,7x"
  bitfld.long  0x00 18.--19.         "  PDT       ,Delay after transfer prescaler" "1x,3x,5x,7x"
  bitfld.long  0x00 16.--17.         "  PBR       ,Baud rate prescaler" "2x,3x,5x,7x"
  TEXTLINE "                "
  bitfld.long  0x00 12.--15.         "  CSSCK ,PCS to SCK delay scaler"     "    2x,    4x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x,65536x"
  bitfld.long  0x00 08.--11.         "  ASC   ,After SCK delay scaler"      "    2x,    4x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x,65536x"
  bitfld.long  0x00 04.--07.         "  DT    ,Delay after transfer scaler" "    2x,    4x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x,65536x"
  bitfld.long  0x00 00.--03.         "  BR    ,Baud rate scaler"            "    2x,    4x,    6x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x"
TEXTLINE ""

group.long (0xFFF90000+0x28)++0x03
  line.long    0x00 "CTAR7,Clock and Transfer Attributes Register"
  bitfld.long  0x00 31.                "DBR        ,Double baud rate" "0,1"
  bitfld.long  0x00 27.--30.         "  FMSZ     ,Framesize" "res,res,res,  4 bits,  5 bits,  6 bits,  7 bits,  8 bits,  9 bits, 10 bits, 11 bits, 12 bits, 13 bits, 14 bits, 15 bits, 16 bits"
  TEXTLINE "                "
  bitfld.long  0x00 26.              "  CPOL    ,Clock polarity" " low,high"
  bitfld.long  0x00 25.              "  CPHA       ,Clock phase" "0,1"
  bitfld.long  0x00 24.              "  LSBFE      ,LSB first enable" "0,1"
  TEXTLINE "                "
  bitfld.long  0x00 22.--23.         "  PCSSCK    ,PCS to SCK delay prescaler" "1x,3x,5x,7x"
  bitfld.long  0x00 20.--21.         "  PASC      ,After SCK delay prescaler" "1x,3x,5x,7x"
  bitfld.long  0x00 18.--19.         "  PDT       ,Delay after transfer prescaler" "1x,3x,5x,7x"
  bitfld.long  0x00 16.--17.         "  PBR       ,Baud rate prescaler" "2x,3x,5x,7x"
  TEXTLINE "                "
  bitfld.long  0x00 12.--15.         "  CSSCK ,PCS to SCK delay scaler"     "    2x,    4x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x,65536x"
  bitfld.long  0x00 08.--11.         "  ASC   ,After SCK delay scaler"      "    2x,    4x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x,65536x"
  bitfld.long  0x00 04.--07.         "  DT    ,Delay after transfer scaler" "    2x,    4x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x,65536x"
  bitfld.long  0x00 00.--03.         "  BR    ,Baud rate scaler"            "    2x,    4x,    6x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x"
TEXTLINE ""


group.long (0xFFF90000+0x2C)++0x03
  line.long    0x00 "SR,DSPI Status Register"
  eventfld.long  0x00 31.                "TCF       ,Transfer complete flag" "0,1"
  eventfld.long  0x00 30.              "  TXRXS     ,TX & RX status" "0,1"
  eventfld.long  0x00 28.              "  EOQF      ,End-of-queue flag" "0,1"
  TEXTLINE "                "
  eventfld.long  0x00 27.              "  TFUF      ,Transmit FIFO underflow flag" "0,1"
  eventfld.long  0x00 25.              "  TFFF      ,Transmit FIFO fill flag" "0,1"
  eventfld.long  0x00 19.              "  RFOF      ,Receive FIFO overflow flag" "0,1"
  eventfld.long  0x00 17.              "  RFDF      ,Receive FIFO drain flag" "0,1"
  TEXTLINE "                "
  bitfld.long  0x00 12.--15.           "  TXCTR    ,TX FIFO Counter" " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.           "  TXNXTPTR ,Transmit next pointer." " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long  0x00 04.--07.           "  RXCTR    ,RX FIFO Counter" " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.           "  POPNXTPTR ,Pop next pointer" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
TEXTLINE ""

group.long (0xFFF90000+0x30)++0x03
  line.long    0x00 "RSER,DSPI DMA/Interrupt Request Select and Enable Register"
  bitfld.long  0x00 31.                "TCF_RE    ,Transfer complete request enable" "0,1"
  bitfld.long  0x00 28.              "  EOQF_RE   ,End-of-queue request enable" "0,1"
  bitfld.long  0x00 27.              "  TFUF_RE   ,Transmit FIFO underflow request enable" "0,1"
  bitfld.long  0x00 25.              "  TFFF_RE   ,Transmit FIFO fill request enable" "0,1"
  bitfld.long  0x00 24.              "  TFFF_DIRS ,Transmit FIFO fill request select" "INT,DMA"
  TEXTLINE "                "
  bitfld.long  0x00 19.              "  RFOF_RE   ,Receive FIFO overflow request enable" "0,1"
  bitfld.long  0x00 17.              "  RFDF_RE   ,Receive FIFO drain request enable" "0,1"
  bitfld.long  0x00 16.              "  RFDF_DIRS ,Receive FIFO drain request select" "INT,DMA"
TEXTLINE ""

group.long (0xFFF90000+0x34)++0x03
  line.long    0x00 "PUSHR,DSPI PUSH TX FIFO Register"
  bitfld.long  0x00 31.              "CONT ,Continuous peripheral chip select enable" "0,1"
  bitfld.long  0x00 28.--30.         "  CTAS ,Clock and transfer attributes select" "DSPI_CTAR0,DSPI_CTAR1,DSPI_CTAR2,DSPI_CTAR3,DSPI_CTAR4,DSPI_CTAR5,DSPI_CTAR6,DSPI_CTAR7"
  bitfld.long  0x00 27.              "  EOQ ,End-of-queue." "0,1"
  bitfld.long  0x00 26.              "  CTCNT ,Clear SPI_TCNT" "0,1"
  bitfld.long  0x00 23.              "  PCS7-0 ,Peripheral chip select 7" "0,1"
  bitfld.long  0x00 22.              ",Peripheral chip select 6" "0,1"
  bitfld.long  0x00 21.              ",Peripheral chip select 5" "0,1"
  bitfld.long  0x00 20.              ",Peripheral chip select 4" "0,1"
  bitfld.long  0x00 19.              " ,Peripheral chip select 3" "0,1"
  bitfld.long  0x00 18.              ",Peripheral chip select 2" "0,1"
  bitfld.long  0x00 17.              ",Peripheral chip select 1" "0,1"
  bitfld.long  0x00 16.              ",Peripheral chip select 0" "0,1"
  hexmask.long.word 0x00 00.--15. 1. "  TXDATA ,Transfer data"
TEXTLINE ""

wgroup.long (0xFFF90000+0x38)++0x03
  hide.long    0x00 "POPR,DSPI POP RX FIFO Register"
  IN
TEXTLINE ""

group.long (0xFFF90000+0x3C)++0x03
  line.long    0x00 "TXFR00,Transmit FIFO Register 0"
group.long (0xFFF90000+0x40)++0x03
  line.long    0x00 "TXFR01,Transmit FIFO Register 1"
group.long (0xFFF90000+0x44)++0x03
  line.long    0x00 "TXFR02,Transmit FIFO Register 2"
group.long (0xFFF90000+0x48)++0x03
  line.long    0x00 "TXFR03,Transmit FIFO Register 3"
group.long (0xFFF90000+0x4C)++0x03
  line.long    0x00 "TXFR04,Transmit FIFO Register 4"
group.long (0xFFF90000+0x50)++0x03
  line.long    0x00 "TXFR05,Transmit FIFO Register 5"
group.long (0xFFF90000+0x54)++0x03
  line.long    0x00 "TXFR06,Transmit FIFO Register 6"
group.long (0xFFF90000+0x58)++0x03
  line.long    0x00 "TXFR07,Transmit FIFO Register 7"
group.long (0xFFF90000+0x5C)++0x03
  line.long    0x00 "TXFR08,Transmit FIFO Register 8"
group.long (0xFFF90000+0x60)++0x03
  line.long    0x00 "TXFR09,Transmit FIFO Register 9"
group.long (0xFFF90000+0x64)++0x03
  line.long    0x00 "TXFR10,Transmit FIFO Register 10"
group.long (0xFFF90000+0x68)++0x03
  line.long    0x00 "TXFR11,Transmit FIFO Register 11"
group.long (0xFFF90000+0x6C)++0x03
  line.long    0x00 "TXFR12,Transmit FIFO Register 12"
group.long (0xFFF90000+0x70)++0x03
  line.long    0x00 "TXFR13,Transmit FIFO Register 13"
group.long (0xFFF90000+0x74)++0x03
  line.long    0x00 "TXFR14,Transmit FIFO Register 14"



TEXTLINE ""

group.long (0xFFF90000+0x7C)++0x03
  line.long    0x00 "RXFR0,DSPI Receive FIFO Register"
  hexmask.word 0x02 00.--15. 1.      "RXDATA ,Receive data"

group.long (0xFFF90000+0x80)++0x03
  line.long    0x00 "RXFR1,DSPI Receive FIFO Register"
  hexmask.word 0x02 00.--15. 1.      "RXDATA ,Receive data"

group.long (0xFFF90000+0x84)++0x03
  line.long    0x00 "RXFR2,DSPI Receive FIFO Register"
  hexmask.word 0x02 00.--15. 1.      "RXDATA ,Receive data"

group.long (0xFFF90000+0x88)++0x03
  line.long    0x00 "RXFR3,DSPI Receive FIFO Register"
  hexmask.word 0x02 00.--15. 1.      "RXDATA ,Receive data"

TEXTLINE ""

group.long (0xFFF90000+0xBC)++0x03
  line.long    0x00 "DSICR,DSPI DSI Configuration Register"
  bitfld.long  0x00 31.              "MTOE ,Multiple transfer operation enable" "0,1"
  hexmask.byte 0x00 00.--05. 1.      "   MTOCNT  ,Multiple transfer operation count"
  bitfld.long  0x00 19.              "  TXSS ,Transmit data source select" "0,1"
  bitfld.long  0x00 18.              "  TPOL  ,Trigger polarity" "0,1"
  bitfld.long  0x00 17.              "  TRRE  ,Trigger reception enable" "0,1"
  bitfld.long  0x00 16.              "  CID   ,Change in data transfer enable" "0,1"
  TEXTLINE "                "
  bitfld.long  0x00 15.              "  DCONT ,DSI continuous peripheral chip select enable" "0,1"
  bitfld.long  0x00 12.--14.         "  DSICTAS ,DSI Clock and Transfer Attributes select" "DSPI_CTAR0,DSPI_CTAR1,DSPI_CTAR2,DSPI_CTAR3,DSPI_CTAR4,DSPI_CTAR5,DSPI_CTAR6,DSPI_CTAR7"
  bitfld.long  0x00 23.              "  DPCS7-0 ,Peripheral chip select 7" "0,1"
  bitfld.long  0x00 22.              ",Peripheral chip select 6" "0,1"
  bitfld.long  0x00 21.              ",Peripheral chip select 5" "0,1"
  bitfld.long  0x00 20.              ",Peripheral chip select 4" "0,1"
  bitfld.long  0x00 19.              " ,Peripheral chip select 3" "0,1"
  bitfld.long  0x00 18.              ",Peripheral chip select 2" "0,1"
  bitfld.long  0x00 17.              ",Peripheral chip select 1" "0,1"
  bitfld.long  0x00 16.              ",Peripheral chip select 0" "0,1"
TEXTLINE ""

group.long (0xFFF90000+0xC0)++0x03
  line.long    0x00 "SDR,DSPI DSI Serialization Data Register"

group.long (0xFFF90000+0xC4)++0x03
  line.long    0x00 "ASDR,DSPI DSI Serialization Data Register"

group.long (0xFFF90000+0xC8)++0x03
  line.long    0x00 "COMPR,DSPI Transmit Comparison Register"

group.long (0xFFF90000+0xCC)++0x03
  line.long    0x00 "DDR,DSPI Deserialization Data Register"


sif (cpu()=="MPC5632M")||(cpu()=="MPC5633M")||(cpu()=="MPC5634M")||(cpu()=="SPC563M54")||(cpu()=="SPC563M60")||(cpu()=="SPC563M64")||(CPUIS("MPC5674*"))
 TEXTLINE ""

 group.long (0xFFF90000+0xD0)++0x03
   line.long    0x00 "DSICR1,DSPI DSI Configuration Register 1"
   bitfld.long  0x00 24.--28.         "TSBCNT ,Timed Serial Bus Operation Count" "res(0),res(1),res(2),res(3),res(4),5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
  bitfld.long  0x00 23.              "  DPCS7-0 ,Peripheral chip select 7" "0,1"
  bitfld.long  0x00 22.              ",Peripheral chip select 6" "0,1"
  bitfld.long  0x00 21.              ",Peripheral chip select 5" "0,1"
  bitfld.long  0x00 20.              ",Peripheral chip select 4" "0,1"
  bitfld.long  0x00 19.              " ,Peripheral chip select 3" "0,1"
  bitfld.long  0x00 18.              ",Peripheral chip select 2" "0,1"
  bitfld.long  0x00 17.              ",Peripheral chip select 1" "0,1"
  bitfld.long  0x00 16.              ",Peripheral chip select 0" "0,1"

endif
 
   
tree.end

  endif
  sif (cpu()=="MPC5534")||(cpu()=="MPC5553")||(cpu()=="MPC5554")||(cpu()=="MPC5561")||(cpu()=="MPC5565")||(cpu()=="MPC5566")||(cpu()=="MPC5567")||(cpu()=="MPC5633M")||(cpu()=="MPC5634M")||(cpu()=="SPC563M60")||(cpu()=="SPC563M64")||(CPUIS("MPC5674*"))
tree "DSPI B"

group.long 0xFFF94000++0x03
  line.long    0x00 "MCR,Module Configuration Register"
  bitfld.long  0x00 31.                "MSTR      ,Master/slave mode select" "S,M"
  bitfld.long  0x00 30.              "  CONT_SCKE ,Continuous SCK enable" "0,1"
  bitfld.long  0x00 28.--29.         "  DCONF   ,DSPI configuration" "SPI,DSI,CSI,res"
  bitfld.long  0x00 27.              "  FRZ       ,Freeze" "0,1"
  TEXTLINE "                "
  bitfld.long  0x00 26.              "  MTFE      ,Modified timing format enable" "0,1"
  bitfld.long  0x00 25.              "  PCSSE     ,Peripheral chip select strobe enable" "0,1"
  bitfld.long  0x00 24.              "  ROOE      ,Receive FIFO overflow overwrite enable" "0,1"
  bitfld.long  0x00 23.              "  PCSIS7-0  ,Peripheral chip select 7 inactive state" "L,H"
  bitfld.long  0x00 22.              ",Peripheral chip select 6 inactive state" "L,H"
  bitfld.long  0x00 21.              ",Peripheral chip select 5 inactive state" "L,H"
  bitfld.long  0x00 20.              ",Peripheral chip select 4 inactive state" "L,H"
  bitfld.long  0x00 19.              " ,Peripheral chip select 3 inactive state" "L,H"
  bitfld.long  0x00 18.              ",Peripheral chip select 2 inactive state" "L,H"
  bitfld.long  0x00 17.              ",Peripheral chip select 1 inactive state" "L,H"
  bitfld.long  0x00 16.              ",Peripheral chip select 0 inactive state" "L,H"
  TEXTLINE "                "
  bitfld.long  0x00 15.              "  DOZE      ,Doze enable" "0,1"
  bitfld.long  0x00 14.              "  MDIS      ,Module disable" "0,1"
  TEXTLINE "                "
  bitfld.long  0x00 13.              "  DIS_TXF   ,Disable transmit FIFO" "0,1"
  bitfld.long  0x00 12.              "  DIS_RXF   ,Disable receive FIFO" "0,1"
  bitfld.long  0x00 11.              "  CLR_TXF   ,Clear TX FIFO" "0,1"
  bitfld.long  0x00 10.              "  CLR_RXF   ,Clear RX FIFO." "0,1"
  TEXTLINE "                "
  bitfld.long  0x00 08.--09.         "  SMPL_PT ,Sample point" "  0,  1,  2,res"
  bitfld.long  0x00 00.              "  HALT      ,Halt" "0,1"
TEXTLINE ""

group.long (0xFFF94000+0x08)++0x03
  line.long    0x00 "TCR,Transfer Count Register"
  hexmask.word 0x00 00.--15. 1. "TCNT , SPI transfer counter"
TEXTLINE ""

group.long (0xFFF94000+0x0C)++0x03
  line.long    0x00 "CTAR0,Clock and Transfer Attributes Register"
  bitfld.long  0x00 31.                "DBR        ,Double baud rate" "0,1"
  bitfld.long  0x00 27.--30.         "  FMSZ     ,Framesize" "res,res,res,  4 bits,  5 bits,  6 bits,  7 bits,  8 bits,  9 bits, 10 bits, 11 bits, 12 bits, 13 bits, 14 bits, 15 bits, 16 bits"
  TEXTLINE "                "
  bitfld.long  0x00 26.              "  CPOL    ,Clock polarity" " low,high"
  bitfld.long  0x00 25.              "  CPHA       ,Clock phase" "0,1"
  bitfld.long  0x00 24.              "  LSBFE      ,LSB first enable" "0,1"
  TEXTLINE "                "
  bitfld.long  0x00 22.--23.         "  PCSSCK    ,PCS to SCK delay prescaler" "1x,3x,5x,7x"
  bitfld.long  0x00 20.--21.         "  PASC      ,After SCK delay prescaler" "1x,3x,5x,7x"
  bitfld.long  0x00 18.--19.         "  PDT       ,Delay after transfer prescaler" "1x,3x,5x,7x"
  bitfld.long  0x00 16.--17.         "  PBR       ,Baud rate prescaler" "2x,3x,5x,7x"
  TEXTLINE "                "
  bitfld.long  0x00 12.--15.         "  CSSCK ,PCS to SCK delay scaler"     "    2x,    4x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x,65536x"
  bitfld.long  0x00 08.--11.         "  ASC   ,After SCK delay scaler"      "    2x,    4x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x,65536x"
  bitfld.long  0x00 04.--07.         "  DT    ,Delay after transfer scaler" "    2x,    4x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x,65536x"
  bitfld.long  0x00 00.--03.         "  BR    ,Baud rate scaler"            "    2x,    4x,    6x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x"
TEXTLINE ""

group.long (0xFFF94000+0x10)++0x03
  line.long    0x00 "CTAR1,Clock and Transfer Attributes Register"
  bitfld.long  0x00 31.                "DBR        ,Double baud rate" "0,1"
  bitfld.long  0x00 27.--30.         "  FMSZ     ,Framesize" "res,res,res,  4 bits,  5 bits,  6 bits,  7 bits,  8 bits,  9 bits, 10 bits, 11 bits, 12 bits, 13 bits, 14 bits, 15 bits, 16 bits"
  TEXTLINE "                "
  bitfld.long  0x00 26.              "  CPOL    ,Clock polarity" " low,high"
  bitfld.long  0x00 25.              "  CPHA       ,Clock phase" "0,1"
  bitfld.long  0x00 24.              "  LSBFE      ,LSB first enable" "0,1"
  TEXTLINE "                "
  bitfld.long  0x00 22.--23.         "  PCSSCK    ,PCS to SCK delay prescaler" "1x,3x,5x,7x"
  bitfld.long  0x00 20.--21.         "  PASC      ,After SCK delay prescaler" "1x,3x,5x,7x"
  bitfld.long  0x00 18.--19.         "  PDT       ,Delay after transfer prescaler" "1x,3x,5x,7x"
  bitfld.long  0x00 16.--17.         "  PBR       ,Baud rate prescaler" "2x,3x,5x,7x"
  TEXTLINE "                "
  bitfld.long  0x00 12.--15.         "  CSSCK ,PCS to SCK delay scaler"     "    2x,    4x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x,65536x"
  bitfld.long  0x00 08.--11.         "  ASC   ,After SCK delay scaler"      "    2x,    4x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x,65536x"
  bitfld.long  0x00 04.--07.         "  DT    ,Delay after transfer scaler" "    2x,    4x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x,65536x"
  bitfld.long  0x00 00.--03.         "  BR    ,Baud rate scaler"            "    2x,    4x,    6x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x"
TEXTLINE ""

group.long (0xFFF94000+0x14)++0x03
  line.long    0x00 "CTAR2,Clock and Transfer Attributes Register"
  bitfld.long  0x00 31.                "DBR        ,Double baud rate" "0,1"
  bitfld.long  0x00 27.--30.         "  FMSZ     ,Framesize" "res,res,res,  4 bits,  5 bits,  6 bits,  7 bits,  8 bits,  9 bits, 10 bits, 11 bits, 12 bits, 13 bits, 14 bits, 15 bits, 16 bits"
  TEXTLINE "                "
  bitfld.long  0x00 26.              "  CPOL    ,Clock polarity" " low,high"
  bitfld.long  0x00 25.              "  CPHA       ,Clock phase" "0,1"
  bitfld.long  0x00 24.              "  LSBFE      ,LSB first enable" "0,1"
  TEXTLINE "                "
  bitfld.long  0x00 22.--23.         "  PCSSCK    ,PCS to SCK delay prescaler" "1x,3x,5x,7x"
  bitfld.long  0x00 20.--21.         "  PASC      ,After SCK delay prescaler" "1x,3x,5x,7x"
  bitfld.long  0x00 18.--19.         "  PDT       ,Delay after transfer prescaler" "1x,3x,5x,7x"
  bitfld.long  0x00 16.--17.         "  PBR       ,Baud rate prescaler" "2x,3x,5x,7x"
  TEXTLINE "                "
  bitfld.long  0x00 12.--15.         "  CSSCK ,PCS to SCK delay scaler"     "    2x,    4x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x,65536x"
  bitfld.long  0x00 08.--11.         "  ASC   ,After SCK delay scaler"      "    2x,    4x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x,65536x"
  bitfld.long  0x00 04.--07.         "  DT    ,Delay after transfer scaler" "    2x,    4x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x,65536x"
  bitfld.long  0x00 00.--03.         "  BR    ,Baud rate scaler"            "    2x,    4x,    6x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x"
TEXTLINE ""

group.long (0xFFF94000+0x18)++0x03
  line.long    0x00 "CTAR3,Clock and Transfer Attributes Register"
  bitfld.long  0x00 31.                "DBR        ,Double baud rate" "0,1"
  bitfld.long  0x00 27.--30.         "  FMSZ     ,Framesize" "res,res,res,  4 bits,  5 bits,  6 bits,  7 bits,  8 bits,  9 bits, 10 bits, 11 bits, 12 bits, 13 bits, 14 bits, 15 bits, 16 bits"
  TEXTLINE "                "
  bitfld.long  0x00 26.              "  CPOL    ,Clock polarity" " low,high"
  bitfld.long  0x00 25.              "  CPHA       ,Clock phase" "0,1"
  bitfld.long  0x00 24.              "  LSBFE      ,LSB first enable" "0,1"
  TEXTLINE "                "
  bitfld.long  0x00 22.--23.         "  PCSSCK    ,PCS to SCK delay prescaler" "1x,3x,5x,7x"
  bitfld.long  0x00 20.--21.         "  PASC      ,After SCK delay prescaler" "1x,3x,5x,7x"
  bitfld.long  0x00 18.--19.         "  PDT       ,Delay after transfer prescaler" "1x,3x,5x,7x"
  bitfld.long  0x00 16.--17.         "  PBR       ,Baud rate prescaler" "2x,3x,5x,7x"
  TEXTLINE "                "
  bitfld.long  0x00 12.--15.         "  CSSCK ,PCS to SCK delay scaler"     "    2x,    4x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x,65536x"
  bitfld.long  0x00 08.--11.         "  ASC   ,After SCK delay scaler"      "    2x,    4x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x,65536x"
  bitfld.long  0x00 04.--07.         "  DT    ,Delay after transfer scaler" "    2x,    4x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x,65536x"
  bitfld.long  0x00 00.--03.         "  BR    ,Baud rate scaler"            "    2x,    4x,    6x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x"
TEXTLINE ""

group.long (0xFFF94000+0x1C)++0x03
  line.long    0x00 "CTAR4,Clock and Transfer Attributes Register"
  bitfld.long  0x00 31.                "DBR        ,Double baud rate" "0,1"
  bitfld.long  0x00 27.--30.         "  FMSZ     ,Framesize" "res,res,res,  4 bits,  5 bits,  6 bits,  7 bits,  8 bits,  9 bits, 10 bits, 11 bits, 12 bits, 13 bits, 14 bits, 15 bits, 16 bits"
  TEXTLINE "                "
  bitfld.long  0x00 26.              "  CPOL    ,Clock polarity" " low,high"
  bitfld.long  0x00 25.              "  CPHA       ,Clock phase" "0,1"
  bitfld.long  0x00 24.              "  LSBFE      ,LSB first enable" "0,1"
  TEXTLINE "                "
  bitfld.long  0x00 22.--23.         "  PCSSCK    ,PCS to SCK delay prescaler" "1x,3x,5x,7x"
  bitfld.long  0x00 20.--21.         "  PASC      ,After SCK delay prescaler" "1x,3x,5x,7x"
  bitfld.long  0x00 18.--19.         "  PDT       ,Delay after transfer prescaler" "1x,3x,5x,7x"
  bitfld.long  0x00 16.--17.         "  PBR       ,Baud rate prescaler" "2x,3x,5x,7x"
  TEXTLINE "                "
  bitfld.long  0x00 12.--15.         "  CSSCK ,PCS to SCK delay scaler"     "    2x,    4x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x,65536x"
  bitfld.long  0x00 08.--11.         "  ASC   ,After SCK delay scaler"      "    2x,    4x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x,65536x"
  bitfld.long  0x00 04.--07.         "  DT    ,Delay after transfer scaler" "    2x,    4x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x,65536x"
  bitfld.long  0x00 00.--03.         "  BR    ,Baud rate scaler"            "    2x,    4x,    6x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x"
TEXTLINE ""

group.long (0xFFF94000+0x20)++0x03
  line.long    0x00 "CTAR5,Clock and Transfer Attributes Register"
  bitfld.long  0x00 31.                "DBR        ,Double baud rate" "0,1"
  bitfld.long  0x00 27.--30.         "  FMSZ     ,Framesize" "res,res,res,  4 bits,  5 bits,  6 bits,  7 bits,  8 bits,  9 bits, 10 bits, 11 bits, 12 bits, 13 bits, 14 bits, 15 bits, 16 bits"
  TEXTLINE "                "
  bitfld.long  0x00 26.              "  CPOL    ,Clock polarity" " low,high"
  bitfld.long  0x00 25.              "  CPHA       ,Clock phase" "0,1"
  bitfld.long  0x00 24.              "  LSBFE      ,LSB first enable" "0,1"
  TEXTLINE "                "
  bitfld.long  0x00 22.--23.         "  PCSSCK    ,PCS to SCK delay prescaler" "1x,3x,5x,7x"
  bitfld.long  0x00 20.--21.         "  PASC      ,After SCK delay prescaler" "1x,3x,5x,7x"
  bitfld.long  0x00 18.--19.         "  PDT       ,Delay after transfer prescaler" "1x,3x,5x,7x"
  bitfld.long  0x00 16.--17.         "  PBR       ,Baud rate prescaler" "2x,3x,5x,7x"
  TEXTLINE "                "
  bitfld.long  0x00 12.--15.         "  CSSCK ,PCS to SCK delay scaler"     "    2x,    4x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x,65536x"
  bitfld.long  0x00 08.--11.         "  ASC   ,After SCK delay scaler"      "    2x,    4x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x,65536x"
  bitfld.long  0x00 04.--07.         "  DT    ,Delay after transfer scaler" "    2x,    4x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x,65536x"
  bitfld.long  0x00 00.--03.         "  BR    ,Baud rate scaler"            "    2x,    4x,    6x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x"
TEXTLINE ""

group.long (0xFFF94000+0x24)++0x03
  line.long    0x00 "CTAR6,Clock and Transfer Attributes Register"
  bitfld.long  0x00 31.                "DBR        ,Double baud rate" "0,1"
  bitfld.long  0x00 27.--30.         "  FMSZ     ,Framesize" "res,res,res,  4 bits,  5 bits,  6 bits,  7 bits,  8 bits,  9 bits, 10 bits, 11 bits, 12 bits, 13 bits, 14 bits, 15 bits, 16 bits"
  TEXTLINE "                "
  bitfld.long  0x00 26.              "  CPOL    ,Clock polarity" " low,high"
  bitfld.long  0x00 25.              "  CPHA       ,Clock phase" "0,1"
  bitfld.long  0x00 24.              "  LSBFE      ,LSB first enable" "0,1"
  TEXTLINE "                "
  bitfld.long  0x00 22.--23.         "  PCSSCK    ,PCS to SCK delay prescaler" "1x,3x,5x,7x"
  bitfld.long  0x00 20.--21.         "  PASC      ,After SCK delay prescaler" "1x,3x,5x,7x"
  bitfld.long  0x00 18.--19.         "  PDT       ,Delay after transfer prescaler" "1x,3x,5x,7x"
  bitfld.long  0x00 16.--17.         "  PBR       ,Baud rate prescaler" "2x,3x,5x,7x"
  TEXTLINE "                "
  bitfld.long  0x00 12.--15.         "  CSSCK ,PCS to SCK delay scaler"     "    2x,    4x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x,65536x"
  bitfld.long  0x00 08.--11.         "  ASC   ,After SCK delay scaler"      "    2x,    4x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x,65536x"
  bitfld.long  0x00 04.--07.         "  DT    ,Delay after transfer scaler" "    2x,    4x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x,65536x"
  bitfld.long  0x00 00.--03.         "  BR    ,Baud rate scaler"            "    2x,    4x,    6x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x"
TEXTLINE ""

group.long (0xFFF94000+0x28)++0x03
  line.long    0x00 "CTAR7,Clock and Transfer Attributes Register"
  bitfld.long  0x00 31.                "DBR        ,Double baud rate" "0,1"
  bitfld.long  0x00 27.--30.         "  FMSZ     ,Framesize" "res,res,res,  4 bits,  5 bits,  6 bits,  7 bits,  8 bits,  9 bits, 10 bits, 11 bits, 12 bits, 13 bits, 14 bits, 15 bits, 16 bits"
  TEXTLINE "                "
  bitfld.long  0x00 26.              "  CPOL    ,Clock polarity" " low,high"
  bitfld.long  0x00 25.              "  CPHA       ,Clock phase" "0,1"
  bitfld.long  0x00 24.              "  LSBFE      ,LSB first enable" "0,1"
  TEXTLINE "                "
  bitfld.long  0x00 22.--23.         "  PCSSCK    ,PCS to SCK delay prescaler" "1x,3x,5x,7x"
  bitfld.long  0x00 20.--21.         "  PASC      ,After SCK delay prescaler" "1x,3x,5x,7x"
  bitfld.long  0x00 18.--19.         "  PDT       ,Delay after transfer prescaler" "1x,3x,5x,7x"
  bitfld.long  0x00 16.--17.         "  PBR       ,Baud rate prescaler" "2x,3x,5x,7x"
  TEXTLINE "                "
  bitfld.long  0x00 12.--15.         "  CSSCK ,PCS to SCK delay scaler"     "    2x,    4x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x,65536x"
  bitfld.long  0x00 08.--11.         "  ASC   ,After SCK delay scaler"      "    2x,    4x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x,65536x"
  bitfld.long  0x00 04.--07.         "  DT    ,Delay after transfer scaler" "    2x,    4x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x,65536x"
  bitfld.long  0x00 00.--03.         "  BR    ,Baud rate scaler"            "    2x,    4x,    6x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x"
TEXTLINE ""


group.long (0xFFF94000+0x2C)++0x03
  line.long    0x00 "SR,DSPI Status Register"
  eventfld.long  0x00 31.                "TCF       ,Transfer complete flag" "0,1"
  eventfld.long  0x00 30.              "  TXRXS     ,TX & RX status" "0,1"
  eventfld.long  0x00 28.              "  EOQF      ,End-of-queue flag" "0,1"
  TEXTLINE "                "
  eventfld.long  0x00 27.              "  TFUF      ,Transmit FIFO underflow flag" "0,1"
  eventfld.long  0x00 25.              "  TFFF      ,Transmit FIFO fill flag" "0,1"
  eventfld.long  0x00 19.              "  RFOF      ,Receive FIFO overflow flag" "0,1"
  eventfld.long  0x00 17.              "  RFDF      ,Receive FIFO drain flag" "0,1"
  TEXTLINE "                "
  bitfld.long  0x00 12.--15.           "  TXCTR    ,TX FIFO Counter" " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.           "  TXNXTPTR ,Transmit next pointer." " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long  0x00 04.--07.           "  RXCTR    ,RX FIFO Counter" " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.           "  POPNXTPTR ,Pop next pointer" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
TEXTLINE ""

group.long (0xFFF94000+0x30)++0x03
  line.long    0x00 "RSER,DSPI DMA/Interrupt Request Select and Enable Register"
  bitfld.long  0x00 31.                "TCF_RE    ,Transfer complete request enable" "0,1"
  bitfld.long  0x00 28.              "  EOQF_RE   ,End-of-queue request enable" "0,1"
  bitfld.long  0x00 27.              "  TFUF_RE   ,Transmit FIFO underflow request enable" "0,1"
  bitfld.long  0x00 25.              "  TFFF_RE   ,Transmit FIFO fill request enable" "0,1"
  bitfld.long  0x00 24.              "  TFFF_DIRS ,Transmit FIFO fill request select" "INT,DMA"
  TEXTLINE "                "
  bitfld.long  0x00 19.              "  RFOF_RE   ,Receive FIFO overflow request enable" "0,1"
  bitfld.long  0x00 17.              "  RFDF_RE   ,Receive FIFO drain request enable" "0,1"
  bitfld.long  0x00 16.              "  RFDF_DIRS ,Receive FIFO drain request select" "INT,DMA"
TEXTLINE ""

group.long (0xFFF94000+0x34)++0x03
  line.long    0x00 "PUSHR,DSPI PUSH TX FIFO Register"
  bitfld.long  0x00 31.              "CONT ,Continuous peripheral chip select enable" "0,1"
  bitfld.long  0x00 28.--30.         "  CTAS ,Clock and transfer attributes select" "DSPI_CTAR0,DSPI_CTAR1,DSPI_CTAR2,DSPI_CTAR3,DSPI_CTAR4,DSPI_CTAR5,DSPI_CTAR6,DSPI_CTAR7"
  bitfld.long  0x00 27.              "  EOQ ,End-of-queue." "0,1"
  bitfld.long  0x00 26.              "  CTCNT ,Clear SPI_TCNT" "0,1"
  bitfld.long  0x00 23.              "  PCS7-0 ,Peripheral chip select 7" "0,1"
  bitfld.long  0x00 22.              ",Peripheral chip select 6" "0,1"
  bitfld.long  0x00 21.              ",Peripheral chip select 5" "0,1"
  bitfld.long  0x00 20.              ",Peripheral chip select 4" "0,1"
  bitfld.long  0x00 19.              " ,Peripheral chip select 3" "0,1"
  bitfld.long  0x00 18.              ",Peripheral chip select 2" "0,1"
  bitfld.long  0x00 17.              ",Peripheral chip select 1" "0,1"
  bitfld.long  0x00 16.              ",Peripheral chip select 0" "0,1"
  hexmask.long.word 0x00 00.--15. 1. "  TXDATA ,Transfer data"
TEXTLINE ""

wgroup.long (0xFFF94000+0x38)++0x03
  hide.long    0x00 "POPR,DSPI POP RX FIFO Register"
  IN
TEXTLINE ""

group.long (0xFFF94000+0x3C)++0x03
  line.long    0x00 "TXFR00,Transmit FIFO Register 0"
group.long (0xFFF94000+0x40)++0x03
  line.long    0x00 "TXFR01,Transmit FIFO Register 1"
group.long (0xFFF94000+0x44)++0x03
  line.long    0x00 "TXFR02,Transmit FIFO Register 2"
group.long (0xFFF94000+0x48)++0x03
  line.long    0x00 "TXFR03,Transmit FIFO Register 3"
group.long (0xFFF94000+0x4C)++0x03
  line.long    0x00 "TXFR04,Transmit FIFO Register 4"
group.long (0xFFF94000+0x50)++0x03
  line.long    0x00 "TXFR05,Transmit FIFO Register 5"
group.long (0xFFF94000+0x54)++0x03
  line.long    0x00 "TXFR06,Transmit FIFO Register 6"
group.long (0xFFF94000+0x58)++0x03
  line.long    0x00 "TXFR07,Transmit FIFO Register 7"
group.long (0xFFF94000+0x5C)++0x03
  line.long    0x00 "TXFR08,Transmit FIFO Register 8"
group.long (0xFFF94000+0x60)++0x03
  line.long    0x00 "TXFR09,Transmit FIFO Register 9"
group.long (0xFFF94000+0x64)++0x03
  line.long    0x00 "TXFR10,Transmit FIFO Register 10"
group.long (0xFFF94000+0x68)++0x03
  line.long    0x00 "TXFR11,Transmit FIFO Register 11"
group.long (0xFFF94000+0x6C)++0x03
  line.long    0x00 "TXFR12,Transmit FIFO Register 12"
group.long (0xFFF94000+0x70)++0x03
  line.long    0x00 "TXFR13,Transmit FIFO Register 13"
group.long (0xFFF94000+0x74)++0x03
  line.long    0x00 "TXFR14,Transmit FIFO Register 14"



TEXTLINE ""

group.long (0xFFF94000+0x7C)++0x03
  line.long    0x00 "RXFR0,DSPI Receive FIFO Register"
  hexmask.word 0x02 00.--15. 1.      "RXDATA ,Receive data"

group.long (0xFFF94000+0x80)++0x03
  line.long    0x00 "RXFR1,DSPI Receive FIFO Register"
  hexmask.word 0x02 00.--15. 1.      "RXDATA ,Receive data"

group.long (0xFFF94000+0x84)++0x03
  line.long    0x00 "RXFR2,DSPI Receive FIFO Register"
  hexmask.word 0x02 00.--15. 1.      "RXDATA ,Receive data"

group.long (0xFFF94000+0x88)++0x03
  line.long    0x00 "RXFR3,DSPI Receive FIFO Register"
  hexmask.word 0x02 00.--15. 1.      "RXDATA ,Receive data"

TEXTLINE ""

group.long (0xFFF94000+0xBC)++0x03
  line.long    0x00 "DSICR,DSPI DSI Configuration Register"
  bitfld.long  0x00 31.              "MTOE ,Multiple transfer operation enable" "0,1"
  hexmask.byte 0x00 00.--05. 1.      "   MTOCNT  ,Multiple transfer operation count"
  bitfld.long  0x00 19.              "  TXSS ,Transmit data source select" "0,1"
  bitfld.long  0x00 18.              "  TPOL  ,Trigger polarity" "0,1"
  bitfld.long  0x00 17.              "  TRRE  ,Trigger reception enable" "0,1"
  bitfld.long  0x00 16.              "  CID   ,Change in data transfer enable" "0,1"
  TEXTLINE "                "
  bitfld.long  0x00 15.              "  DCONT ,DSI continuous peripheral chip select enable" "0,1"
  bitfld.long  0x00 12.--14.         "  DSICTAS ,DSI Clock and Transfer Attributes select" "DSPI_CTAR0,DSPI_CTAR1,DSPI_CTAR2,DSPI_CTAR3,DSPI_CTAR4,DSPI_CTAR5,DSPI_CTAR6,DSPI_CTAR7"
  bitfld.long  0x00 23.              "  DPCS7-0 ,Peripheral chip select 7" "0,1"
  bitfld.long  0x00 22.              ",Peripheral chip select 6" "0,1"
  bitfld.long  0x00 21.              ",Peripheral chip select 5" "0,1"
  bitfld.long  0x00 20.              ",Peripheral chip select 4" "0,1"
  bitfld.long  0x00 19.              " ,Peripheral chip select 3" "0,1"
  bitfld.long  0x00 18.              ",Peripheral chip select 2" "0,1"
  bitfld.long  0x00 17.              ",Peripheral chip select 1" "0,1"
  bitfld.long  0x00 16.              ",Peripheral chip select 0" "0,1"
TEXTLINE ""

group.long (0xFFF94000+0xC0)++0x03
  line.long    0x00 "SDR,DSPI DSI Serialization Data Register"

group.long (0xFFF94000+0xC4)++0x03
  line.long    0x00 "ASDR,DSPI DSI Serialization Data Register"

group.long (0xFFF94000+0xC8)++0x03
  line.long    0x00 "COMPR,DSPI Transmit Comparison Register"

group.long (0xFFF94000+0xCC)++0x03
  line.long    0x00 "DDR,DSPI Deserialization Data Register"


sif (cpu()=="MPC5632M")||(cpu()=="MPC5633M")||(cpu()=="MPC5634M")||(cpu()=="SPC563M54")||(cpu()=="SPC563M60")||(cpu()=="SPC563M64")||(CPUIS("MPC5674*"))
 TEXTLINE ""

 group.long (0xFFF94000+0xD0)++0x03
   line.long    0x00 "DSICR1,DSPI DSI Configuration Register 1"
   bitfld.long  0x00 24.--28.         "TSBCNT ,Timed Serial Bus Operation Count" "res(0),res(1),res(2),res(3),res(4),5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
  bitfld.long  0x00 23.              "  DPCS7-0 ,Peripheral chip select 7" "0,1"
  bitfld.long  0x00 22.              ",Peripheral chip select 6" "0,1"
  bitfld.long  0x00 21.              ",Peripheral chip select 5" "0,1"
  bitfld.long  0x00 20.              ",Peripheral chip select 4" "0,1"
  bitfld.long  0x00 19.              " ,Peripheral chip select 3" "0,1"
  bitfld.long  0x00 18.              ",Peripheral chip select 2" "0,1"
  bitfld.long  0x00 17.              ",Peripheral chip select 1" "0,1"
  bitfld.long  0x00 16.              ",Peripheral chip select 0" "0,1"

endif
 
   
tree.end

  endif
tree "DSPI C"

group.long 0xFFF98000++0x03
  line.long    0x00 "MCR,Module Configuration Register"
  bitfld.long  0x00 31.                "MSTR      ,Master/slave mode select" "S,M"
  bitfld.long  0x00 30.              "  CONT_SCKE ,Continuous SCK enable" "0,1"
  bitfld.long  0x00 28.--29.         "  DCONF   ,DSPI configuration" "SPI,DSI,CSI,res"
  bitfld.long  0x00 27.              "  FRZ       ,Freeze" "0,1"
  TEXTLINE "                "
  bitfld.long  0x00 26.              "  MTFE      ,Modified timing format enable" "0,1"
  bitfld.long  0x00 25.              "  PCSSE     ,Peripheral chip select strobe enable" "0,1"
  bitfld.long  0x00 24.              "  ROOE      ,Receive FIFO overflow overwrite enable" "0,1"
  bitfld.long  0x00 23.              "  PCSIS7-0  ,Peripheral chip select 7 inactive state" "L,H"
  bitfld.long  0x00 22.              ",Peripheral chip select 6 inactive state" "L,H"
  bitfld.long  0x00 21.              ",Peripheral chip select 5 inactive state" "L,H"
  bitfld.long  0x00 20.              ",Peripheral chip select 4 inactive state" "L,H"
  bitfld.long  0x00 19.              " ,Peripheral chip select 3 inactive state" "L,H"
  bitfld.long  0x00 18.              ",Peripheral chip select 2 inactive state" "L,H"
  bitfld.long  0x00 17.              ",Peripheral chip select 1 inactive state" "L,H"
  bitfld.long  0x00 16.              ",Peripheral chip select 0 inactive state" "L,H"
  TEXTLINE "                "
  bitfld.long  0x00 15.              "  DOZE      ,Doze enable" "0,1"
  bitfld.long  0x00 14.              "  MDIS      ,Module disable" "0,1"
  TEXTLINE "                "
  bitfld.long  0x00 13.              "  DIS_TXF   ,Disable transmit FIFO" "0,1"
  bitfld.long  0x00 12.              "  DIS_RXF   ,Disable receive FIFO" "0,1"
  bitfld.long  0x00 11.              "  CLR_TXF   ,Clear TX FIFO" "0,1"
  bitfld.long  0x00 10.              "  CLR_RXF   ,Clear RX FIFO." "0,1"
  TEXTLINE "                "
  bitfld.long  0x00 08.--09.         "  SMPL_PT ,Sample point" "  0,  1,  2,res"
  bitfld.long  0x00 00.              "  HALT      ,Halt" "0,1"
TEXTLINE ""

group.long (0xFFF98000+0x08)++0x03
  line.long    0x00 "TCR,Transfer Count Register"
  hexmask.word 0x00 00.--15. 1. "TCNT , SPI transfer counter"
TEXTLINE ""

group.long (0xFFF98000+0x0C)++0x03
  line.long    0x00 "CTAR0,Clock and Transfer Attributes Register"
  bitfld.long  0x00 31.                "DBR        ,Double baud rate" "0,1"
  bitfld.long  0x00 27.--30.         "  FMSZ     ,Framesize" "res,res,res,  4 bits,  5 bits,  6 bits,  7 bits,  8 bits,  9 bits, 10 bits, 11 bits, 12 bits, 13 bits, 14 bits, 15 bits, 16 bits"
  TEXTLINE "                "
  bitfld.long  0x00 26.              "  CPOL    ,Clock polarity" " low,high"
  bitfld.long  0x00 25.              "  CPHA       ,Clock phase" "0,1"
  bitfld.long  0x00 24.              "  LSBFE      ,LSB first enable" "0,1"
  TEXTLINE "                "
  bitfld.long  0x00 22.--23.         "  PCSSCK    ,PCS to SCK delay prescaler" "1x,3x,5x,7x"
  bitfld.long  0x00 20.--21.         "  PASC      ,After SCK delay prescaler" "1x,3x,5x,7x"
  bitfld.long  0x00 18.--19.         "  PDT       ,Delay after transfer prescaler" "1x,3x,5x,7x"
  bitfld.long  0x00 16.--17.         "  PBR       ,Baud rate prescaler" "2x,3x,5x,7x"
  TEXTLINE "                "
  bitfld.long  0x00 12.--15.         "  CSSCK ,PCS to SCK delay scaler"     "    2x,    4x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x,65536x"
  bitfld.long  0x00 08.--11.         "  ASC   ,After SCK delay scaler"      "    2x,    4x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x,65536x"
  bitfld.long  0x00 04.--07.         "  DT    ,Delay after transfer scaler" "    2x,    4x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x,65536x"
  bitfld.long  0x00 00.--03.         "  BR    ,Baud rate scaler"            "    2x,    4x,    6x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x"
TEXTLINE ""

group.long (0xFFF98000+0x10)++0x03
  line.long    0x00 "CTAR1,Clock and Transfer Attributes Register"
  bitfld.long  0x00 31.                "DBR        ,Double baud rate" "0,1"
  bitfld.long  0x00 27.--30.         "  FMSZ     ,Framesize" "res,res,res,  4 bits,  5 bits,  6 bits,  7 bits,  8 bits,  9 bits, 10 bits, 11 bits, 12 bits, 13 bits, 14 bits, 15 bits, 16 bits"
  TEXTLINE "                "
  bitfld.long  0x00 26.              "  CPOL    ,Clock polarity" " low,high"
  bitfld.long  0x00 25.              "  CPHA       ,Clock phase" "0,1"
  bitfld.long  0x00 24.              "  LSBFE      ,LSB first enable" "0,1"
  TEXTLINE "                "
  bitfld.long  0x00 22.--23.         "  PCSSCK    ,PCS to SCK delay prescaler" "1x,3x,5x,7x"
  bitfld.long  0x00 20.--21.         "  PASC      ,After SCK delay prescaler" "1x,3x,5x,7x"
  bitfld.long  0x00 18.--19.         "  PDT       ,Delay after transfer prescaler" "1x,3x,5x,7x"
  bitfld.long  0x00 16.--17.         "  PBR       ,Baud rate prescaler" "2x,3x,5x,7x"
  TEXTLINE "                "
  bitfld.long  0x00 12.--15.         "  CSSCK ,PCS to SCK delay scaler"     "    2x,    4x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x,65536x"
  bitfld.long  0x00 08.--11.         "  ASC   ,After SCK delay scaler"      "    2x,    4x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x,65536x"
  bitfld.long  0x00 04.--07.         "  DT    ,Delay after transfer scaler" "    2x,    4x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x,65536x"
  bitfld.long  0x00 00.--03.         "  BR    ,Baud rate scaler"            "    2x,    4x,    6x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x"
TEXTLINE ""

group.long (0xFFF98000+0x14)++0x03
  line.long    0x00 "CTAR2,Clock and Transfer Attributes Register"
  bitfld.long  0x00 31.                "DBR        ,Double baud rate" "0,1"
  bitfld.long  0x00 27.--30.         "  FMSZ     ,Framesize" "res,res,res,  4 bits,  5 bits,  6 bits,  7 bits,  8 bits,  9 bits, 10 bits, 11 bits, 12 bits, 13 bits, 14 bits, 15 bits, 16 bits"
  TEXTLINE "                "
  bitfld.long  0x00 26.              "  CPOL    ,Clock polarity" " low,high"
  bitfld.long  0x00 25.              "  CPHA       ,Clock phase" "0,1"
  bitfld.long  0x00 24.              "  LSBFE      ,LSB first enable" "0,1"
  TEXTLINE "                "
  bitfld.long  0x00 22.--23.         "  PCSSCK    ,PCS to SCK delay prescaler" "1x,3x,5x,7x"
  bitfld.long  0x00 20.--21.         "  PASC      ,After SCK delay prescaler" "1x,3x,5x,7x"
  bitfld.long  0x00 18.--19.         "  PDT       ,Delay after transfer prescaler" "1x,3x,5x,7x"
  bitfld.long  0x00 16.--17.         "  PBR       ,Baud rate prescaler" "2x,3x,5x,7x"
  TEXTLINE "                "
  bitfld.long  0x00 12.--15.         "  CSSCK ,PCS to SCK delay scaler"     "    2x,    4x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x,65536x"
  bitfld.long  0x00 08.--11.         "  ASC   ,After SCK delay scaler"      "    2x,    4x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x,65536x"
  bitfld.long  0x00 04.--07.         "  DT    ,Delay after transfer scaler" "    2x,    4x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x,65536x"
  bitfld.long  0x00 00.--03.         "  BR    ,Baud rate scaler"            "    2x,    4x,    6x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x"
TEXTLINE ""

group.long (0xFFF98000+0x18)++0x03
  line.long    0x00 "CTAR3,Clock and Transfer Attributes Register"
  bitfld.long  0x00 31.                "DBR        ,Double baud rate" "0,1"
  bitfld.long  0x00 27.--30.         "  FMSZ     ,Framesize" "res,res,res,  4 bits,  5 bits,  6 bits,  7 bits,  8 bits,  9 bits, 10 bits, 11 bits, 12 bits, 13 bits, 14 bits, 15 bits, 16 bits"
  TEXTLINE "                "
  bitfld.long  0x00 26.              "  CPOL    ,Clock polarity" " low,high"
  bitfld.long  0x00 25.              "  CPHA       ,Clock phase" "0,1"
  bitfld.long  0x00 24.              "  LSBFE      ,LSB first enable" "0,1"
  TEXTLINE "                "
  bitfld.long  0x00 22.--23.         "  PCSSCK    ,PCS to SCK delay prescaler" "1x,3x,5x,7x"
  bitfld.long  0x00 20.--21.         "  PASC      ,After SCK delay prescaler" "1x,3x,5x,7x"
  bitfld.long  0x00 18.--19.         "  PDT       ,Delay after transfer prescaler" "1x,3x,5x,7x"
  bitfld.long  0x00 16.--17.         "  PBR       ,Baud rate prescaler" "2x,3x,5x,7x"
  TEXTLINE "                "
  bitfld.long  0x00 12.--15.         "  CSSCK ,PCS to SCK delay scaler"     "    2x,    4x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x,65536x"
  bitfld.long  0x00 08.--11.         "  ASC   ,After SCK delay scaler"      "    2x,    4x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x,65536x"
  bitfld.long  0x00 04.--07.         "  DT    ,Delay after transfer scaler" "    2x,    4x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x,65536x"
  bitfld.long  0x00 00.--03.         "  BR    ,Baud rate scaler"            "    2x,    4x,    6x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x"
TEXTLINE ""

group.long (0xFFF98000+0x1C)++0x03
  line.long    0x00 "CTAR4,Clock and Transfer Attributes Register"
  bitfld.long  0x00 31.                "DBR        ,Double baud rate" "0,1"
  bitfld.long  0x00 27.--30.         "  FMSZ     ,Framesize" "res,res,res,  4 bits,  5 bits,  6 bits,  7 bits,  8 bits,  9 bits, 10 bits, 11 bits, 12 bits, 13 bits, 14 bits, 15 bits, 16 bits"
  TEXTLINE "                "
  bitfld.long  0x00 26.              "  CPOL    ,Clock polarity" " low,high"
  bitfld.long  0x00 25.              "  CPHA       ,Clock phase" "0,1"
  bitfld.long  0x00 24.              "  LSBFE      ,LSB first enable" "0,1"
  TEXTLINE "                "
  bitfld.long  0x00 22.--23.         "  PCSSCK    ,PCS to SCK delay prescaler" "1x,3x,5x,7x"
  bitfld.long  0x00 20.--21.         "  PASC      ,After SCK delay prescaler" "1x,3x,5x,7x"
  bitfld.long  0x00 18.--19.         "  PDT       ,Delay after transfer prescaler" "1x,3x,5x,7x"
  bitfld.long  0x00 16.--17.         "  PBR       ,Baud rate prescaler" "2x,3x,5x,7x"
  TEXTLINE "                "
  bitfld.long  0x00 12.--15.         "  CSSCK ,PCS to SCK delay scaler"     "    2x,    4x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x,65536x"
  bitfld.long  0x00 08.--11.         "  ASC   ,After SCK delay scaler"      "    2x,    4x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x,65536x"
  bitfld.long  0x00 04.--07.         "  DT    ,Delay after transfer scaler" "    2x,    4x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x,65536x"
  bitfld.long  0x00 00.--03.         "  BR    ,Baud rate scaler"            "    2x,    4x,    6x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x"
TEXTLINE ""

group.long (0xFFF98000+0x20)++0x03
  line.long    0x00 "CTAR5,Clock and Transfer Attributes Register"
  bitfld.long  0x00 31.                "DBR        ,Double baud rate" "0,1"
  bitfld.long  0x00 27.--30.         "  FMSZ     ,Framesize" "res,res,res,  4 bits,  5 bits,  6 bits,  7 bits,  8 bits,  9 bits, 10 bits, 11 bits, 12 bits, 13 bits, 14 bits, 15 bits, 16 bits"
  TEXTLINE "                "
  bitfld.long  0x00 26.              "  CPOL    ,Clock polarity" " low,high"
  bitfld.long  0x00 25.              "  CPHA       ,Clock phase" "0,1"
  bitfld.long  0x00 24.              "  LSBFE      ,LSB first enable" "0,1"
  TEXTLINE "                "
  bitfld.long  0x00 22.--23.         "  PCSSCK    ,PCS to SCK delay prescaler" "1x,3x,5x,7x"
  bitfld.long  0x00 20.--21.         "  PASC      ,After SCK delay prescaler" "1x,3x,5x,7x"
  bitfld.long  0x00 18.--19.         "  PDT       ,Delay after transfer prescaler" "1x,3x,5x,7x"
  bitfld.long  0x00 16.--17.         "  PBR       ,Baud rate prescaler" "2x,3x,5x,7x"
  TEXTLINE "                "
  bitfld.long  0x00 12.--15.         "  CSSCK ,PCS to SCK delay scaler"     "    2x,    4x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x,65536x"
  bitfld.long  0x00 08.--11.         "  ASC   ,After SCK delay scaler"      "    2x,    4x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x,65536x"
  bitfld.long  0x00 04.--07.         "  DT    ,Delay after transfer scaler" "    2x,    4x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x,65536x"
  bitfld.long  0x00 00.--03.         "  BR    ,Baud rate scaler"            "    2x,    4x,    6x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x"
TEXTLINE ""

group.long (0xFFF98000+0x24)++0x03
  line.long    0x00 "CTAR6,Clock and Transfer Attributes Register"
  bitfld.long  0x00 31.                "DBR        ,Double baud rate" "0,1"
  bitfld.long  0x00 27.--30.         "  FMSZ     ,Framesize" "res,res,res,  4 bits,  5 bits,  6 bits,  7 bits,  8 bits,  9 bits, 10 bits, 11 bits, 12 bits, 13 bits, 14 bits, 15 bits, 16 bits"
  TEXTLINE "                "
  bitfld.long  0x00 26.              "  CPOL    ,Clock polarity" " low,high"
  bitfld.long  0x00 25.              "  CPHA       ,Clock phase" "0,1"
  bitfld.long  0x00 24.              "  LSBFE      ,LSB first enable" "0,1"
  TEXTLINE "                "
  bitfld.long  0x00 22.--23.         "  PCSSCK    ,PCS to SCK delay prescaler" "1x,3x,5x,7x"
  bitfld.long  0x00 20.--21.         "  PASC      ,After SCK delay prescaler" "1x,3x,5x,7x"
  bitfld.long  0x00 18.--19.         "  PDT       ,Delay after transfer prescaler" "1x,3x,5x,7x"
  bitfld.long  0x00 16.--17.         "  PBR       ,Baud rate prescaler" "2x,3x,5x,7x"
  TEXTLINE "                "
  bitfld.long  0x00 12.--15.         "  CSSCK ,PCS to SCK delay scaler"     "    2x,    4x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x,65536x"
  bitfld.long  0x00 08.--11.         "  ASC   ,After SCK delay scaler"      "    2x,    4x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x,65536x"
  bitfld.long  0x00 04.--07.         "  DT    ,Delay after transfer scaler" "    2x,    4x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x,65536x"
  bitfld.long  0x00 00.--03.         "  BR    ,Baud rate scaler"            "    2x,    4x,    6x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x"
TEXTLINE ""

group.long (0xFFF98000+0x28)++0x03
  line.long    0x00 "CTAR7,Clock and Transfer Attributes Register"
  bitfld.long  0x00 31.                "DBR        ,Double baud rate" "0,1"
  bitfld.long  0x00 27.--30.         "  FMSZ     ,Framesize" "res,res,res,  4 bits,  5 bits,  6 bits,  7 bits,  8 bits,  9 bits, 10 bits, 11 bits, 12 bits, 13 bits, 14 bits, 15 bits, 16 bits"
  TEXTLINE "                "
  bitfld.long  0x00 26.              "  CPOL    ,Clock polarity" " low,high"
  bitfld.long  0x00 25.              "  CPHA       ,Clock phase" "0,1"
  bitfld.long  0x00 24.              "  LSBFE      ,LSB first enable" "0,1"
  TEXTLINE "                "
  bitfld.long  0x00 22.--23.         "  PCSSCK    ,PCS to SCK delay prescaler" "1x,3x,5x,7x"
  bitfld.long  0x00 20.--21.         "  PASC      ,After SCK delay prescaler" "1x,3x,5x,7x"
  bitfld.long  0x00 18.--19.         "  PDT       ,Delay after transfer prescaler" "1x,3x,5x,7x"
  bitfld.long  0x00 16.--17.         "  PBR       ,Baud rate prescaler" "2x,3x,5x,7x"
  TEXTLINE "                "
  bitfld.long  0x00 12.--15.         "  CSSCK ,PCS to SCK delay scaler"     "    2x,    4x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x,65536x"
  bitfld.long  0x00 08.--11.         "  ASC   ,After SCK delay scaler"      "    2x,    4x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x,65536x"
  bitfld.long  0x00 04.--07.         "  DT    ,Delay after transfer scaler" "    2x,    4x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x,65536x"
  bitfld.long  0x00 00.--03.         "  BR    ,Baud rate scaler"            "    2x,    4x,    6x,    8x,   16x,   32x,   64x,  128x,  256x,  512x, 1024x, 2048x, 4096x, 8192x,16384x,32768x"
TEXTLINE ""


group.long (0xFFF98000+0x2C)++0x03
  line.long    0x00 "SR,DSPI Status Register"
  eventfld.long  0x00 31.                "TCF       ,Transfer complete flag" "0,1"
  eventfld.long  0x00 30.              "  TXRXS     ,TX & RX status" "0,1"
  eventfld.long  0x00 28.              "  EOQF      ,End-of-queue flag" "0,1"
  TEXTLINE "                "
  eventfld.long  0x00 27.              "  TFUF      ,Transmit FIFO underflow flag" "0,1"
  eventfld.long  0x00 25.              "  TFFF      ,Transmit FIFO fill flag" "0,1"
  eventfld.long  0x00 19.              "  RFOF      ,Receive FIFO overflow flag" "0,1"
  eventfld.long  0x00 17.              "  RFDF      ,Receive FIFO drain flag" "0,1"
  TEXTLINE "                "
  bitfld.long  0x00 12.--15.           "  TXCTR    ,TX FIFO Counter" " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long  0x00 08.--11.           "  TXNXTPTR ,Transmit next pointer." " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long  0x00 04.--07.           "  RXCTR    ,RX FIFO Counter" " 0, 1, 2, 3, 4, 5, 6, 7, 8, 9,10,11,12,13,14,15"
  bitfld.long  0x00 00.--03.           "  POPNXTPTR ,Pop next pointer" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
TEXTLINE ""

group.long (0xFFF98000+0x30)++0x03
  line.long    0x00 "RSER,DSPI DMA/Interrupt Request Select and Enable Register"
  bitfld.long  0x00 31.                "TCF_RE    ,Transfer complete request enable" "0,1"
  bitfld.long  0x00 28.              "  EOQF_RE   ,End-of-queue request enable" "0,1"
  bitfld.long  0x00 27.              "  TFUF_RE   ,Transmit FIFO underflow request enable" "0,1"
  bitfld.long  0x00 25.              "  TFFF_RE   ,Transmit FIFO fill request enable" "0,1"
  bitfld.long  0x00 24.              "  TFFF_DIRS ,Transmit FIFO fill request select" "INT,DMA"
  TEXTLINE "                "
  bitfld.long  0x00 19.              "  RFOF_RE   ,Receive FIFO overflow request enable" "0,1"
  bitfld.long  0x00 17.              "  RFDF_RE   ,Receive FIFO drain request enable" "0,1"
  bitfld.long  0x00 16.              "  RFDF_DIRS ,Receive FIFO drain request select" "INT,DMA"
TEXTLINE ""

group.long (0xFFF98000+0x34)++0x03
  line.long    0x00 "PUSHR,DSPI PUSH TX FIFO Register"
  bitfld.long  0x00 31.              "CONT ,Continuous peripheral chip select enable" "0,1"
